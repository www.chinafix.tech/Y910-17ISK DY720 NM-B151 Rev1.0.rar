# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP_TX3_OUT_DP: length 111.7
  TOP w0.097: C472.1 18.59,157.51 18.89,157.81 19.2,157.81 v3(19.27,157.74)
  IN05 w0.102: v1(65.12,88.03) 65.18,87.97 65.18,87.72 65.1,87.64 64.18,87.64 62.98,86.44 60.78,86.44 58.77,88.45 58.77,92.15 58.26,92.66 56.87,92.66 56.48,93.04 55.34,93.04 54.33,94.06 51.91,94.06 45.94,100.03 40.51,100.03 20.32,120.22 19.12,120.22 12.75,126.6 12.75,155.61 15.22,158.08 18.74,158.08 18.86,157.95 18.86,157.68 18.99,157.56 19.16,157.56 19.27,157.67 v3(19.27,157.74)
  BOTTOM w0.097: U2015.26 66.35,87.87 66.24,87.76 65.39,87.76 v1(65.12,88.03)
DPA_AUX_DN_C: length 4.1
  BOTTOM w0.097: C460.2 74.97,86.32 74.97,86.95 75.16,87.14 75.16,89.23 75.23,89.29 U2016.6
DPA_AUX_DP_C: length 4.1
  BOTTOM w0.097: C461.2 74.7,86.32 74.7,87.06 74.89,87.25 74.89,89.23 74.83,89.29 U2016.7
DPA_DDC_AUX_SEL: length 9.1
  BOTTOM w0.097: R387.1 73.83,96.04 73.38,95.58 v2(73.38,95.33) 73.38,94.82 74.65,93.55 74.65,92.28 74.22,91.85 74.22,91.44 74.39,91.27 74.39,90.92 U2016.10 ; R387.1 74.72,95.71 Q6.2 ; R387.1 74.56,96.21 Q6.3
DPA_DDC_EN: length 11.4
  BOTTOM w0.097: Q7.5 Q7.2 76.98,98 C599.2 77.11,99.06 77.44,99.39 78.2,99.39 78.58,99.01 78.58,96.09 v2(78.07,95.58) 77.69,95.2 76.67,95.2 ; 76.67,95.2 76.68,95.2 R386.1 ; 76.67,95.2 Q6.6
DPA_REP_ENI2C: length 2.6
  BOTTOM w0.097: U2015.21 67.42,84.5 R389.2 R2144.1
DPA_REP_EQ0: length 1
  BOTTOM w0.097: R394.2 67.42,94.86 U2015.39
DPA_REP_EQ1: length 1
  BOTTOM w0.097: U2015.40 67.92,95 R397.2
DPA_REP_EQ2: length 1.1
  BOTTOM w0.097: U2015.41 68.42,94.44 68.93,94.95 R398.2
DPA_REP_EQ3: length 1.5
  BOTTOM w0.097: R399.2 69.82,94.82 69.57,94.57 69.28,94.57 U2015.42
DPA_REP_FG0: length 1.5
  BOTTOM w0.097: R392.2 65.23,93.37 U2015.37
DPA_REP_FG1: length 1.5
  BOTTOM w0.097: R393.2 66.26,94.06 66.45,93.87 U2015.38
DPA_REP_I2C_DONE: length 1
  BOTTOM w0.097: TP96.1 65.69,85.87 U2015.22
DPA_REP_SCL: length 2.8
  TOP w0.097: R2242.2 v1(69.44,84.79)
  BOTTOM w0.097: R2242.2 v1(69.44,84.79) 68.93,84.79 68.42,85.3 U2015.19
DPA_REP_SDA: length 3.3
  TOP w0.097: R2243.2 v1(70.45,84.79)
  BOTTOM w0.097: U2015.18 68.92,85.44 69.06,85.3 69.95,85.3 v1(70.45,84.79) R2243.2
DPA_REP_SW0: length 2.7
  BOTTOM w0.097: U2015.2 70.14,93.37 71.6,94.82 R390.2
DPA_REP_SW1: length 1.9
  BOTTOM w0.097: R391.2 70.71,94.44 70.14,93.87 U2015.1
DPA_TX0_DN_C: length 1.8
  BOTTOM w0.097: U2015.5 69.98,91.87 70.09,91.98 70.41,91.98 70.76,92.33 70.96,92.33 C451.2
DPA_TX0_DP_C: length 1.8
  BOTTOM w0.097: C448.2 70.96,92.61 70.64,92.61 70.29,92.26 70.09,92.26 69.98,92.37 U2015.4
DPA_TX1_DN_C: length 1.7
  BOTTOM w0.097: C453.2 70.96,90.56 70.6,90.56 70.52,90.48 70.09,90.48 69.98,90.37 U2015.8
DPA_TX1_DP_C: length 1.7
  BOTTOM w0.097: C452.2 70.96,90.83 70.48,90.83 70.41,90.76 70.09,90.76 69.98,90.87 U2015.7
DPA_TX2_DN_C: length 1.8
  BOTTOM w0.097: U2015.11 69.98,88.87 70.09,88.98 70.49,88.98 70.7,88.77 70.97,88.77 C455.2
DPA_TX2_DP_C: length 1.8
  BOTTOM w0.097: U2015.10 69.98,89.37 70.09,89.26 70.6,89.26 70.82,89.04 70.95,89.04 C454.2
DPA_TX3_DN_C: length 1.9
  BOTTOM w0.097: C457.2 70.96,87 70.73,87 70.25,87.48 70.12,87.48 70.01,87.37 U2015.14
DPA_TX3_DP_C: length 1.9
  BOTTOM w0.097: U2015.13 70.01,87.87 70.13,87.76 70.36,87.76 70.84,87.28 70.96,87.28 C456.2
DPE_AUX_DN_C: length 2.9
  BOTTOM w0.097: C530.2 75.46,77.67 75.46,77.43 74.64,76.61 74.64,76.34 74.53,76.23 U2013.29
DPE_AUX_DP_C: length 2.9
  BOTTOM w0.097: C531.2 75.74,77.68 75.74,77.32 74.92,76.5 74.92,76.34 75.03,76.23 U2013.30
DPE_CAD_SNK: length 2
  BOTTOM w0.097: U2013.10 73.53,67.87 73.38,67.71 R2104.1
DPE_CAD_SRC: length 1.2
  BOTTOM w0.097: TP186.1 74.53,67.4 U2013.8
DPE_CFG0: length 2.8
  BOTTOM w0.097: R492.2 R541.2 76.03,66.72 U2013.5
DPE_CFG1: length 3.5
  TOP w0.097: v1(77.82,73.49) 78.28,73.03 R422.2 R454.2
  BOTTOM w0.097: v1(77.82,73.49) 77.97,73.34 U2013.40
DPE_HPD_SNK: length 2.1
  BOTTOM w0.097: R420.1 72.49,67.24 73.03,67.78 U2013.11
DPE_PD: length 2.2
  BOTTOM w0.097: U2013.26 73.03,76.12 v2(72.36,76.79) 71.85,76.79 TP97.1
DPE_PEQ: length 3.3
  TOP w0.097: R518.2 v1(76.93,67.52)
  BOTTOM w0.097: R436.2 77.74,66.7 v1(76.93,67.52) 76.53,67.92 U2013.4
DPE_RST_N: length 3.9
  TOP w0.097: R2280.1 C2687.2 77.57,76.91 v1(77.95,76.53)
  BOTTOM w0.097: U2013.35 77.53,76.24 77.82,76.53 v1(77.95,76.53) 77.95,77.04 v2(78.2,77.3)
DPE_TX0_DN_C: length 2.3
  BOTTOM w0.097: C479.2 80.2,74.46 79.97,74.46 79.85,74.34 79.85,74.17 79.63,73.95 79.24,73.95 79.13,73.84 U2013.39
DPE_TX0_DP_C: length 2.3
  BOTTOM w0.097: U2013.38 79.13,74.34 79.24,74.23 79.52,74.23 79.58,74.29 79.58,74.46 79.85,74.73 80.26,74.73 C480.2
DPE_TX1_DN_C: length 2
  BOTTOM w0.097: C481.2 80.3,72.58 80.29,72.58 80.24,72.63 79.76,72.63 79.59,72.46 79.22,72.46 79.1,72.34 U2013.42
DPE_TX1_DP_C: length 2
  BOTTOM w0.097: U2013.41 79.1,72.84 79.2,72.73 79.47,72.73 79.65,72.91 80.21,72.91 C477.2
DPE_TX2_DN_C: length 2
  BOTTOM w0.097: U2013.45 79.22,70.84 79.34,70.96 79.58,70.96 79.68,70.86 80.24,70.86 C484.2
DPE_TX2_DP_C: length 2
  BOTTOM w0.097: U2013.44 79.12,71.34 79.22,71.23 79.69,71.23 79.8,71.13 80.22,71.13 C478.2
DPE_TX3_DN_C: length 2.1
  BOTTOM w0.097: C482.2 80.21,69.12 79.81,69.12 79.48,69.44 79.32,69.44 79.22,69.34 U2013.48
DPE_TX3_DP_C: length 2.1
  BOTTOM w0.097: C483.2 80.25,69.39 79.92,69.39 79.59,69.72 79.34,69.72 79.22,69.84 U2013.47
DPF_AUX_DN_C: length 2.8
  BOTTOM w0.097: C582.2 65.37,67.58 65.68,67.27 65.68,67.13 64.99,66.44 64.99,66.18 64.88,66.07 U2014.29
DPF_AUX_DP_C: length 2.8
  BOTTOM w0.097: C583.2 66.26,67.52 65.96,67.21 65.96,67.02 65.27,66.33 65.27,66.18 65.38,66.07 U2014.30
DPF_CAD_SNK: length 2.9
  BOTTOM w0.097: U2014.10 63.88,57.89 63.72,57.74 63.47,57.74 63.09,57.36 62.83,57.36 62.58,57.1 R2105.1
DPF_CAD_SRC: length 1.6
  BOTTOM w0.097: U2014.8 64.88,57.75 TP187.1
DPF_CFG0: length 3.1
  BOTTOM w0.097: R595.2 R590.2 65.88,57.1 66.38,57.6 U2014.5
DPF_CFG1: length 4.4
  TOP w0.097: R425.2 68.63,62.44 v2(69.44,62.44) 69.44,62.94 68.85,63.53 R487.2 68.17,63.58 v1(68.04,63.45)
  BOTTOM w0.254: U2014.40 68.32,63.18 v1(68.04,63.45)
DPF_HPD_SNK: length 4.7
  BOTTOM w0.097: U2014.11 63.38,58.03 63.09,57.74 61.06,57.74 v2(60.8,57.48) 60.8,57.31 R423.1
DPF_PD: length 3.2
  BOTTOM w0.097: TP185.1 v2(62.07,66.75) 62.58,66.25 63.09,66.25 63.38,65.96 U2014.26
DPF_PEQ: length 3.2
  BOTTOM w0.097: U2014.4 66.88,57.2 R437.2 R591.2
DPF_RST_N: length 3.2
  BOTTOM w0.097: C2688.2 R2281.1 68.04,66.75 v2(67.91,66.63) 67.88,66.59 U2014.35
DPF_TX0_DN_C: length 2.2
  BOTTOM w0.097: C487.2 70.58,64.27 70.37,64.27 69.89,63.79 69.57,63.79 69.46,63.68 U2014.39
DPF_TX0_DP_C: length 2.2
  BOTTOM w0.097: U2014.38 69.46,64.18 69.57,64.07 69.78,64.07 70.25,64.54 70.58,64.54 C488.2
DPF_TX1_DN_C: length 2
  BOTTOM w0.097: C489.2 70.6,62.35 69.72,62.35 69.56,62.18 U2014.42
DPF_TX1_DP_C: length 2
  BOTTOM w0.097: U2014.41 69.55,62.68 69.61,62.62 70.62,62.62 70.89,62.88 C485.2
DPF_TX2_DN_C: length 2
  BOTTOM w0.097: C492.2 70.58,60.59 70.11,60.59 69.91,60.79 69.62,60.79 69.51,60.68 U2014.45
DPF_TX2_DP_C: length 2
  BOTTOM w0.097: U2014.44 69.51,61.18 69.62,61.07 70.02,61.07 70.23,60.86 70.58,60.86 C486.2
DPF_TX3_DN_C: length 2.2
  BOTTOM w0.097: C490.2 70.58,58.81 70.23,58.81 69.75,59.29 69.62,59.29 69.51,59.18 U2014.48
DPF_TX3_DP_C: length 2.2
  BOTTOM w0.097: U2014.47 69.11,59.68 69.51,59.68 69.62,59.57 69.86,59.57 70.35,59.08 70.58,59.08 C491.2
DPSNK_RBIAS: length 1.1
  TOP w0.356: R2029.2 54.48,83.13 v2(54.47,83.13)
  BOTTOM w0.178: v2(54.47,83.13) 54.8,83.45 U2005.Y18
DQMA0: length 22.6
  IN05 w0.14: v3(260.69,145.67) 260.37,145.98 260.37,148.92 260.51,149.07 260.51,154.78 260.11,155.18 260.11,166.35 v3(260.51,166.75)
  BOTTOM w0.152: U48.P2 v3(260.51,166.75) ; G2.U47 v3(260.69,145.67)
DQMA1: length 26.1
  IN05 w0.14: v3(251.71,166.75) 252.11,166.35 254.4,166.35 258.29,162.46 258.29,156.08 257.78,155.57 257.78,150.3 258.5,149.57 258.5,147.53 v3(258.78,147.26)
  BOTTOM w0.102: G2.Y48 258.29,146.33 258.62,146.66 258.62,147.1 v3(258.78,147.26)
  BOTTOM w0.152: v3(251.71,166.75) 252.11,167.15 U48.P13
DQMA2: length 38.5
  IN05 w0.14: v3(252.51,175.55) 252.11,175.95 252.11,176.52 251.88,176.75 250.33,176.75 249.4,175.81 249.4,174.32 247.99,172.91 247.99,162.65 252.6,158.03 252.6,148.59 253.51,147.69 253.51,146.09 v3(253.09,145.67)
  BOTTOM w0.152: v3(252.51,175.55) U48.D13 ; G2.AG47 253.39,145.37 v3(253.09,145.67)
DQMA3: length 42.5
  IN05 w0.14: v3(261.31,174.75) U48.D2 260.91,175.75 260.71,175.95 259.43,175.95 259.31,175.83 259.31,173.76 259.09,173.55 257.88,173.55 257.39,173.06 257.39,172.46 254.48,169.55 250.7,169.55 250.51,169.35 250.51,163.6 254.93,159.17 254.93,150.52 256.59,148.87 v3(256.59,147.17)
  BOTTOM w0.152: G2.AC48 256.19,146.29 256.52,146.62 256.52,147.1 v3(256.59,147.17) ; U48.D2 v3(261.31,174.75)
DQMA4: length 25.8
  IN05 w0.14: v3(233.68,166.75) 233.28,166.35 233.28,154.97 240.07,148.17 242.89,148.17 v3(243.19,148.47)
  BOTTOM w0.152: v3(233.68,166.75) 234.07,167.15 U2022.D2 ; G2.BB51 v3(243.19,148.47)
DQMA5: length 27.8
  IN05 w0.14: v3(243.28,166.75) 242.88,166.35 240.52,166.35 239.87,165.71 239.87,152.96 241.07,151.76 v3(241.07,151.35)
  BOTTOM w0.102: 241.39,150.82 241.51,150.7 245.4,150.7 246.28,149.83 246.28,148.56 246.04,148.32 246.04,147.82 G2.AV50
  BOTTOM w0.152: 241.39,150.82 241.07,151.14 v3(241.07,151.35) ; U2022.D13 v3(243.28,166.75)
DQMA6: length 35.4
  IN05 w0.14: v3(243.28,175.55) 243.68,175.95 244.66,175.95 246.56,174.04 246.56,161.42 251.01,156.98 251.01,149.21 249.97,148.18 249.97,147.48 v3(250.29,147.17)
  BOTTOM w0.102: G2.AM48 249.89,146.29 250.24,146.64 250.24,147.12 v3(250.29,147.17)
  BOTTOM w0.152: U2022.P13 v3(243.28,175.55)
DQMA7: length 38.7
  IN05 w0.14: v3(233.68,174.75) 234.08,174.35 234.08,172.54 234.67,171.95 235.51,171.95 240.31,167.15 243.46,167.15 243.8,166.81 243.8,163.94 242.08,162.23 242.08,153.97 246.03,150.02 v3(247,150.02)
  BOTTOM w0.102: G2.AR49 247.43,147.12 247.43,149.06 247.37,149.13 247.37,149.65 v3(247,150.02)
  BOTTOM w0.152: v3(233.68,174.75) U2022.P2
DQMB0: length 25.8
  IN05 w0.14: v3(289.7,146.54) 289.3,146.14 289.3,145.52 288.93,145.14 286.03,145.14 276.19,135.31 274.91,135.31 v3(274.47,134.87)
  BOTTOM w0.102: G2.C32 270.52,134.54 270.96,134.54 271.27,134.23 273.83,134.23 273.91,134.31
  BOTTOM w0.152: U2023.P2 v3(289.7,146.54) ; v3(274.47,134.87) 273.91,134.31
DQMB1: length 31.4
  IN05 w0.14: v3(289.7,156.14) 289.3,155.74 289.3,153.41 273.42,137.53 271.68,137.53 270.85,136.7 269.96,136.7 269.22,135.97 v3(269.09,135.97)
  BOTTOM w0.152: U2023.P13 v3(289.7,156.14) ; v3(269.09,135.97) 268.79,135.67 G2.E33
DQMB2: length 39.6
  IN05 w0.14: v3(298.5,156.14) 298.1,156.54 298.1,157.31 295.99,159.42 286.01,159.42 271.83,145.24 271.83,144.31 270.49,142.97 v3(269.09,142.97)
  BOTTOM w0.152: G2.E44 v3(269.09,142.97) ; U2023.D13 v3(298.5,156.14)
DQMB3: length 52
  IN05 w0.14: v3(267.57,140.7) 268.34,141.48 270.14,141.48 282.02,153.36 282.02,154.09 286.67,158.74 295.7,158.74 297.3,157.14 297.3,153.49 297.7,153.09 297.7,152 298.9,150.8 298.9,149.9 298.9,147.14 298.69,146.92 298.09,146.92 v3(297.7,146.54)
  BOTTOM w0.102: v3(267.57,140.7) 267.53,140.7 267.4,140.57 267.4,139.78 G2.G39
  BOTTOM w0.152: U2023.D2 v3(297.7,146.54)
DQMB4: length 24.2
  IN05 w0.14: v3(261.79,149.88) 262.78,150.87 262.78,151.77 269.13,158.12 269.13,166.35 v3(269.53,166.75)
  BOTTOM w0.102: v3(261.79,149.88) 261.88,149.88 262.21,149.55 262.21,149.09 262.15,149.03 262.15,147.1 G2.P49
  BOTTOM w0.152: U55.D2 v3(269.53,166.75)
DQMB5: length 29.4
  IN05 w0.14: v3(264.99,147.17) 264.68,147.47 264.68,148.27 265.4,148.99 266.24,148.99 267.51,150.26 268.07,150.26 273.9,156.09 273.9,156.92 275.19,158.21 275.19,165.99 275.55,166.35 277.93,166.35 v3(278.33,166.75)
  BOTTOM w0.102: G2.L48 264.59,146.31 264.92,146.64 264.92,147.1 v3(264.99,147.17)
  BOTTOM w0.152: U55.D13 v3(278.33,166.75)
DQMB6: length 38.7
  IN05 w0.14: v3(278.33,175.55) 278.73,175.15 279.45,175.15 281.17,173.42 281.17,163.99 278.74,161.56 278.74,155.66 273.44,150.36 269.71,150.36 269.08,149.72 269.08,149.1 268.59,148.62 268.59,147.62 269.05,147.17 v3(269.19,147.17)
  BOTTOM w0.152: U55.P13 v3(278.33,175.55) ; G2.D50 v3(269.19,147.17)
DQMB7: length 32.9
  IN05 w0.14: v3(268.01,151.87) 268.01,153.3 272.68,157.97 272.68,170.9 270.84,172.75 269.32,172.75 269.13,172.94 269.13,174.35 v3(268.73,174.75)
  BOTTOM w0.102: G2.H50 267.04,147.82 267.04,148.37 267.65,148.99 267.65,150.16 268.01,150.52 v3(268.01,151.87)
  BOTTOM w0.152: U55.P2 v3(268.73,174.75)
DQMC0: length 21.1
  IN05 w0.14: v3(289.83,111.49) 289.42,111.09 286.08,111.09 281.99,115.17 274.19,115.17 273.53,115.84 272.05,115.84 v3(271.89,115.67)
  BOTTOM w0.152: U2025.P2 290.22,111.88 v3(289.83,111.49) ; v3(271.89,115.67) G2.A5
DQMC1: length 23.2
  IN03 w0.14: v3(270.44,117.7) 270.6,117.53 274.36,117.53 274.97,118.14 288.36,118.14 288.63,118.41 288.63,120.47 288.84,120.69 289.43,120.69 v3(289.83,121.08)
  BOTTOM w0.152: U2025.P13 290.23,120.68 v3(289.83,121.09) ; v3(270.44,117.7) 270.44,117.82 G2.C8
DQMC2: length 39.9
  IN05 w0.14: v3(298.62,120.29) 299.02,120.68 299.62,120.68 299.83,120.89 299.83,122.41 296.66,125.59 286.03,125.59 285.35,124.9 266.15,124.9 v3(265.69,125.37)
  BOTTOM w0.152: G2.J18 v3(265.69,125.37) ; v3(298.62,120.29) 298.23,120.68 U2025.D13
DQMC3: length 42
  IN05 w0.076: 270.62,120.93 270.49,120.8 268.15,120.8 v3(267.79,121.17)
  IN05 w0.14: v3(297.82,112.29) 298.22,112.69 298.22,113.43 298.39,113.6 298.39,115.39 295.82,117.95 295.82,122.06 294.38,123.5 286.88,123.5 285.51,122.13 271.83,122.13 270.62,120.93
  BOTTOM w0.152: G2.F12 268.09,120.87 v3(267.79,121.17) ; v3(297.82,112.29) U2025.D2
DQMC4: length 23.9
  IN05 w0.14: v3(289.83,139.11) 289.43,139.52 283.58,139.52 279.22,135.15 278.26,135.15 v3(277.97,134.87)
  BOTTOM w0.102: 276.28,133.18 271.8,133.18 271.75,133.13 269.85,133.13 G2.D29
  BOTTOM w0.152: v3(277.97,134.87) 276.28,133.18 ; U2024.D2 290.22,138.72 v3(289.83,139.11)
DQMC5: length 26.9
  IN10 w0.14: v3(269.09,131.67) 269.93,132.51 271.04,132.51 271.94,131.6 273.02,131.6 273.49,131.13 275.77,131.13 276.51,130.39 280,130.39 282.9,133.3 287.43,133.3 288.63,132.1 288.63,130.14 288.85,129.92 289.43,129.92 v3(289.83,129.52)
  BOTTOM w0.152: v3(289.83,129.52) U2024.D13 ; G2.E27 v3(269.09,131.67)
DQMC6: length 36.6
  IN05 w0.14: v3(268.39,126.17) 268.67,126.45 269.47,126.45 269.61,126.31 298.37,126.31 299.83,127.77 299.83,129.72 299.63,129.92 299.03,129.92 v3(298.63,130.32)
  BOTTOM w0.152: U2024.P13 298.23,129.92 v3(298.63,130.32) ; G2.F20 v3(268.39,126.17)
DQMC7: length 37.6
  IN05 w0.14: v3(297.83,139.11) 297.43,138.71 296.85,138.71 296.63,138.49 296.63,137.35 293.43,134.15 293.43,130.14 293.21,129.92 276.44,129.92 275.15,131.2 271.52,131.2 270.66,130.35 270.06,130.35 v3(269.93,130.21)
  BOTTOM w0.102: G2.E26 269.05,130.67 269.4,130.31 269.83,130.31 v3(269.93,130.21)
  BOTTOM w0.152: U2024.P2 298.22,138.72 v3(297.83,139.11)
DQMD0: length 21.1
  IN05 w0.14: v3(251.3,110.87) 251.04,110.87 249.67,109.5 249.67,103.58 244.87,98.78 244.87,96.32 v3(244.47,95.92)
  BOTTOM w0.152: v3(251.3,110.87) 251.99,111.56 G2.AJ1 ; U2026.P2 v3(244.47,95.92)
DQMD1: length 19.2
  IN05 w0.14: v3(254.09,111.55) 255.38,110.26 255.38,101.72 254.47,100.81 254.47,96.32 v3(254.07,95.92)
  BOTTOM w0.152: v3(254.09,111.55) 253.39,112.25 G2.AG1 ; v3(254.07,95.92) U2026.P13
DQMD2: length 33.3
  IN05 w0.14: v3(257.29,117.07) 257.64,116.72 257.64,101.46 256.61,100.43 256.61,89.26 255.67,88.32 253.67,88.32 v3(253.27,87.92)
  BOTTOM w0.152: U2026.D13 v3(253.27,87.92) ; G2.AA7 v3(257.29,117.07)
DQMD3: length 35.4
  IN05 w0.14: v3(245.27,87.12) 245.67,87.52 245.67,89.78 245.81,89.92 247.03,89.92 251.12,94.01 251.12,99.46 253.67,102.01 253.67,107.08 253.07,107.68 253.07,108.55 253.61,109.08 253.61,112.93 254.34,113.67 254.85,113.67 255.36,114.17 255.36,115.4 v3(255.11,115.66)
  BOTTOM w0.152: G2.AD5 255.18,115.66 v3(255.11,115.66) ; U2026.D2 v3(245.27,87.12)
DQMD4: length 23.8
  IN05 w0.14: v3(272.23,95.92) 272.63,96.32 273.74,96.32 274.92,97.5 274.92,105.96 270.01,110.87 270.01,114.65 v3(269.79,114.87)
  BOTTOM w0.152: U60.D2 v3(272.23,95.92) ; G2.D3 269.49,114.57 v3(269.79,114.87)
DQMD5: length 23
  IN05 w0.14: v3(267.47,113.1) 267.9,112.66 267.9,98.02 266.2,96.32 263.83,96.32 v3(263.43,95.92)
  BOTTOM w0.102: G2.H3 266.69,114.37 267.01,114.04 267.01,113.74 267.47,113.29 v3(267.47,113.1)
  BOTTOM w0.152: v3(263.43,95.92) U60.D13
DQMD6: length 32.8
  IN05 w0.14: v3(262.63,87.12) 262.23,87.52 261.66,87.52 259.1,90.08 259.1,99.3 261.24,101.44 261.24,112.67 260.37,113.54 260.37,115.3 v3(260.73,115.66)
  BOTTOM w0.152: U60.P13 v3(262.63,87.12) ; G2.U5 260.69,115.66 v3(260.73,115.66)
DQMD7: length 41.8
  IN05 w0.14: v3(272.23,87.92) 271.83,88.32 271.83,89.69 270.8,90.72 270.18,90.72 265.38,95.52 262.41,95.52 262.08,95.84 262.08,97.62 262.38,97.92 264.46,97.92 265.4,98.86 265.4,113.44 264.31,114.52 264.31,118.34 v3(263.59,119.07)
  BOTTOM w0.152: v3(263.59,119.07) G2.M9 ; v3(272.23,87.92) U60.P2
DQSA0: length 21.3
  IN05 w0.14: v3(261.31,165.95) 261.31,165.95 261.71,165.55 261.71,158.35 261.35,157.99 261.35,148.49 261.91,147.93 261.91,146.79 v3(261.49,146.37)
  BOTTOM w0.152: v3(261.31,165.95) U48.R2 ; v3(261.49,146.37) G2.R48
DQSA1: length 23.8
  IN05 w0.14: v3(252.51,165.95) 252.91,165.55 252.91,163.96 256.76,160.1 256.76,150.52 257.94,149.34 257.94,147.19 258.4,146.74 259,146.74 v3(259.37,146.37)
  BOTTOM w0.152: v3(252.51,165.95) U48.R13 ; G2.V48 259.4,146.36 259.38,146.36 v3(259.37,146.37)
DQSA2: length 37.9
  IN05 w0.14: v3(251.71,176.35) 251.31,175.95 250.59,175.95 250.03,175.39 250.03,174.07 248.66,172.7 248.66,162.93 253.29,158.29 253.29,149.87 253.18,149.75 253.18,149.01 253.94,148.26 253.94,144.02 v3(254.39,143.57)
  BOTTOM w0.152: U48.C13 v3(251.71,176.35) ; v3(254.39,143.57) 254.09,143.27 G2.AF44
DQSA3: length 38.9
  IN05 w0.14: v3(260.51,175.55) 260.11,175.15 260.11,172.96 259.9,172.75 259.22,172.75 254.42,167.95 251.48,167.95 251.31,167.77 251.31,163.98 255.61,159.68 255.61,150.7 257.62,148.68 257.62,146.76 v3(257.24,146.38)
  BOTTOM w0.152: G2.AA48 257.28,146.38 v3(257.24,146.38) ; U48.C2 v3(260.51,175.55)
DQSA4: length 23.1
  IN05 w0.14: v3(242.09,149.05) 241.82,148.78 240.57,148.78 234.08,155.27 234.08,165.55 v3(234.48,165.95)
  BOTTOM w0.152: v3(242.09,149.05) 242.13,149 242.75,149 G2.BB52 ; v3(234.48,165.95) U2022.C2
DQSA5: length 24
  IN05 w0.14: v3(242.29,151.35) 242.29,151.87 240.98,153.18 240.98,162.83 242.08,163.92 242.08,165.55 v3(242.48,165.95)
  BOTTOM w0.102: 242.58,151.06 242.65,150.99 245.73,150.99 246.56,150.16 246.56,148.54 246.74,148.37 246.74,147.97 247.09,147.62 G2.AT50
  BOTTOM w0.152: v3(242.48,165.95) U2022.C13 ; v3(242.29,151.35) 242.58,151.06
DQSA6: length 37.1
  IN05 w0.14: v3(242.48,176.35) 242.88,176.75 244.96,176.75 247.24,174.47 247.24,161.76 251.7,157.3 251.7,147.16 v3(250.94,146.4)
  BOTTOM w0.152: v3(250.94,146.4) 251.28,146.07 G2.AK48 ; U2022.R13 v3(242.48,176.35)
DQSA7: length 39
  IN05 w0.14: v3(234.48,175.55) 234.88,175.15 235.57,175.15 236.06,174.67 236.78,174.67 237.57,173.87 237.57,173.1 239.1,171.57 240.35,171.57 240.78,171.15 243.89,171.15 244.72,170.32 244.72,163.51 242.91,161.71 242.91,154.34 246.82,150.44 247.35,150.44 v3(247.79,150)
  BOTTOM w0.102: G2.AR51 247.79,148.4 248.16,148.77 248.16,149.63 v3(247.79,150)
  BOTTOM w0.152: v3(234.48,175.55) U2022.R2
DQSB0: length 23.9
  IN05 w0.14: v3(273.99,135.72) 274.49,136.22 275.7,136.22 286.42,146.94 288.5,146.94 v3(288.9,147.34)
  BOTTOM w0.102: G2.B33 271.43,136.11 273.76,136.11 273.99,135.88 v3(273.99,135.72)
  BOTTOM w0.152: U2023.R2 v3(288.9,147.34)
DQSB1: length 30.3
  IN05 w0.14: v3(268.49,136.67) 268.93,137.11 270.67,137.11 271.92,138.36 272.45,138.36 285.55,151.46 285.55,153.41 287.08,154.94 288.5,154.94 v3(288.9,155.34)
  BOTTOM w0.152: v3(288.9,155.34) U2023.R13 ; v3(268.49,136.67) G2.E35
DQSB2: length 45.1
  IN05 w0.14: v3(266.5,143.08) 266.65,143.23 267.07,143.23 267.59,143.75 270.49,143.75 271.13,144.38 271.13,145.53 285.69,160.09 296.45,160.09 298.9,157.64 U2023.C13 v3(299.3,155.34)
  BOTTOM w0.152: U2023.C13 v3(299.3,155.34) ; v3(266.5,143.08) 266.69,143.27 G2.G44
DQSB3: length 50.1
  IN05 w0.14: v3(266.39,138.77) 266.39,138.64 266.62,138.41 266.62,137.79 267,137.41 270.21,137.41 284.73,151.92 284.73,154.16 287.1,156.54 292.29,156.54 292.5,156.32 292.5,151.81 295.78,148.54 297.91,148.54 298.1,148.35 298.1,147.74 v3(298.5,147.34)
  BOTTOM w0.152: v3(298.5,147.34) U2023.C2 ; v3(266.39,138.77) G2.H38
DQSB4: length 23.9
  IN05 w0.14: v3(268.73,165.95) 268.33,166.35 267.54,166.35 267.17,165.98 267.17,157.13 v3(261.79,151.74)
  BOTTOM w0.102: 262.47,151.05 263.01,150.51 263.01,148.62 262.84,148.45 262.84,147.82 G2.P50
  BOTTOM w0.152: v3(261.79,151.74) 262.47,151.05 ; U55.C2 v3(268.73,165.95)
DQSB5: length 26.2
  IN05 w0.14: v3(265.69,146.37) 265.98,146.66 265.98,147.49 266.21,147.72 266.21,148.24 267.94,149.97 268.18,149.97 269.92,151.71 270.95,151.71 276.4,157.16 276.4,162.61 277.13,163.34 277.13,165.55 v3(277.53,165.95)
  BOTTOM w0.152: v3(277.53,165.95) U55.C13 ; v3(265.69,146.37) G2.J48
DQSB6: length 39
  IN05 w0.14: v3(277.53,176.35) 277.93,176.75 279.34,176.75 281.93,174.16 281.93,163.67 279.43,161.16 279.43,155.38 273.67,149.62 270.98,149.62 269.83,148.47 v3(269.79,148.47)
  BOTTOM w0.152: U55.R13 v3(277.53,176.35) ; G2.D51 v3(269.79,148.47)
DQSB7: length 33.2
  IN05 w0.14: v3(268.91,151.97) 269.33,151.97 270.03,152.67 270.03,154.33 273.68,157.97 273.68,171.63 272.78,172.52 272.78,173.93 272.06,174.66 271.12,174.66 270.63,175.15 269.93,175.15 v3(269.53,175.55)
  BOTTOM w0.102: 268.91,150.62 268.91,150.45 268.57,150.12 268.57,149.45 268.45,149.33 268.45,148.53 G2.F51
  BOTTOM w0.152: v3(268.91,151.97) 268.91,150.62 ; U55.R2 v3(269.53,175.55)
DQSC0: length 23
  IN05 w0.14: v3(289.03,112.29) 288.63,111.89 286.24,111.89 282.28,115.86 274.44,115.86 274.13,116.16 269.68,116.16 v3(269.19,115.67)
  BOTTOM w0.152: G2.D5 v3(269.19,115.67) ; v3(289.03,112.29) 289.03,112.29 U2025.R2
DQSC1: length 32.8
  IN05 w0.14: v3(289.03,120.29) 288.63,119.89 288.63,116.5 290.23,114.9 290.23,112.91 290.01,112.69 286.39,112.69 282.55,116.53 269.74,116.53 269.49,116.79 269.49,117.46 v3(269.19,117.77)
  BOTTOM w0.152: G2.D8 v3(269.19,117.77) ; v3(289.03,120.29) U2025.R13
DQSC2: length 33.7
  IN05 w0.14: v3(269.09,124.07) 269.25,124.23 285.68,124.23 286.34,124.9 296.3,124.9 299.03,122.17 299.03,121.48 299.42,121.08 v3(299.43,121.08)
  BOTTOM w0.152: v3(269.09,124.07) G2.E17 ; U2025.C13 v3(299.43,121.08)
DQSC3: length 42.9
  IN05 w0.14: v3(269.09,121.17) 270.88,122.96 285.38,122.96 286.65,124.22 295.3,124.22 297.42,122.1 297.42,118.4 297.83,118 297.83,117.43 298.93,116.33 298.93,113.58 299.02,113.49 299.02,111.89 v3(298.62,111.49)
  BOTTOM w0.152: G2.E12 268.79,120.87 v3(269.09,121.17) ; U2025.C2 299.02,111.88 v3(298.62,111.49)
DQSC4: length 23.1
  IN05 w0.14: v3(289.03,138.31) 288.63,137.92 283.83,137.92 280.22,134.31 271.43,134.31 270.58,133.46 269.39,133.46 v3(269.09,133.77)
  BOTTOM w0.152: G2.E30 v3(269.09,133.77) ; v3(289.03,138.31) 289.43,138.71 U2024.C2
DQSC5: length 20.4
  IN05 w0.14: v3(289.03,130.32) 288.63,130.72 288.63,131.3 288.41,131.52 287.67,131.52 287.03,132.15 273.25,132.15 v3(272.64,132.77)
  BOTTOM w0.102: G2.B29 271.29,132.37 272.24,132.37
  BOTTOM w0.152: U2024.C13 v3(289.03,130.32) ; v3(272.64,132.77) 272.24,132.37
DQSC6: length 35
  IN05 w0.14: v3(267.09,127.47) 267.57,126.99 297.58,126.99 299.03,128.43 299.03,129.12 v3(299.43,129.52)
  BOTTOM w0.152: v3(299.43,129.52) U2024.R13 ; G2.G21 v3(267.09,127.47)
DQSC7: length 37.3
  IN05 w0.14: v3(269.09,129.62) 269.48,129.22 286.26,129.22 286.37,129.12 294.01,129.12 294.23,129.33 294.23,132.35 297.47,135.59 297.47,136.51 298.23,137.27 298.23,137.91 v3(298.63,138.31)
  BOTTOM w0.152: v3(298.63,138.31) 299.03,138.71 U2024.R2 ; G2.E24 268.79,129.32 v3(269.09,129.62)
DQSD0: length 21.8
  IN05 w0.14: v3(245.27,96.72) 245.67,97.12 245.67,98.51 250.35,103.2 250.35,108.9 251.16,109.71 v3(251.3,109.71)
  BOTTOM w0.102: G2.AJ3 252.32,114.24 252.32,113.71 252.54,113.49 252.54,113.34
  BOTTOM w0.152: 252.54,113.34 252.54,110.79 251.45,109.71 v3(251.3,109.71) ; v3(245.27,96.72) 244.87,96.32 U2026.R2
DQSD1: length 19.1
  IN05 w0.14: v3(254.09,110.38) 254.58,109.89 254.58,101.87 253.67,100.96 253.67,97.12 v3(253.27,96.72)
  BOTTOM w0.152: G2.AG2 252.96,113.44 252.96,111.5 v3(254.09,110.38) ; v3(253.27,96.72) U2026.R13
DQSD2: length 36
  IN05 w0.14: v3(254.07,87.12) 254.47,87.52 255.87,87.52 257.29,88.94 257.29,100.15 258.44,101.3 258.44,114.41 258.18,114.66 258.18,118.17 v3(257.29,119.07)
  BOTTOM w0.152: G2.AA9 v3(257.29,119.07) ; U2026.C13 v3(254.07,87.12)
DQSD3: length 34.7
  IN05 w0.14: v3(254.39,114.97) 252.9,113.48 252.9,108.96 252.39,108.45 252.39,107.23 252.9,106.73 252.9,102.23 250.38,99.71 250.38,94.66 246.44,90.72 245.53,90.72 244.87,90.06 U2026.C2 v3(244.47,86.32)
  BOTTOM w0.152: U2026.C2 v3(244.47,86.32) ; G2.AF4 v3(254.39,114.97)
DQSD4: length 22.6
  IN05 w0.14: v3(269.09,114.27) 269.54,113.81 269.54,110.15 274.08,105.61 274.08,97.8 273.39,97.12 271.83,97.12 v3(271.43,96.72)
  BOTTOM w0.152: U60.C2 v3(271.43,96.72) ; v3(269.09,114.27) G2.E3
DQSD5: length 21.6
  IN05 w0.14: v3(262.63,96.72) 263.03,97.12 265.74,97.12 267.01,98.39 267.01,111.47 v3(267.47,111.93)
  BOTTOM w0.102: v3(267.47,111.93) 267.04,112.35 267.04,113.31 266.69,113.67 G2.H2
  BOTTOM w0.152: v3(262.63,96.72) U60.C13
DQSD6: length 36.8
  IN05 w0.14: v3(263.43,86.32) 263.03,85.92 261.67,85.92 258.43,89.16 258.43,99.68 260.49,101.75 260.49,112.11 259.78,112.83 259.78,116.06 v3(260.68,116.96)
  BOTTOM w0.152: U60.R13 v3(263.43,86.32) ; G2.U6 v3(260.68,116.96)
DQSD7: length 38.4
  IN05 w0.14: v3(263.54,116.22) 263.84,115.91 263.84,115.33 263.61,115.09 263.61,100.61 261.19,98.19 261.19,94.58 261.44,94.32 262.05,94.32 262.45,93.92 265.22,93.92 268.5,90.63 268.5,88.59 268.85,88.24 269.66,88.24 270.38,87.52 271.03,87.52 v3(271.43,87.12)
  BOTTOM w0.152: v3(263.54,116.22) 263.79,115.97 G2.M5 ; v3(271.43,87.12) U60.R2
DRAM_CRESET_N: length 97.5
  TOP w0.097: v1(161.39,55.96) 162.15,55.2 162.15,52.4 v1(166.47,48.09)
  IN10 w0.091: v3(241.9,53.17) 241.9,52.78 240.63,51.51 239.36,51.51 237.59,49.74 237.59,49.48 234.67,46.56 223.87,46.56 223.36,47.07 216.5,47.07 215.7,47.88 215.7,49.15 214.47,50.37 202.22,50.37 200.95,49.1 170.66,49.1 169.64,48.09 v1(166.47,48.09)
  BOTTOM w0.097: U2.BC14 241.9,52.51 v3(241.9,53.17) ; R86.1 160.8,59.01 C170.2 R84.1 161.77,56.34 v1(161.39,55.96)
DRON: length 120.2
  TOP w0.203: 130.61,192.4 PU1101.35
  TOP w0.254: v1(132.96,192.84) 132.91,192.84 132.51,192.43 130.65,192.43 130.61,192.4
  IN03 w0.254: v1(200.38,188.67) 199.36,188.67 197.58,190.45 197.58,192.87 197.96,193.25 197.96,194.26 200.76,197.06 209.52,197.06 211.04,198.58 211.42,198.58 212.19,197.82 212.19,192.74 211.81,192.36 211.47,192.36 211.04,191.93 211.04,189.06 v1(211.42,188.67)
  IN05 w0.254: v1(132.96,192.84) 133.62,192.18 133.62,191.79 134.05,191.36 153.28,191.36 154.02,192.1 165.32,192.1 v1(166.34,193.12) 166.85,193.63 167.74,193.63 169.01,192.36 174.21,192.36 176.75,189.82 177.52,189.82 177.9,190.2 177.9,191.21 177.26,191.85 v1(177.26,193.25) 178.28,193.25 179.04,192.48 187.42,192.48 v1(188.18,193.25) 188.69,193.25 191.1,190.83 197.71,190.83 199.87,188.67 v1(200.38,188.67)
  BOTTOM w0.254: PR1611.1 188.06,193.12 v1(188.18,193.25) ; v1(166.34,193.12) 166.47,192.99 PR1506.1 ; v1(177.26,193.25) PR1512.1
  BOTTOM w0.356: PR1620.1 211.04,188.93 211.3,188.67 v1(211.42,188.67) ; v1(200.38,188.67) 200.12,188.93 PR1606.1
EC_ADP_ID_ON_N: length 125.5
  TOP w0.097: v1(76.3,81.99) 77.95,81.99 78.33,82.38 78.33,89.23 v2(79.85,90.76) 81.25,92.15 81.25,93.17 81.5,93.42 PQ101.5
  IN05 w0.091: v1(81.38,33.35) 79.6,33.35 79.34,33.61 76.17,33.61 75.66,33.1 72.87,33.1 70.07,30.31 68.99,30.31 66.64,32.65 58.33,32.65 53.97,37.01 53.97,41.35 47.49,47.83 44.67,47.83 v1(44.17,48.34)
  IN08 w0.091: v1(81.38,33.35) 76.55,38.18 76.55,50.24 77.15,50.85 77.15,58.96 76.47,59.64 76.47,65.56 74.39,67.64 74.39,78.31 75.03,78.95 76.17,78.95 76.47,79.25 76.47,80.81 76.3,80.98 v1(76.3,81.99)
  BOTTOM w0.076: U5.D12 37.78,51.41 38.04,51.16 38.55,51.16
  BOTTOM w0.097: 38.55,51.16 39.97,49.74 39.97,48.85 40.41,48.41 44.09,48.41 v1(44.17,48.34)
EC_AGND: length 203.2
  TOP w0.203: R558.2 154.91,133.1 154.91,132.32 147.54,124.95 147.54,115.9 140.69,109.05 124.48,109.05 v1(124.23,109.3)
  IN05 w0.203: v1(94.41,38.18) 93.4,37.16 90.27,37.16 88.67,35.56 57.96,35.56 55.6,37.93 55.6,43.01 53.54,45.06 53.54,46.59 51.89,48.24 49.09,48.24 45.82,51.51 44.8,51.51 44.67,51.39 44.04,51.39 43.78,51.64 43.78,52.15 43.4,52.53 41.63,52.53 41.24,52.15 38.32,52.15 37.68,51.51 v2(37.37,51.51)
  IN08 w0.203: v1(124.23,109.3) 123.84,108.92 122.27,108.92 111.98,98.63 111.98,89.23 108.49,85.74 108.49,70.5 105.13,67.14 105.13,66.37 101.19,62.44 99.71,62.44 98.52,61.25 98.52,43.13 96.87,41.48 96.87,40.08 95.47,38.69 94.97,38.69 94.46,38.18 v1(94.41,38.18)
  BOTTOM w0.254: U5.E10 37.18,51.51 37.37,51.51 v2(37.37,51.51)
EC_CK32K/GPJ6: length 7.3
  TOP w0.097: v1(28.67,50.24) 29.1,49.81 R526.2
  BOTTOM w0.076: U5.F2 32.77,52.41 32.51,52.67 31.97,52.67
  BOTTOM w0.097: R261.2 28.67,50.04 v1(28.67,50.24) 28.67,50.42 29.56,51.31 30.49,51.31 31.84,52.67 31.97,52.67
EC_CLEAR_CMOS: length 219.4
  TOP w0.089: v3(40.99,50.52) 40.99,50.85 40.41,51.44 R523.1
  TOP w0.097: v1(233.65,45.8) 233.78,45.67 233.9,45.67 236.06,43.51 242.23,43.51 C401.1 243.35,44.28 R428.2 244.32,44.49 Q12.2
  IN03 w0.089: 41.5,50.58 41.05,50.58 v3(40.99,50.52)
  IN03 w0.091: v1(233.65,45.8) 233.01,46.43 224.25,46.43 220.57,50.12 219.5,50.12 214.8,54.82 190.98,54.82 188.95,56.85 156.69,56.85 156.05,57.48 131.92,57.48 130.4,59.01 126.97,59.01 126.84,59.13 111.86,59.13 110.84,60.15 106.27,60.15 103.87,57.75 88.88,57.75 86.42,55.29 77.15,55.29 76.57,55.86 72.26,55.86 70.58,54.18 63.22,54.18 60.8,51.77 60.8,51.26 58.26,48.72 45.69,48.72 43.83,50.58 41.5,50.58
EC_CS_N: length 10.8
  BOTTOM w0.097: U5.A7 35.28,45.77 35.04,45.54 35.04,41.79 35.27,41.56 v2(35.27,40.97) 34.78,40.48 RP4.8
EC_FAN_PWM1: length 347.8
  IN05 w0.089: 41.5,57.61 40.86,58.25 40.86,58.63
  IN05 w0.091: 41.5,57.61 41.56,57.55 41.65,57.46 45.54,57.46 46.66,58.59 51.95,58.59 52.8,57.74 52.8,55.07 55.09,52.78 55.34,52.78 58.14,49.99 58.14,49.23 59.28,48.09 66.77,48.09 67.46,47.39 71.53,47.39 72.4,46.52 89.3,46.52 90.28,45.55 92.93,45.55 97.89,40.59 97.89,39.87 101.88,35.88 110.72,35.88 113.15,38.31 115.29,38.31 v1(115.54,38.56) ; v1(34.39,60.23) 35.2,60.23 35.91,59.52 36.8,59.52 37.82,60.53 39.59,60.53 40.86,59.26 40.86,58.63
  IN08 w0.091: v1(115.54,38.56) 115.79,38.81 115.79,42.75 119.71,46.67 167.94,46.67 170.26,44.35 189.33,44.35 192.07,41.61 200.38,41.61 202.87,44.1 212.2,44.1 214.74,41.56 235.55,41.56 235.99,41.99 253.59,41.99 254.02,41.56 256.5,41.56 258.54,43.6 258.54,44.78 259.43,45.67 264.64,45.67 265.65,44.66 267.56,44.66 270.2,42.02 275.84,42.02 276.19,42.37 277.34,42.37 277.97,41.74 293.34,41.74 293.59,41.48 296.77,41.48 300.83,45.55 304.64,45.55 305.79,46.69 305.79,53.29 304.52,54.56 298.42,54.56 297.78,55.2 297.78,68.91 299.31,70.44 299.31,71.33 298.67,71.96 v1(298.42,71.96)
  BOTTOM w0.076: U5.M6 34.77,55.42 35.03,55.67 35.03,56.21
  BOTTOM w0.097: JFAN1.3 295.82,72.66 296.51,71.96 v1(298.42,71.96) ; v1(34.39,60.23) 34.89,59.72 34.89,58.25 35.03,58.12 35.03,56.21
EC_FAN_PWM2: length 121.7
  IN05 w0.203: v1(83.92,45.75) 83.92,45.42 82.27,43.77 76.93,43.77 74.9,45.8 67.53,45.8 65.88,47.45 57.75,47.45 55.21,49.99 55.21,51.9 54.96,52.15 54.71,52.15 52.04,54.82 52.04,57.61 51.56,58.09 47.06,58.09 45.94,56.97 41.38,56.97 39.47,58.88 34.51,58.88 v1(34.39,59.01)
  IN10 w0.203: v1(83.92,45.75) 83.92,47.45 84.55,48.09 84.55,52.4 84.93,52.78 84.93,62.44 85.69,63.2 85.69,67.01 88.36,69.68 88.36,88.68 91.28,91.61 91.28,95.84 91.79,96.35 92.68,96.35 v1(92.81,96.47)
  BOTTOM w0.097: U5.N6 34.77,57.99 34.51,58.25 34.51,58.88 v1(34.39,59.01)
  BOTTOM w0.254: JFAN2.3 93.3,96.97 v1(92.81,96.47)
EC_FAN_TACH1: length 341.8
  TOP w0.089: v2(38.27,56.47) 38.27,57.71 R253.2
  IN05 w0.091: v1(116.43,37) 113.36,37 111.16,34.81 100.54,34.81 96.36,38.98 96.36,39.81 92.15,44.02 84.17,44.02 83.28,43.13 75.53,43.13 75.15,42.75 69.57,42.75 68.8,43.51 67.53,43.51 65.88,45.16 58.06,45.16 52.85,50.37 51.02,50.37 50.01,51.39 49.5,51.39 46.2,54.69 41.5,54.69 40.69,55.5 39.7,55.5 38.73,56.47 v2(38.27,56.47)
  IN08 w0.091: v1(116.43,37) 116.05,37.38 116.05,42.7 118.81,45.46 168.68,45.46 170.12,44.02 189.07,44.02 191.74,41.35 200.63,41.35 203.04,43.77 212.06,43.77 214.5,41.33 235.68,41.33 236.09,41.74 253.46,41.74 253.87,41.33 256.74,41.33 258.8,43.39 258.8,44.53 259.68,45.42 264.38,45.42 265.53,44.28 267.56,44.28 270.17,41.66 275.89,41.66 276.19,41.35 276.96,41.35 277.08,41.48 293.21,41.48 293.47,41.23 296.9,41.23 300.83,45.16 304.9,45.16 306.17,46.43 306.17,53.67 305.02,54.82 298.55,54.82 298.04,55.32 298.04,68.79 299.69,70.44 299.69,72.98 v1(298.55,74.12)
  BOTTOM w0.076: U5.M11 37.28,55.42 37.53,55.67 37.53,56.02
  BOTTOM w0.089: 37.53,56.02 37.85,56.34 38.15,56.34 v2(38.27,56.47)
  BOTTOM w0.097: JFAN1.2 294.04,73.49 295.5,73.49 296.51,74.5 298.17,74.5 v1(298.55,74.12)
EC_FAN_TACH2: length 117.1
  TOP w0.089: R254.2 39.09,56.59 39.21,56.47 v2(39.21,55.45)
  IN05 w0.203: v2(39.21,55.45) 39.47,55.2 40.48,55.2 41.37,54.31 46.07,54.31 49.37,51.01 49.88,51.01 50.88,50.01 52.78,50.01 55.85,46.94 55.85,45.42 57.63,43.64 57.63,42.88 57.88,42.62 58.39,42.62 58.64,42.88 68.3,42.88 69.57,41.61 74.65,41.61 75.79,42.75 78.33,42.75 78.58,42.5 83.66,42.5 v1(84.68,43.51)
  IN10 w0.203: v1(92.81,95.58) 92.43,95.96 91.92,95.96 91.66,95.71 91.66,91.52 88.74,88.6 88.74,69.55 86.2,67.01 86.2,63.07 85.31,62.18 85.31,52.66 84.93,52.28 84.93,47.7 84.68,47.45 v1(84.68,43.51)
  BOTTOM w0.076: 38.58,55.16 38.04,55.16 37.78,55.41 U5.M12
  BOTTOM w0.097: v2(39.21,55.45) 38.92,55.16 38.58,55.16
  BOTTOM w0.254: v1(92.81,95.58) 92.94,95.72 JFAN2.2
EC_I2C_CLK3: length 840.5
  TOP w0.089: v2(36.22,50.89) 36.29,50.82 R563.2
  TOP w0.097: v1(302.86,84.79) 303.37,85.3 304.64,85.3 304.97,85.63 PR3575.1 ; v1(69.82,82.38) 69.44,82.76 R2242.1 ; R2240.1 81,76.91 v1(80.49,76.41) v2(78.07,78.82) 76.55,80.34 74.52,80.34 73.88,80.98 v1(73.88,81.87) ; PR3584.1 302.53,175.39 302.36,175.21 300.45,175.21 v1(299.82,174.58)
  IN03 w0.089: 29.81,49.74 30.07,49.74 30.45,50.12 35.66,50.12 36.22,50.68 v2(36.22,50.89)
  IN03 w0.091: 29.81,49.74 29.69,49.74 28.93,48.97 28.54,48.97 27.15,47.58 27.15,45.93 v1(26.13,44.91)
  IN05 w0.091: v1(61.56,34.37) 60.29,33.1 58.64,33.1 54.48,37.27 54.48,41.71 52.32,43.87 52.32,45.95 51.81,46.46 49.6,46.46 47.72,48.34 45.69,48.34 44.37,49.66 42.77,49.66 42.31,50.12 36.99,50.12 v2(36.22,50.89) ; v1(73.88,81.87) 73.38,81.36 70.24,81.36 69.82,81.78 v1(69.82,82.38) ; v1(302.86,84.79) 303.14,85.07 303.14,91.09 303.79,91.74 303.79,93.41 305.68,95.3 305.68,98.99 303.75,100.92 302.36,100.92 301.47,101.81 301.47,102.7 301.88,103.11 301.88,103.75 301.24,104.39 301.24,108.16 304.26,111.18 304.26,122.25 304.9,122.89 304.9,161.77 302.9,163.77 302.9,171.49 v1(299.82,174.58)
  IN08 w0.091: v1(217.01,105.74) 215.81,105.74 215.49,105.42 213.52,105.42 210.64,102.54 210.64,95.5 209.51,94.37 209.51,92.78 207.49,90.76 207.49,81.87 212.57,76.79 218.79,76.79 221.77,73.8 221.77,70.76 222.85,69.68 224.89,69.68 226.03,68.53 231.49,68.53 232.38,69.42 232.76,69.42 233.01,69.17 233.01,67.77 233.65,67.14 237.33,67.14 237.59,67.39 238.86,67.39 239.11,67.64 239.75,67.64 240.07,67.32 241.59,67.32 242.03,66.88 243.56,66.88 243.81,67.14 247.9,67.14 252.95,72.19 252.95,73.49 253.84,74.37 258.03,74.37 258.29,74.12 258.29,71.83 258.96,71.16 271.28,71.16 274.8,67.64 274.8,63.2 275.33,62.67 275.33,61.78 278.43,58.67 288.85,58.67 289.02,58.5 294.61,58.5 295.75,59.64 295.75,66.88 v1(296.13,67.26) ; v1(299.82,58.88) 300.5,59.56 300.5,60.36 299.56,61.29 299.56,67.46 302.1,70 302.1,71.6 303.12,72.62 303.12,77.8 303.37,78.06 303.37,84.28 v1(302.86,84.79)
  IN10 w0.091: v1(299.82,58.88) 297.28,61.42 296.9,61.42 296.13,62.18 v1(296.13,67.26) ; v1(64.99,4.63) 62.75,6.86 62.75,7.24 61.92,8.07 50.38,8.07 46.83,4.52 41.63,4.52 41.12,4.02 29.83,4.02 26.59,7.26 26.59,18.62 28.93,20.95 28.93,35.89 26.51,38.31 26.51,41.86 26.97,42.33 26.97,44.07 v1(26.13,44.91) ; v1(299.82,174.58) 299.31,174.07 297.64,174.07 285.21,186.5 283.33,186.5 281.78,188.04 273,188.04 271.47,189.56 263.11,189.56 262.22,190.45 259.43,190.45 258.03,189.06 239.24,189.06 237.84,190.45 219.68,190.45 209.74,200.39 206.37,200.39 206.09,200.1 199.74,200.1 199.49,200.36 185.01,200.36 183.86,199.21 183.86,197.89 183.79,197.82 183.2,197.82 183,198.02 183,198.81 182.85,198.96 181.78,198.96 181.4,198.58 v1(176.63,198.58) 174.59,200.61 160.82,200.61 158.79,198.58 155.42,198.58 147.04,190.2 147.04,184.76 144.98,182.71 128.11,182.71 125.83,180.42 118.74,180.42 111.98,173.67 111.98,132.16 109.61,129.78 109.61,119.62 99.92,109.93 97.27,109.93 87.35,100.01 87.35,94.06 82.65,89.36 82.65,82.5 81.12,80.98 81.12,76.79 80.74,76.41 v1(80.49,76.41) 80.21,76.12 80.21,73.28 75.34,68.41 73.5,68.41 70.07,64.98 70.07,55.58 72.61,53.04 72.61,50.24 71.47,49.1 71.47,44.28 69.31,42.12 69.31,37.16 67.15,35 62.2,35 v1(61.56,34.37)
  BOTTOM w0.076: v2(36.22,50.89) 36.03,51.08 36.03,51.52 35.78,51.78 U5.E8
  BOTTOM w0.097: v1(217.01,105.74) PR3580.1 ; PR1314.1 177.57,197.64 v1(176.63,198.58) ; R2341.2 63.06,4.19 64.56,4.19 v1(64.99,4.63)
EC_I2C_CLK3_R: length 8.9
  TOP w0.076: U19.B3 68.84,8.11 68.45,8.11
  TOP w0.097: 68.45,8.11 67.95,8.11 v2(67.79,7.95)
  BOTTOM w0.089: v2(67.79,7.95) 67.41,7.57 67.41,6.68 67.03,6.3 67.03,5.83 66.77,5.58
  BOTTOM w0.097: 66.77,5.58 66.69,5.49 66.18,5.49 65.66,6.01 63.05,6.01 R2341.1
EC_I2C_CLK5: length 301.7
  TOP w0.089: v2(34.77,54.94) 34.77,55.13 R238.2
  TOP w0.097: v1(177.9,50.88) 177.9,42.24 v1(179.42,40.72) ; R319.1 265.58,27.84 v1(264.89,28.53) ; v1(271.75,16.08) 271.8,16.03 R550.1
  IN05 w0.091: v2(34.77,54.94) 35.12,55.28 37.71,55.28 39.44,53.55 40.69,53.55 40.87,53.37 45.16,53.37 49.34,49.19 52.26,49.19 54.58,46.87 54.58,45.55 56.61,43.51 56.61,41.16 58.23,39.54 58.23,38.98 59.95,37.26 85.49,37.26 88.23,40 95.01,40 95.63,39.39 95.63,38.68 100.15,34.15 111.43,34.15 112.08,34.8 115.87,34.8 v1(116.94,33.73)
  IN08 w0.091: v1(271.75,16.08) 269.88,16.08 265.65,20.3 265.65,27.77 v1(264.89,28.53) 265.32,28.95 265.32,34.22 264.38,35.15 264.38,40.59 262.99,41.99 260.83,41.99 257.27,38.43 214.6,38.43 211.2,41.84 204.11,41.84 201.39,39.12 181.02,39.12 v1(179.42,40.72) 178.16,41.98 169.91,41.98 167.5,44.39 122.36,44.39 118.63,40.66 118.63,38.48 116.94,36.78 v1(116.94,33.73)
  BOTTOM w0.089: U5.K6 v2(34.77,54.94)
EC_I2C_DATA3: length 833.8
  TOP w0.089: R564.2 35.23,49.99 v2(35.23,50.88)
  TOP w0.097: v1(300.58,174.58) 302.31,174.58 PR3587.1 ; R2241.1 81.88,76.91 v1(81.38,76.41) 80.87,75.9 80.36,75.9 76.17,80.09 73.63,80.09 72.99,80.72 v2(72.99,80.98) v1(72.99,81.87) ; v1(302.86,83.9) 302.36,84.41 302.36,84.79 301.85,85.3 301.34,85.3 300.96,85.68 297.78,85.68 297.71,85.75 PR3578.1 ; v1(70.71,82.38) 70.45,82.63 R2243.1
  IN03 w0.089: v2(35.23,50.88) 35.23,50.71 34.89,50.37 31.85,50.37 31.34,50.88 29.81,50.88
  IN03 w0.091: v1(26.13,44.02) 25.7,44.45 25.7,47.53 25.93,47.76 26.82,47.76 28.42,49.36 28.8,49.36 29.31,49.86 29.31,50.37 29.81,50.88
  IN05 w0.091: v1(62.33,34.37) 60.82,32.87 58.5,32.87 54.22,37.14 54.22,41.58 51.33,44.48 51.33,45.98 51.1,46.21 49.43,46.21 47.55,48.09 45.05,48.09 44.34,48.8 42.82,48.8 42.01,49.61 36.5,49.61 v2(35.23,50.88) ; v1(302.86,83.9) 303.53,84.57 303.53,91.17 304.01,91.65 304.01,93.32 305.9,95.21 305.9,99.15 303.88,101.17 302.74,101.17 302.61,101.3 302.61,103.33 301.46,104.48 301.46,108.02 304.52,111.08 304.52,122.13 305.15,122.76 305.15,161.88 303.12,163.91 303.12,172.04 v1(300.58,174.58) ; v1(72.99,81.87) 71.22,81.87 v1(70.71,82.38)
  IN08 w0.091: v1(297.02,67.26) 296.01,66.25 296.01,58.5 295.24,57.74 278.23,57.74 274.38,61.58 274.38,67.61 271.04,70.95 258.03,70.95 257.65,71.33 252.37,71.33 247.67,66.63 246.86,66.63 246.35,66.12 242.34,66.12 241.33,67.13 240.5,67.13 239.94,66.57 239.32,66.57 238.69,67.2 238.15,67.2 237.71,66.75 235.68,66.75 235.17,66.25 227.93,66.25 224.76,69.42 222.6,69.42 221.39,70.63 221.39,73.8 218.66,76.53 212.44,76.53 207.23,81.74 207.23,90.88 209.28,92.93 209.28,94.47 210.42,95.61 210.42,102.65 213.41,105.64 215.4,105.64 216.13,106.38 v1(217.01,106.38) ; v1(302.86,83.9) 303.12,83.65 303.12,78.18 302.86,77.93 302.86,72.72 301.85,71.71 301.85,70.06 299.31,67.52 299.31,60.15 v1(299.82,59.64)
  IN10 w0.091: v1(300.58,174.58) 299.82,173.82 297.53,173.82 285.1,186.24 283.2,186.24 281.66,187.79 272.89,187.79 271.37,189.31 262.99,189.31 262.1,190.2 259.6,190.2 258.21,188.8 239.11,188.8 237.71,190.2 219.55,190.2 209.58,200.17 206.54,200.17 206.25,199.89 199.07,199.89 198.85,200.1 185.11,200.1 184.08,199.07 184.08,197.75 183.89,197.56 183.08,197.56 182.77,197.87 182.77,198.61 182.67,198.71 181.91,198.71 181.53,198.33 177.52,198.33 177.34,198.15 176.22,198.15 v1(175.79,198.58) 174.14,200.23 166.59,200.23 166.04,199.68 160.25,199.68 158.9,198.33 155.47,198.33 147.29,190.14 147.29,184.65 145.09,182.45 128.24,182.45 125.95,180.17 118.84,180.17 112.36,173.69 112.36,132.03 109.82,129.49 109.82,119.33 100.17,109.68 97.51,109.68 87.85,100.03 87.85,94.19 83.03,89.36 83.03,82.38 81.38,80.72 v1(81.38,76.41) 81.38,75.9 80.42,74.95 80.42,73.19 70.33,63.09 70.33,55.71 72.99,53.04 72.99,50.24 71.72,48.97 71.72,44.02 69.69,41.99 69.69,37.04 67.03,34.37 v1(62.33,34.37) ; v1(26.13,44.02) 26.73,43.42 26.73,42.72 26.13,42.12 26.13,38.02 26.78,37.37 26.78,32.34 27.27,31.84 27.27,25.99 26.53,25.24 26.53,18.89 25.62,17.99 25.62,14.3 26.13,13.8 26.13,7.37 29.74,3.76 41.37,3.76 41.89,4.28 47.42,4.28 50.04,6.9 52.2,6.9 53.15,7.85 60.01,7.85 61.06,6.81 62.05,6.81 v1(64.23,4.63) ; v1(297.02,67.26) 297.66,66.63 297.66,63.96 298.17,63.45 298.17,61.29 v1(299.82,59.64)
  BOTTOM w0.089: U5.D7 35.28,51.26 35.23,51.21 v2(35.23,50.88)
  BOTTOM w0.097: PR1312.1 v1(175.79,198.58) ; v1(217.01,106.38) 216.67,106.38 216.62,106.43 PR3583.1 ; v1(64.23,4.63) 64.21,4.65 R2342.2
EC_I2C_DATA3_R: length 7.5
  TOP w0.076: 68.48,7.62 68.85,7.62 U19.B2
  TOP w0.097: v2(67.79,6.94) 68.42,7.57 68.43,7.57 68.48,7.62
  BOTTOM w0.089: 67.28,5.54 67.28,6.18 67.79,6.68 v2(67.79,6.94)
  BOTTOM w0.097: 67.28,5.54 67.01,5.27 66.03,5.27 65.51,5.79 63.72,5.79 R2342.1
EC_I2C_DATA5: length 298.6
  TOP w0.089: R244.2 v2(34.26,54.94)
  TOP w0.097: v1(264.89,30.05) 265.02,29.92 265.2,29.92 R318.1 ; R551.1 v1(275.43,15.32)
  IN05 w0.091: v1(117.83,33.73) 116.54,35.01 111.99,35.01 111.34,34.37 100.24,34.37 95.93,38.69 95.93,39.4 95.04,40.29 87.55,40.29 85.82,38.56 70.97,38.56 67.67,41.86 61.69,41.86 59.41,39.58 58.52,39.58 56.87,41.23 56.87,43.57 54.96,45.47 54.96,46.8 52.35,49.41 49.43,49.41 45.25,53.59 41,53.59 40.79,53.8 39.57,53.8 37.79,55.58 34.89,55.58 v2(34.26,54.94)
  IN08 w0.091: v1(117.83,33.73) 117.23,34.33 117.23,36.62 118.85,38.25 118.85,40.5 122.47,44.12 167.39,44.12 169.9,41.61 177.77,41.61 180.51,38.87 201.49,38.87 204.21,41.58 211.09,41.58 214.47,38.21 257.42,38.21 260.95,41.74 262.86,41.74 264.13,40.47 264.13,35 265.02,34.12 265.02,32.85 264,31.83 264,30.94 v1(264.89,30.05) 264,29.16 264,28.78 265.4,27.38 265.4,20.02 270.1,15.32 v1(275.43,15.32)
  BOTTOM w0.076: U5.J6 34.52,54.17 34.52,54.68 v2(34.26,54.94)
EC_INT_N: length 254.6
  IN03 w0.091: v1(40.2,38.69) 40.2,38.43 40.48,38.15 40.48,34.5 42.77,32.21 56.99,32.21 57.63,31.58 66.77,31.58 68.01,30.34 70.67,30.34 72.99,28.02 76.68,28.02 77.69,27 81.88,27 82.9,28.02 97.51,28.02 99.98,30.5 109.19,30.5 113.51,34.82 114.72,34.82 115.16,35.26 116.81,35.26 121.23,39.68 121.23,41.96 122.59,43.32 130.09,43.32 v1(133.32,40.08)
  IN08 w0.091: v1(40.2,38.69) 40.96,39.45 41.37,39.45 43.78,41.86 43.78,44.91 42.77,45.93 42.77,49.61 v1(43.28,50.12)
  IN10 w0.091: v3(229.59,66.75) 227.43,68.91 222.85,68.91 216.63,62.69 212.82,62.69 209.65,65.87 209.65,72.63 209.01,73.27 204.66,73.27 203.85,72.46 203.85,70.11 199.87,66.12 179.42,66.12 178.66,65.36 178.66,59.73 177.39,58.46 162.11,58.46 159.1,55.45 146.59,55.45 133.32,42.19 v1(133.32,40.08)
  BOTTOM w0.097: v3(229.59,66.75) 229.46,66.63 229.08,66.63 228.7,66.25 U2.R41 ; R566.2 43.86,50.78 43.86,50.7 v1(43.28,50.12) R370.1
EC_INT_N_R: length 4.6
  BOTTOM w0.076: 38.58,51.66 38.04,51.66 37.78,51.91 U5.E12
  BOTTOM w0.089: 39.97,50.37 38.68,51.66
  BOTTOM w0.097: R370.2 v2(40.48,50.12) 40.22,50.12 39.97,50.37 ; 38.68,51.66 38.58,51.66
EC_KSO16: length 5
  TOP w0.089: R578.2 40.99,54.26 v2(40.84,54.11) 40.69,54.11 v2(40.1,54.69) 39.97,54.69 39.62,54.33 R267.2
  BOTTOM w0.097: U5.K13 39.82,54.41 v2(40.1,54.69)
EC_KSO17: length 6.7
  TOP w0.089: v2(39.85,56.59) 39.85,56.54 v2(40.23,56.16) 40.43,55.96 R579.2 R324.2
  IN10 w0.089: v2(40.23,56.16) 39.21,56.16 v2(37.36,54.31)
  BOTTOM w0.089: U5.J10 36.91,53.91 37.31,54.31 v2(37.36,54.31)
EC_ON: length 375.1
  TOP w0.097: R152.1 v2(21.05,46.94) 21.43,46.94 v1(22.19,46.18) ; PR313.1 48.81,10.16 v1(49.12,9.86) 49.88,9.1 50.64,9.1 51.15,9.6 PR1415.1
  IN05 w0.091: v1(36.29,61.17) 35.66,61.17 34.64,62.18 31.72,62.18 31.08,61.55 v1(31.08,60.91) ; v1(55.72,22.3) 56.07,22.65 62.79,22.65 63.51,23.37 67.49,23.37 68.04,22.81 72.49,22.81 73.38,23.7 77.06,23.7 79.23,25.88 82.39,25.88 83.03,25.24 96,25.24 97.13,26.38 111.23,26.38 114.41,29.55 119.43,29.55 120.33,30.46 120.33,42.69 121.67,44.02 190.6,44.02 193.14,46.56 212.51,46.56 212.89,46.18 214.54,46.18 215.44,45.28 224.62,45.28 225.34,44.56 228.99,44.56 229.54,44.01 233.86,44.01 236.14,41.73 249.77,41.73 252.57,44.53 252.57,46.18 252.95,46.56 254.22,46.56 256,48.34 256,49.61 257.55,51.16 257.55,55.63 261.76,59.85 265.07,59.85 265.31,59.6 266.28,59.6 266.8,59.08 v1(266.8,52.4)
  IN08 w0.091: v1(55.72,22.3) 54.83,21.42 54.83,20.27 54.33,19.76 51.15,19.76 50.13,18.75 50.13,10.87 v1(49.12,9.86)
  IN10 w0.091: v1(49.12,9.86) 48.48,9.22 47.34,9.22 43.36,5.24 28.97,5.24 26.89,7.32 26.89,18.37 29.31,20.78 29.31,37.29 27.53,39.07 27.15,39.07 26.85,39.37 26.85,41.56 27.27,41.99 27.27,44.53 26.44,45.37 22.5,45.37 22.19,45.67 v1(22.19,46.18) 23.85,47.83 26.39,47.83 26.64,48.09 26.64,53.17 28.04,54.56 28.04,58.5 30.45,60.91 v1(31.08,60.91)
  BOTTOM w0.097: v1(266.8,52.4) 266.75,52.4 266.64,52.51 PR505.1 ; R256.2 R251.2 35.71,60.33 36.29,60.91 v1(36.29,61.17)
EC_ON_R: length 2.7
  BOTTOM w0.089: 35.28,57.59 35.4,57.71 R256.1
  BOTTOM w0.097: 35.28,57.59 U5.N7
EC_PECI: length 8.1
  TOP w0.097: v2(28.67,46.18) 28.42,45.93 R252.1
  BOTTOM w0.097: U5.B1 32.27,50.41 31.08,49.23 31.08,48.14 30.12,47.17 29.53,47.17 29.26,46.89 v2(29.26,46.13) 28.72,46.13 v2(28.67,46.18) 28.29,45.8 C245.2
EC_RST_N: length 3.6
  BOTTOM w0.076: 34.03,56.21 34.03,55.67 33.77,55.42 U5.M4
  BOTTOM w0.097: 34.03,56.21 34.03,57.83 33.31,58.55 R237.2
EC_SCI_N: length 253.4
  TOP w0.097: R173.2 v3(224.12,66.25)
  IN03 w0.091: v1(134.34,38.81) 133.57,39.58 133.07,39.58 129.76,42.88 122.77,42.88 121.45,41.56 121.45,39.59 116.83,34.97 115.45,34.97 114.94,34.46 113.46,34.46 109.28,30.28 100.11,30.28 97.6,27.77 83.03,27.77 82.01,26.75 77.57,26.75 76.55,27.77 72.87,27.77 70.52,30.12 67.91,30.12 66.72,31.32 57.5,31.32 56.87,31.96 42.39,31.96 40.23,34.12 40.23,38.05 39.09,39.2 35.91,39.2 35.45,38.74 35.45,38.01 35.12,37.67 34.77,37.67 34.56,37.88 34.56,38.39 34.34,38.61 32.31,38.61 v1(31.72,39.2)
  IN10 w0.089: 30.58,58.63 31.08,58.12 31.08,56.21 30.58,55.71 30.58,46.69
  IN10 w0.091: v3(224.12,66.25) 222.09,66.25 220.55,64.71 220.33,64.71 217.3,61.67 204.19,61.67 203.63,62.23 183.66,62.23 182.98,61.55 182.98,59.46 180.26,56.75 168.33,56.75 166.28,54.69 160.5,54.69 159.86,54.05 147.16,54.05 134.84,41.73 134.84,39.45 134.34,38.94 v1(134.34,38.81) ; 30.58,58.63 30.45,58.75 30.45,59.95 v1(30.37,60.02) ; 30.58,46.69 30.58,42.12 30.2,41.74 30.2,40.08 30.45,39.83 31.34,39.83 31.72,39.45 v1(31.72,39.2)
  BOTTOM w0.076: 225.52,66.75 225.78,66.75 226.8,67.78 U2.M44
  BOTTOM w0.097: v3(224.12,66.25) 224.12,66.35 224.53,66.75 225.52,66.75 ; D4.2 v1(30.37,60.02)
EC_SCI_N_R: length 7.1
  BOTTOM w0.089: 32.48,58.63 32.48,58.54 32.9,58.12 33.24,58.12 33.5,57.86
  BOTTOM w0.097: 33.5,57.86 33.77,57.59 U5.N4 ; 32.48,58.63 32.48,59.36 D4.1 31.82,60.82 v2(30.96,61.67)
EC_SCK: length 9.1
  BOTTOM w0.076: 34.52,49.61 34.52,50.16 U5.B5
  BOTTOM w0.097: RP4.5 34.04,41.98 34.2,42.14 v2(34.2,43.18) 34.34,43.31 34.34,45.29 34.16,45.47 34.16,47.3 34.52,47.66 34.52,49.61
EC_SI: length 10.1
  BOTTOM w0.076: 35.02,49.67 35.02,50.16 U5.B6
  BOTTOM w0.097: RP4.7 34.01,40.98 34.81,41.78 v2(34.81,45.85) 34.81,46.18 35.02,46.38 35.02,49.67
EC_SMB_CLK0: length 184
  TOP w0.089: 41.28,49.27 40.86,48.85 40.86,47.88 39.92,46.94 38.45,46.94
  TOP w0.097: 38.45,46.94 v3(37.69,46.18) ; v3(79.09,10.87) 79.09,10.75 79.62,10.21 79.93,10.21 PR228.1 ; 41.28,49.27 41.88,49.86 41.88,52.28 43.28,53.67 43.28,57.51 39.09,61.7 39.09,61.93 v2(38.7,62.31) R2059.1
  IN03 w0.091: v3(37.05,4.52) 37.05,4.4 37.43,4.02 40.12,4.02 41.88,5.77 41.88,8.44 42.66,9.22 45.67,9.22 46.32,8.57 46.32,6.41 47.06,5.67 50.16,5.67 51.93,7.45 61.44,7.45 62.45,8.46 64.87,8.46 65.87,7.46 72.88,7.46 74,8.57 74,9.08 75.22,10.31 76.53,10.31 76.53,10.31 78.52,10.31 79.09,10.87 v3(79.09,10.87) 79.09,11 80.74,12.65 89.12,12.65 v3(90.65,14.18)
  IN05 w0.091: v3(77.19,31.93) 76.83,31.58 73.76,31.58 70.96,28.78 66.14,28.78 63.72,31.19 57.63,31.19 52.52,36.31 52.52,40.59 48.27,44.83 39.03,44.83 v3(37.69,46.18)
  IN08 w0.091: v3(77.19,31.93) 77.19,19.4 77.44,19.15 77.44,16.84 78.2,16.08 78.96,16.08 79.73,15.32 79.73,13.67 78.84,12.78 78.84,11.4 79.09,11.15 v3(79.09,10.87)
  BOTTOM w0.097: U5.A10 36.78,47.86 37.69,46.94 v3(37.69,46.18) 37.85,46.02 38.05,46.02 R236.2 ; v3(90.65,14.18) 91.28,14.81 93.24,14.81 PR101.1 ; JDBUG1.2 38.32,4.75 38.04,5.03 37.56,5.03 v3(37.05,4.52)
EC_SMB_CLK1: length 325.1
  TOP w0.097: Q80.6 219.41,121.25 219.17,121.49 211.17,121.49 207.61,117.94 207.61,116.64 206.73,115.76 206.73,111.2 207.49,110.44 v3(208.12,110.44)
  IN03 w0.089: 40.56,48.77 39.93,48.77 38.83,49.86 37.82,49.86 36.04,48.09 v3(32.48,48.09)
  IN03 w0.091: 40.56,48.77 41.37,47.96 43.79,47.96 44.04,47.7 45.94,47.7 46.42,48.18 58.61,48.18 61.31,50.88 61.31,51.51 63.47,53.67 70.96,53.67 72.71,55.43 76.19,55.43 76.8,54.82 86.67,54.82 89.13,57.28 104.19,57.28 106.56,59.64 110.46,59.64 111.48,58.63 126.36,58.63 127.25,57.74 128.62,57.74 129.38,56.98 155.86,56.98 161.45,51.39 197.71,51.39 198.06,51.74 198.19,51.74 198.4,51.53 198.53,51.53 198.92,51.91 198.92,52.04 198.71,52.26 198.71,52.39 199.09,52.77 199.22,52.77 199.43,52.56 199.56,52.56 199.95,52.94 199.95,53.07 199.73,53.28 199.73,53.41 200.25,53.93 200.85,53.93 200.94,53.84 200.94,53.38 201.04,53.29 201.58,53.29 201.67,53.38 201.67,53.84 201.76,53.93 202.31,53.93 202.4,53.84 202.4,53.38 202.49,53.29 203.03,53.29 203.12,53.38 203.12,53.84 203.21,53.93 203.76,53.93 203.85,53.84 203.85,53.38 203.94,53.29 204.48,53.29 204.58,53.38 204.58,53.84 204.67,53.93 205.21,53.93 205.3,53.84 205.3,53.38 205.39,53.29 205.94,53.29 206.03,53.38 206.03,53.84 206.12,53.93 206.66,53.93 206.76,53.84 206.76,53.38 206.85,53.29 207.39,53.29 207.48,53.38 207.48,53.84 207.57,53.93 208.12,53.93 208.21,53.84 208.21,53.38 208.3,53.29 208.84,53.29 208.93,53.38 208.93,53.84 209.03,53.93 209.57,53.93 209.66,53.84 209.66,53.38 209.75,53.29 210.3,53.29 210.39,53.38 210.39,53.84 210.48,53.93 211.02,53.93 211.11,53.84 211.11,53.38 211.21,53.29 211.75,53.29 211.84,53.38 211.84,53.84 211.93,53.93 214.57,53.93 218.79,49.71 218.79,48.21 217.65,47.07 v3(217.65,43.89)
  IN08 w0.091: v3(208.12,110.44) 204.44,106.76 204.44,67.64 208.88,63.2 208.88,48.79 210.06,47.61 212.98,47.61 216.7,43.89 v3(217.65,43.89)
  BOTTOM w0.076: U5.B3 33.27,50.4 33.02,50.15 33.02,49.61
  BOTTOM w0.097: v3(217.65,43.89) 216.89,44.66 R166.2 217.7,45.6 217.91,45.81 Q2.1 ; 33.02,49.61 32.86,49.45 32.86,48.47 v3(32.48,48.09) ; U25.10 205.09,110.59 205.58,111.08 207.23,111.08 207.87,110.44 v3(208.12,110.44)
