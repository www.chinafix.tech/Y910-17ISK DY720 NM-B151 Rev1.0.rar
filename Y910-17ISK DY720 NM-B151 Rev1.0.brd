# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BGA_2152_P070_375X375
  round 0.3 smd: A2(-17.15,17.85) A3(-16.45,17.85) A4(-15.75,17.85) A5(-15.05,17.85) A6(-14.35,17.85) A8(-12.95,17.85) A9(-12.25,17.85) A11(-10.85,17.85) A12(-10.15,17.85) A14(-8.75,17.85) A15(-8.05,17.85) A17(-6.65,17.85) A18(-5.95,17.85) A20(-4.55,17.85) A21(-3.85,17.85) A23(-2.45,17.85) A24(-1.75,17.85) A26(-0.35,17.85) A27(0.35,17.85) A29(1.75,17.85) A30(2.45,17.85) A32(3.85,17.85) A33(4.55,17.85) A35(5.95,17.85) A36(6.65,17.85) A38(8.05,17.85) A39(8.75,17.85) A41(10.15,17.85) A42(10.85,17.85) A44(12.25,17.85) A45(12.95,17.85) A47(14.35,17.85) A48(15.05,17.85) A49(15.75,17.85) A50(16.45,17.85) A51(17.15,17.85) AA1(-17.85,3.85) AA2(-17.15,3.85) AA3(-16.45,3.85) AA4(-15.75,3.85) AA5(-15.05,3.85) AA6(-14.35,3.85) AA7(-13.65,3.85) AA8(-12.95,3.85) AA9(-12.25,3.85) AA10(-11.55,3.85) AA11(-10.85,3.85) AA14(-8.75,3.85) AA15(-8.05,3.85) AA16(-7.35,3.85) AA17(-6.65,3.85) AA18(-5.95,3.85) AA19(-5.25,3.85) AA20(-4.55,3.85) AA21(-3.85,3.85) AA22(-3.15,3.85) AA23(-2.45,3.85) AA24(-1.75,3.85) AA25(-1.05,3.85) AA26(-0.35,3.85) AA27(0.35,3.85) AA28(1.05,3.85) AA29(1.75,3.85) AA30(2.45,3.85) AA31(3.15,3.85) AA32(3.85,3.85) AA33(4.55,3.85) AA34(5.25,3.85) AA35(5.95,3.85) AA36(6.65,3.85) AA37(7.35,3.85) AA38(8.05,3.85) AA39(8.75,3.85) AA42(10.85,3.85) AA43(11.55,3.85) AA44(12.25,3.85) AA45(12.95,3.85) AA46(13.65,3.85) AA47(14.35,3.85) AA48(15.05,3.85) AA49(15.75,3.85) AA50(16.45,3.85) AA51(17.15,3.85) AA52(17.85,3.85) AB2(-17.15,3.15) AB4(-15.75,3.15) AB6(-14.35,3.15) AB8(-12.95,3.15) AB10(-11.55,3.15) AB13(-9.45,3.15) AB14(-8.75,3.15) AB15(-8.05,3.15) AB16(-7.35,3.15) AB17(-6.65,3.15) AB18(-5.95,3.15) AB19(-5.25,3.15) AB20(-4.55,3.15) AB21(-3.85,3.15) AB22(-3.15,3.15) AB23(-2.45,3.15) AB24(-1.75,3.15) AB25(-1.05,3.15) AB26(-0.35,3.15) AB27(0.35,3.15) AB28(1.05,3.15) AB29(1.75,3.15) AB30(2.45,3.15) AB31(3.15,3.15) AB32(3.85,3.15) AB33(4.55,3.15) AB34(5.25,3.15) AB35(5.95,3.15) AB36(6.65,3.15) AB37(7.35,3.15) AB38(8.05,3.15) AB39(8.75,3.15) AB40(9.45,3.15) AB43(11.55,3.15) AB45(12.95,3.15) AB47(14.35,3.15) AB49(15.75,3.15) AB51(17.15,3.15) AC1(-17.85,2.45) AC2(-17.15,2.45) AC3(-16.45,2.45) AC4(-15.75,2.45) AC5(-15.05,2.45) AC6(-14.35,2.45) AC7(-13.65,2.45) AC8(-12.95,2.45) AC9(-12.25,2.45) AC10(-11.55,2.45) AC11(-10.85,2.45) AC14(-8.75,2.45) AC15(-8.05,2.45) AC16(-7.35,2.45) AC17(-6.65,2.45) AC18(-5.95,2.45) AC19(-5.25,2.45) AC20(-4.55,2.45) AC21(-3.85,2.45) AC22(-3.15,2.45) AC23(-2.45,2.45) AC24(-1.75,2.45) AC25(-1.05,2.45) AC26(-0.35,2.45) AC27(0.35,2.45) AC28(1.05,2.45) AC29(1.75,2.45) AC30(2.45,2.45) AC31(3.15,2.45) AC32(3.85,2.45) AC33(4.55,2.45) AC34(5.25,2.45) AC35(5.95,2.45) AC36(6.65,2.45) AC37(7.35,2.45) AC38(8.05,2.45) AC39(8.75,2.45) AC42(10.85,2.45) AC43(11.55,2.45) AC44(12.25,2.45) AC45(12.95,2.45) AC46(13.65,2.45) AC47(14.35,2.45) AC48(15.05,2.45) AC49(15.75,2.45) AC50(16.45,2.45) AC51(17.15,2.45) AC52(17.85,2.45) AD1(-17.85,1.75) AD2(-17.15,1.75) AD3(-16.45,1.75) AD4(-15.75,1.75) AD5(-15.05,1.75) AD6(-14.35,1.75) AD7(-13.65,1.75) AD8(-12.95,1.75) AD9(-12.25,1.75) AD10(-11.55,1.75) AD11(-10.85,1.75) AD14(-8.75,1.75) AD15(-8.05,1.75) AD16(-7.35,1.75) AD17(-6.65,1.75) AD18(-5.95,1.75) AD19(-5.25,1.75) AD20(-4.55,1.75) AD21(-3.85,1.75) AD22(-3.15,1.75) AD23(-2.45,1.75) AD24(-1.75,1.75) AD25(-1.05,1.75) AD26(-0.35,1.75) AD27(0.35,1.75) AD28(1.05,1.75) AD29(1.75,1.75) AD30(2.45,1.75) AD31(3.15,1.75) AD32(3.85,1.75) AD33(4.55,1.75) AD34(5.25,1.75) AD35(5.95,1.75) AD36(6.65,1.75) AD37(7.35,1.75) AD38(8.05,1.75) AD39(8.75,1.75) AD42(10.85,1.75) AD43(11.55,1.75) AD44(12.25,1.75) AD45(12.95,1.75) AD46(13.65,1.75) AD47(14.35,1.75) AD48(15.05,1.75) AD49(15.75,1.75) AD50(16.45,1.75) AD51(17.15,1.75) AD52(17.85,1.75) AE2(-17.15,1.05) AE4(-15.75,1.05) AE6(-14.35,1.05) AE8(-12.95,1.05) AE10(-11.55,1.05) AE14(-8.75,1.05) AE15(-8.05,1.05) AE16(-7.35,1.05) AE17(-6.65,1.05) AE18(-5.95,1.05) AE19(-5.25,1.05) AE20(-4.55,1.05) AE21(-3.85,1.05) AE22(-3.15,1.05) AE23(-2.45,1.05) AE24(-1.75,1.05) AE25(-1.05,1.05) AE26(-0.35,1.05) AE27(0.35,1.05) AE28(1.05,1.05) AE29(1.75,1.05) AE30(2.45,1.05) AE31(3.15,1.05) AE32(3.85,1.05) AE33(4.55,1.05) AE34(5.25,1.05) AE35(5.95,1.05) AE36(6.65,1.05) AE37(7.35,1.05) AE38(8.05,1.05) AE39(8.75,1.05) AE43(11.55,1.05) AE45(12.95,1.05) AE47(14.35,1.05) AE49(15.75,1.05) AE51(17.15,1.05) AF1(-17.85,0.35) AF2(-17.15,0.35) AF3(-16.45,0.35) AF4(-15.75,0.35) AF5(-15.05,0.35) AF6(-14.35,0.35) AF7(-13.65,0.35) AF8(-12.95,0.35) AF9(-12.25,0.35) AF10(-11.55,0.35) AF11(-10.85,0.35) AF13(-9.45,0.35) AF14(-8.75,0.35) AF15(-8.05,0.35) AF16(-7.35,0.35) AF17(-6.65,0.35) AF18(-5.95,0.35) AF19(-5.25,0.35) AF20(-4.55,0.35) AF21(-3.85,0.35) AF22(-3.15,0.35) AF23(-2.45,0.35) AF24(-1.75,0.35) AF25(-1.05,0.35) AF26(-0.35,0.35) AF27(0.35,0.35) AF28(1.05,0.35) AF29(1.75,0.35) AF30(2.45,0.35) AF31(3.15,0.35) AF32(3.85,0.35) AF33(4.55,0.35) AF34(5.25,0.35) AF35(5.95,0.35) AF36(6.65,0.35) AF37(7.35,0.35) AF38(8.05,0.35) AF39(8.75,0.35) AF40(9.45,0.35) AF42(10.85,0.35) AF43(11.55,0.35) AF44(12.25,0.35) AF45(12.95,0.35) AF46(13.65,0.35) AF47(14.35,0.35) AF48(15.05,0.35) AF49(15.75,0.35) AF50(16.45,0.35) AF51(17.15,0.35) AF52(17.85,0.35) AG1(-17.85,-0.35) AG2(-17.15,-0.35) AG3(-16.45,-0.35) AG4(-15.75,-0.35) AG5(-15.05,-0.35) AG6(-14.35,-0.35) AG7(-13.65,-0.35) AG8(-12.95,-0.35) AG9(-12.25,-0.35) AG10(-11.55,-0.35) AG11(-10.85,-0.35) AG13(-9.45,-0.35) AG14(-8.75,-0.35) AG15(-8.05,-0.35) AG16(-7.35,-0.35) AG17(-6.65,-0.35) AG18(-5.95,-0.35) AG19(-5.25,-0.35) AG20(-4.55,-0.35) AG21(-3.85,-0.35) AG22(-3.15,-0.35) AG23(-2.45,-0.35) AG24(-1.75,-0.35) AG25(-1.05,-0.35) AG26(-0.35,-0.35) AG27(0.35,-0.35) AG28(1.05,-0.35) AG29(1.75,-0.35) AG30(2.45,-0.35) AG31(3.15,-0.35) AG32(3.85,-0.35) AG33(4.55,-0.35) AG34(5.25,-0.35) AG35(5.95,-0.35) AG36(6.65,-0.35) AG37(7.35,-0.35) AG38(8.05,-0.35) AG39(8.75,-0.35) AG40(9.45,-0.35) AG42(10.85,-0.35) AG43(11.55,-0.35) AG44(12.25,-0.35) AG45(12.95,-0.35) AG46(13.65,-0.35) AG47(14.35,-0.35) AG48(15.05,-0.35) AG49(15.75,-0.35) AG50(16.45,-0.35) AG51(17.15,-0.35) AG52(17.85,-0.35) AH2(-17.15,-1.05) AH4(-15.75,-1.05) AH6(-14.35,-1.05) AH8(-12.95,-1.05) AH10(-11.55,-1.05) AH14(-8.75,-1.05) AH15(-8.05,-1.05) AH16(-7.35,-1.05) AH17(-6.65,-1.05) AH18(-5.95,-1.05) AH19(-5.25,-1.05) AH20(-4.55,-1.05) AH21(-3.85,-1.05) AH22(-3.15,-1.05) AH23(-2.45,-1.05) AH24(-1.75,-1.05) AH25(-1.05,-1.05) AH26(-0.35,-1.05) AH27(0.35,-1.05) AH28(1.05,-1.05) AH29(1.75,-1.05) AH30(2.45,-1.05) AH31(3.15,-1.05) AH32(3.85,-1.05) AH33(4.55,-1.05) AH34(5.25,-1.05) AH35(5.95,-1.05) AH36(6.65,-1.05) AH37(7.35,-1.05) AH38(8.05,-1.05) AH39(8.75,-1.05) AH43(11.55,-1.05) AH45(12.95,-1.05) AH47(14.35,-1.05) AH49(15.75,-1.05) AH51(17.15,-1.05) AJ1(-17.85,-1.75) AJ2(-17.15,-1.75) AJ3(-16.45,-1.75) AJ4(-15.75,-1.75) AJ5(-15.05,-1.75) AJ6(-14.35,-1.75) AJ7(-13.65,-1.75) AJ8(-12.95,-1.75) AJ9(-12.25,-1.75) AJ10(-11.55,-1.75) AJ11(-10.85,-1.75) AJ14(-8.75,-1.75) AJ15(-8.05,-1.75) AJ16(-7.35,-1.75) AJ17(-6.65,-1.75) AJ18(-5.95,-1.75) AJ19(-5.25,-1.75) AJ20(-4.55,-1.75) AJ21(-3.85,-1.75) AJ22(-3.15,-1.75) AJ23(-2.45,-1.75) AJ24(-1.75,-1.75) AJ25(-1.05,-1.75) AJ26(-0.35,-1.75) AJ27(0.35,-1.75) AJ28(1.05,-1.75) AJ29(1.75,-1.75) AJ30(2.45,-1.75) AJ31(3.15,-1.75) AJ32(3.85,-1.75) AJ33(4.55,-1.75) AJ34(5.25,-1.75) AJ35(5.95,-1.75) AJ36(6.65,-1.75) AJ37(7.35,-1.75) AJ38(8.05,-1.75) AJ39(8.75,-1.75) AJ42(10.85,-1.75) AJ43(11.55,-1.75) AJ44(12.25,-1.75) AJ45(12.95,-1.75) AJ46(13.65,-1.75) AJ47(14.35,-1.75) AJ48(15.05,-1.75) AJ49(15.75,-1.75) AJ50(16.45,-1.75) AJ51(17.15,-1.75) AJ52(17.85,-1.75) AK1(-17.85,-2.45) AK2(-17.15,-2.45) AK3(-16.45,-2.45) AK4(-15.75,-2.45) AK5(-15.05,-2.45) AK6(-14.35,-2.45) AK7(-13.65,-2.45) AK8(-12.95,-2.45) AK9(-12.25,-2.45) AK10(-11.55,-2.45) AK11(-10.85,-2.45) AK14(-8.75,-2.45) AK15(-8.05,-2.45) AK16(-7.35,-2.45) AK17(-6.65,-2.45) AK18(-5.95,-2.45) AK19(-5.25,-2.45) AK20(-4.55,-2.45) AK21(-3.85,-2.45) AK22(-3.15,-2.45) AK23(-2.45,-2.45) AK24(-1.75,-2.45) AK25(-1.05,-2.45) AK26(-0.35,-2.45) AK27(0.35,-2.45) AK28(1.05,-2.45) AK29(1.75,-2.45) AK30(2.45,-2.45) AK31(3.15,-2.45) AK32(3.85,-2.45) AK33(4.55,-2.45) AK34(5.25,-2.45) AK35(5.95,-2.45) AK36(6.65,-2.45) AK37(7.35,-2.45) AK38(8.05,-2.45) AK39(8.75,-2.45) AK42(10.85,-2.45) AK43(11.55,-2.45) AK44(12.25,-2.45) AK45(12.95,-2.45) AK46(13.65,-2.45) AK47(14.35,-2.45) AK48(15.05,-2.45) AK49(15.75,-2.45) AK50(16.45,-2.45) AK51(17.15,-2.45) AK52(17.85,-2.45) AL2(-17.15,-3.15) AL4(-15.75,-3.15) AL6(-14.35,-3.15) AL8(-12.95,-3.15) AL10(-11.55,-3.15) AL13(-9.45,-3.15) AL14(-8.75,-3.15) AL15(-8.05,-3.15) AL16(-7.35,-3.15) AL17(-6.65,-3.15) AL18(-5.95,-3.15) AL19(-5.25,-3.15) AL20(-4.55,-3.15) AL21(-3.85,-3.15) AL22(-3.15,-3.15) AL23(-2.45,-3.15) AL24(-1.75,-3.15) AL25(-1.05,-3.15) AL26(-0.35,-3.15) AL27(0.35,-3.15) AL28(1.05,-3.15) AL29(1.75,-3.15) AL30(2.45,-3.15) AL31(3.15,-3.15) AL32(3.85,-3.15) AL33(4.55,-3.15) AL34(5.25,-3.15) AL35(5.95,-3.15) AL36(6.65,-3.15) AL37(7.35,-3.15) AL38(8.05,-3.15) AL39(8.75,-3.15) AL40(9.45,-3.15) AL43(11.55,-3.15) AL45(12.95,-3.15) AL47(14.35,-3.15) AL49(15.75,-3.15) AL51(17.15,-3.15) AM1(-17.85,-3.85) AM2(-17.15,-3.85) AM3(-16.45,-3.85) AM4(-15.75,-3.85) AM5(-15.05,-3.85) AM6(-14.35,-3.85) AM7(-13.65,-3.85) AM8(-12.95,-3.85) AM9(-12.25,-3.85) AM10(-11.55,-3.85) AM11(-10.85,-3.85) AM14(-8.75,-3.85) AM15(-8.05,-3.85) AM16(-7.35,-3.85) AM17(-6.65,-3.85) AM18(-5.95,-3.85) AM19(-5.25,-3.85) AM20(-4.55,-3.85) AM21(-3.85,-3.85) AM22(-3.15,-3.85) AM23(-2.45,-3.85) AM24(-1.75,-3.85) AM25(-1.05,-3.85) AM26(-0.35,-3.85) AM27(0.35,-3.85) AM28(1.05,-3.85) AM29(1.75,-3.85) AM30(2.45,-3.85) AM31(3.15,-3.85) AM32(3.85,-3.85) AM33(4.55,-3.85) AM34(5.25,-3.85) AM35(5.95,-3.85) AM36(6.65,-3.85) AM37(7.35,-3.85) AM38(8.05,-3.85) AM39(8.75,-3.85) AM42(10.85,-3.85) AM43(11.55,-3.85) AM44(12.25,-3.85) AM45(12.95,-3.85) AM46(13.65,-3.85) AM47(14.35,-3.85) AM48(15.05,-3.85) AM49(15.75,-3.85) AM50(16.45,-3.85) AM51(17.15,-3.85) AM52(17.85,-3.85) AN1(-17.85,-4.55) AN2(-17.15,-4.55) AN3(-16.45,-4.55) AN4(-15.75,-4.55) AN5(-15.05,-4.55) AN6(-14.35,-4.55) AN7(-13.65,-4.55) AN8(-12.95,-4.55) AN9(-12.25,-4.55) AN10(-11.55,-4.55) AN11(-10.85,-4.55) AN14(-8.75,-4.55) AN15(-8.05,-4.55) AN16(-7.35,-4.55) AN17(-6.65,-4.55) AN18(-5.95,-4.55) AN19(-5.25,-4.55) AN20(-4.55,-4.55) AN21(-3.85,-4.55) AN22(-3.15,-4.55) AN23(-2.45,-4.55) AN24(-1.75,-4.55) AN25(-1.05,-4.55) AN26(-0.35,-4.55) AN27(0.35,-4.55) AN28(1.05,-4.55) AN29(1.75,-4.55) AN30(2.45,-4.55) AN31(3.15,-4.55) AN32(3.85,-4.55) AN33(4.55,-4.55) AN34(5.25,-4.55) AN35(5.95,-4.55) AN36(6.65,-4.55) AN37(7.35,-4.55) AN38(8.05,-4.55) AN39(8.75,-4.55) AN42(10.85,-4.55) AN43(11.55,-4.55) AN44(12.25,-4.55) AN45(12.95,-4.55) AN46(13.65,-4.55) AN47(14.35,-4.55) AN48(15.05,-4.55) AN49(15.75,-4.55) AN50(16.45,-4.55) AN51(17.15,-4.55) AN52(17.85,-4.55) AP2(-17.15,-5.25) AP4(-15.75,-5.25) AP6(-14.35,-5.25) AP8(-12.95,-5.25) AP10(-11.55,-5.25) AP14(-8.75,-5.25) AP15(-8.05,-5.25) AP16(-7.35,-5.25) AP17(-6.65,-5.25) AP18(-5.95,-5.25) AP19(-5.25,-5.25) AP20(-4.55,-5.25) AP21(-3.85,-5.25) AP22(-3.15,-5.25) AP23(-2.45,-5.25) AP24(-1.75,-5.25) AP25(-1.05,-5.25) AP26(-0.35,-5.25) AP27(0.35,-5.25) AP28(1.05,-5.25) AP29(1.75,-5.25) AP30(2.45,-5.25) AP31(3.15,-5.25) AP32(3.85,-5.25) AP33(4.55,-5.25) AP34(5.25,-5.25) AP35(5.95,-5.25) AP36(6.65,-5.25) AP37(7.35,-5.25) AP38(8.05,-5.25) AP39(8.75,-5.25) AP43(11.55,-5.25) AP45(12.95,-5.25) AP47(14.35,-5.25) AP49(15.75,-5.25) AP51(17.15,-5.25) AR1(-17.85,-5.95) AR2(-17.15,-5.95) AR3(-16.45,-5.95) AR4(-15.75,-5.95) AR5(-15.05,-5.95) AR6(-14.35,-5.95) AR7(-13.65,-5.95) AR8(-12.95,-5.95) AR9(-12.25,-5.95) AR10(-11.55,-5.95) AR11(-10.85,-5.95) AR13(-9.45,-5.95) AR14(-8.75,-5.95) AR15(-8.05,-5.95) AR16(-7.35,-5.95) AR17(-6.65,-5.95) AR18(-5.95,-5.95) AR19(-5.25,-5.95) AR20(-4.55,-5.95) AR21(-3.85,-5.95) AR22(-3.15,-5.95) AR23(-2.45,-5.95) AR24(-1.75,-5.95) AR25(-1.05,-5.95) AR26(-0.35,-5.95) AR27(0.35,-5.95) AR28(1.05,-5.95) AR29(1.75,-5.95) AR30(2.45,-5.95) AR31(3.15,-5.95) AR32(3.85,-5.95) AR33(4.55,-5.95) AR34(5.25,-5.95) AR35(5.95,-5.95) AR36(6.65,-5.95) AR37(7.35,-5.95) AR38(8.05,-5.95) AR39(8.75,-5.95) AR40(9.45,-5.95) AR42(10.85,-5.95) AR43(11.55,-5.95) AR44(12.25,-5.95) AR45(12.95,-5.95) AR46(13.65,-5.95) AR47(14.35,-5.95) AR48(15.05,-5.95) AR49(15.75,-5.95) AR50(16.45,-5.95) AR51(17.15,-5.95) AR52(17.85,-5.95) AT1(-17.85,-6.65) AT2(-17.15,-6.65) AT3(-16.45,-6.65) AT4(-15.75,-6.65) AT5(-15.05,-6.65) AT6(-14.35,-6.65) AT7(-13.65,-6.65) AT8(-12.95,-6.65) AT9(-12.25,-6.65) AT10(-11.55,-6.65) AT11(-10.85,-6.65) AT14(-8.75,-6.65) AT15(-8.05,-6.65) AT16(-7.35,-6.65) AT17(-6.65,-6.65) AT18(-5.95,-6.65) AT19(-5.25,-6.65) AT20(-4.55,-6.65) AT21(-3.85,-6.65) AT22(-3.15,-6.65) AT23(-2.45,-6.65) AT24(-1.75,-6.65) AT25(-1.05,-6.65) AT26(-0.35,-6.65) AT27(0.35,-6.65) AT28(1.05,-6.65) AT29(1.75,-6.65) AT30(2.45,-6.65) AT31(3.15,-6.65) AT32(3.85,-6.65) AT33(4.55,-6.65) AT34(5.25,-6.65) AT35(5.95,-6.65) AT36(6.65,-6.65) AT37(7.35,-6.65) AT38(8.05,-6.65) AT39(8.75,-6.65) AT42(10.85,-6.65) AT43(11.55,-6.65) AT44(12.25,-6.65) AT45(12.95,-6.65) AT46(13.65,-6.65) AT47(14.35,-6.65) AT48(15.05,-6.65) AT49(15.75,-6.65) AT50(16.45,-6.65) AT51(17.15,-6.65) AT52(17.85,-6.65) AU2(-17.15,-7.35) AU4(-15.75,-7.35) AU6(-14.35,-7.35) AU8(-12.95,-7.35) AU10(-11.55,-7.35) AU14(-8.75,-7.35) AU15(-8.05,-7.35) AU16(-7.35,-7.35) AU17(-6.65,-7.35) AU18(-5.95,-7.35) AU19(-5.25,-7.35) AU20(-4.55,-7.35) AU21(-3.85,-7.35) AU22(-3.15,-7.35) AU23(-2.45,-7.35) AU24(-1.75,-7.35) AU25(-1.05,-7.35) AU26(-0.35,-7.35) AU27(0.35,-7.35) AU28(1.05,-7.35) AU29(1.75,-7.35) AU30(2.45,-7.35) AU31(3.15,-7.35) AU32(3.85,-7.35) AU33(4.55,-7.35) AU34(5.25,-7.35) AU35(5.95,-7.35) AU36(6.65,-7.35) AU37(7.35,-7.35) AU38(8.05,-7.35) AU39(8.75,-7.35) AU43(11.55,-7.35) AU45(12.95,-7.35) AU47(14.35,-7.35) AU49(15.75,-7.35) AU51(17.15,-7.35) AV1(-17.85,-8.05) AV2(-17.15,-8.05) AV3(-16.45,-8.05) AV4(-15.75,-8.05) AV5(-15.05,-8.05) AV6(-14.35,-8.05) AV7(-13.65,-8.05) AV8(-12.95,-8.05) AV9(-12.25,-8.05) AV10(-11.55,-8.05) AV11(-10.85,-8.05) AV14(-8.75,-8.05) AV15(-8.05,-8.05) AV16(-7.35,-8.05) AV17(-6.65,-8.05) AV18(-5.95,-8.05) AV19(-5.25,-8.05) AV20(-4.55,-8.05) AV21(-3.85,-8.05) AV22(-3.15,-8.05) AV23(-2.45,-8.05) AV24(-1.75,-8.05) AV25(-1.05,-8.05) AV26(-0.35,-8.05) AV27(0.35,-8.05) AV28(1.05,-8.05) AV29(1.75,-8.05) AV30(2.45,-8.05) AV31(3.15,-8.05) AV32(3.85,-8.05) AV33(4.55,-8.05) AV34(5.25,-8.05) AV35(5.95,-8.05) AV36(6.65,-8.05) AV37(7.35,-8.05) AV38(8.05,-8.05) AV39(8.75,-8.05) AV42(10.85,-8.05) AV43(11.55,-8.05) AV44(12.25,-8.05) AV45(12.95,-8.05) AV46(13.65,-8.05) AV47(14.35,-8.05) AV48(15.05,-8.05) AV49(15.75,-8.05) AV50(16.45,-8.05) AV51(17.15,-8.05) AV52(17.85,-8.05) AW1(-17.85,-8.75) AW2(-17.15,-8.75) AW3(-16.45,-8.75) AW4(-15.75,-8.75) AW5(-15.05,-8.75) AW6(-14.35,-8.75) AW7(-13.65,-8.75) AW8(-12.95,-8.75) AW9(-12.25,-8.75) AW10(-11.55,-8.75) AW11(-10.85,-8.75) AW13(-9.45,-8.75) AW14(-8.75,-8.75) AW15(-8.05,-8.75) AW16(-7.35,-8.75) AW17(-6.65,-8.75) AW18(-5.95,-8.75) AW19(-5.25,-8.75) AW20(-4.55,-8.75) AW21(-3.85,-8.75) AW22(-3.15,-8.75) AW23(-2.45,-8.75) AW24(-1.75,-8.75) AW25(-1.05,-8.75) AW26(-0.35,-8.75) AW27(0.35,-8.75) AW28(1.05,-8.75) AW29(1.75,-8.75) AW30(2.45,-8.75) AW31(3.15,-8.75) AW32(3.85,-8.75) AW33(4.55,-8.75) AW34(5.25,-8.75) AW35(5.95,-8.75) AW36(6.65,-8.75) AW37(7.35,-8.75) AW38(8.05,-8.75) AW39(8.75,-8.75) AW40(9.45,-8.75) AW42(10.85,-8.75) AW43(11.55,-8.75) AW44(12.25,-8.75) AW45(12.95,-8.75) AW46(13.65,-8.75) AW47(14.35,-8.75) AW48(15.05,-8.75) AW49(15.75,-8.75) AW50(16.45,-8.75) AW51(17.15,-8.75) AW52(17.85,-8.75) AY2(-17.15,-9.45) AY4(-15.75,-9.45) AY6(-14.35,-9.45) AY8(-12.95,-9.45) AY10(-11.55,-9.45) AY14(-8.75,-9.45) AY18(-5.95,-9.45) AY22(-3.15,-9.45) AY26(-0.35,-9.45) AY27(0.35,-9.45) AY31(3.15,-9.45) AY35(5.95,-9.45) AY39(8.75,-9.45) AY43(11.55,-9.45) AY45(12.95,-9.45) AY47(14.35,-9.45) AY49(15.75,-9.45) AY51(17.15,-9.45) B1(-17.85,17.15) B2(-17.15,17.15) B3(-16.45,17.15) B4(-15.75,17.15) B5(-15.05,17.15) B6(-14.35,17.15) B7(-13.65,17.15) B8(-12.95,17.15) B9(-12.25,17.15) B10(-11.55,17.15) B11(-10.85,17.15) B12(-10.15,17.15) B13(-9.45,17.15) B14(-8.75,17.15) B15(-8.05,17.15) B16(-7.35,17.15) B17(-6.65,17.15) B18(-5.95,17.15) B19(-5.25,17.15) B20(-4.55,17.15) B21(-3.85,17.15) B22(-3.15,17.15) B23(-2.45,17.15) B24(-1.75,17.15) B25(-1.05,17.15) B26(-0.35,17.15) B27(0.35,17.15) B28(1.05,17.15) B29(1.75,17.15) B30(2.45,17.15) B31(3.15,17.15) B32(3.85,17.15) B33(4.55,17.15) B34(5.25,17.15) B35(5.95,17.15) B36(6.65,17.15) B37(7.35,17.15) B38(8.05,17.15) B39(8.75,17.15) B40(9.45,17.15) B41(10.15,17.15) B42(10.85,17.15) B43(11.55,17.15) B44(12.25,17.15) B45(12.95,17.15) B46(13.65,17.15) B47(14.35,17.15) B48(15.05,17.15) B49(15.75,17.15) B50(16.45,17.15) B51(17.15,17.15) B52(17.85,17.15) BA1(-17.85,-10.15) BA2(-17.15,-10.15) BA3(-16.45,-10.15) BA4(-15.75,-10.15) BA5(-15.05,-10.15) BA6(-14.35,-10.15) BA7(-13.65,-10.15) BA8(-12.95,-10.15) BA9(-12.25,-10.15) BA10(-11.55,-10.15) BA43(11.55,-10.15) BA44(12.25,-10.15) BA45(12.95,-10.15) BA46(13.65,-10.15) BA47(14.35,-10.15) BA48(15.05,-10.15) BA49(15.75,-10.15) BA50(16.45,-10.15) BA51(17.15,-10.15) BA52(17.85,-10.15) BB1(-17.85,-10.85) BB2(-17.15,-10.85) BB3(-16.45,-10.85) BB4(-15.75,-10.85) BB5(-15.05,-10.85) BB6(-14.35,-10.85) BB7(-13.65,-10.85) BB8(-12.95,-10.85) BB14(-8.75,-10.85) BB15(-8.05,-10.85) BB17(-6.65,-10.85) BB18(-5.95,-10.85) BB20(-4.55,-10.85) BB21(-3.85,-10.85) BB23(-2.45,-10.85) BB24(-1.75,-10.85) BB26(-0.35,-10.85) BB27(0.35,-10.85) BB29(1.75,-10.85) BB30(2.45,-10.85) BB32(3.85,-10.85) BB33(4.55,-10.85) BB35(5.95,-10.85) BB36(6.65,-10.85) BB38(8.05,-10.85) BB39(8.75,-10.85) BB45(12.95,-10.85) BB46(13.65,-10.85) BB47(14.35,-10.85) BB48(15.05,-10.85) BB49(15.75,-10.85) BB50(16.45,-10.85) BB51(17.15,-10.85) BB52(17.85,-10.85) BC2(-17.15,-11.55) BC4(-15.75,-11.55) BC6(-14.35,-11.55) BC8(-12.95,-11.55) BC12(-10.15,-11.55) BC13(-9.45,-11.55) BC14(-8.75,-11.55) BC15(-8.05,-11.55) BC16(-7.35,-11.55) BC17(-6.65,-11.55) BC18(-5.95,-11.55) BC19(-5.25,-11.55) BC20(-4.55,-11.55) BC21(-3.85,-11.55) BC22(-3.15,-11.55) BC23(-2.45,-11.55) BC24(-1.75,-11.55) BC25(-1.05,-11.55) BC26(-0.35,-11.55) BC27(0.35,-11.55) BC28(1.05,-11.55) BC29(1.75,-11.55) BC30(2.45,-11.55) BC31(3.15,-11.55) BC32(3.85,-11.55) BC33(4.55,-11.55) BC34(5.25,-11.55) BC35(5.95,-11.55) BC36(6.65,-11.55) BC37(7.35,-11.55) BC38(8.05,-11.55) BC39(8.75,-11.55) BC40(9.45,-11.55) BC41(10.15,-11.55) BC45(12.95,-11.55) BC47(14.35,-11.55) BC49(15.75,-11.55) BC51(17.15,-11.55) BD1(-17.85,-12.25) BD2(-17.15,-12.25) BD3(-16.45,-12.25) BD4(-15.75,-12.25) BD5(-15.05,-12.25) BD6(-14.35,-12.25) BD7(-13.65,-12.25) BD12(-10.15,-12.25) BD14(-8.75,-12.25) BD15(-8.05,-12.25) BD17(-6.65,-12.25) BD18(-5.95,-12.25) BD20(-4.55,-12.25) BD21(-3.85,-12.25) BD23(-2.45,-12.25) BD24(-1.75,-12.25) BD26(-0.35,-12.25) BD27(0.35,-12.25) BD29(1.75,-12.25) BD30(2.45,-12.25) BD32(3.85,-12.25) BD33(4.55,-12.25) BD35(5.95,-12.25) BD36(6.65,-12.25) BD38(8.05,-12.25) BD39(8.75,-12.25) BD41(10.15,-12.25) BD46(13.65,-12.25) BD47(14.35,-12.25) BD48(15.05,-12.25) BD49(15.75,-12.25) BD50(16.45,-12.25) BD51(17.15,-12.25) BD52(17.85,-12.25) BE1(-17.85,-12.95) BE2(-17.15,-12.95) BE3(-16.45,-12.95) BE4(-15.75,-12.95) BE5(-15.05,-12.95) BE6(-14.35,-12.95) BE7(-13.65,-12.95) BE10(-11.55,-12.95) BE11(-10.85,-12.95) BE12(-10.15,-12.95) BE13(-9.45,-12.95) BE14(-8.75,-12.95) BE15(-8.05,-12.95) BE16(-7.35,-12.95) BE17(-6.65,-12.95) BE18(-5.95,-12.95) BE19(-5.25,-12.95) BE20(-4.55,-12.95) BE21(-3.85,-12.95) BE22(-3.15,-12.95) BE23(-2.45,-12.95) BE24(-1.75,-12.95) BE25(-1.05,-12.95) BE26(-0.35,-12.95) BE27(0.35,-12.95) BE28(1.05,-12.95) BE29(1.75,-12.95) BE30(2.45,-12.95) BE31(3.15,-12.95) BE32(3.85,-12.95) BE33(4.55,-12.95) BE34(5.25,-12.95) BE35(5.95,-12.95) BE36(6.65,-12.95) BE37(7.35,-12.95) BE38(8.05,-12.95) BE39(8.75,-12.95) BE40(9.45,-12.95) BE41(10.15,-12.95) BE42(10.85,-12.95) BE43(11.55,-12.95) BE46(13.65,-12.95) BE47(14.35,-12.95) BE48(15.05,-12.95) BE49(15.75,-12.95) BE50(16.45,-12.95) BE51(17.15,-12.95) BE52(17.85,-12.95) BF2(-17.15,-13.65) BF4(-15.75,-13.65) BF6(-14.35,-13.65) BF8(-12.95,-13.65) BF9(-12.25,-13.65) BF11(-10.85,-13.65) BF12(-10.15,-13.65) BF14(-8.75,-13.65) BF15(-8.05,-13.65) BF17(-6.65,-13.65) BF18(-5.95,-13.65) BF20(-4.55,-13.65) BF21(-3.85,-13.65) BF23(-2.45,-13.65) BF24(-1.75,-13.65) BF26(-0.35,-13.65) BF27(0.35,-13.65) BF29(1.75,-13.65) BF30(2.45,-13.65) BF32(3.85,-13.65) BF33(4.55,-13.65) BF35(5.95,-13.65) BF36(6.65,-13.65) BF38(8.05,-13.65) BF39(8.75,-13.65) BF41(10.15,-13.65) BF42(10.85,-13.65) BF44(12.25,-13.65) BF45(12.95,-13.65) BF47(14.35,-13.65) BF49(15.75,-13.65) BF51(17.15,-13.65) BG1(-17.85,-14.35) BG2(-17.15,-14.35) BG3(-16.45,-14.35) BG4(-15.75,-14.35) BG5(-15.05,-14.35) BG6(-14.35,-14.35) BG7(-13.65,-14.35) BG8(-12.95,-14.35) BG9(-12.25,-14.35) BG10(-11.55,-14.35) BG11(-10.85,-14.35) BG12(-10.15,-14.35) BG13(-9.45,-14.35) BG14(-8.75,-14.35) BG15(-8.05,-14.35) BG16(-7.35,-14.35) BG17(-6.65,-14.35) BG18(-5.95,-14.35) BG19(-5.25,-14.35) BG20(-4.55,-14.35) BG21(-3.85,-14.35) BG22(-3.15,-14.35) BG23(-2.45,-14.35) BG24(-1.75,-14.35) BG25(-1.05,-14.35) BG26(-0.35,-14.35) BG27(0.35,-14.35) BG28(1.05,-14.35) BG29(1.75,-14.35) BG30(2.45,-14.35) BG31(3.15,-14.35) BG32(3.85,-14.35) BG33(4.55,-14.35) BG34(5.25,-14.35) BG35(5.95,-14.35) BG36(6.65,-14.35) BG37(7.35,-14.35) BG38(8.05,-14.35) BG39(8.75,-14.35) BG40(9.45,-14.35) BG41(10.15,-14.35) BG42(10.85,-14.35) BG43(11.55,-14.35) BG44(12.25,-14.35) BG45(12.95,-14.35) BG46(13.65,-14.35) BG47(14.35,-14.35) BG48(15.05,-14.35) BG49(15.75,-14.35) BG50(16.45,-14.35) BG51(17.15,-14.35) BG52(17.85,-14.35) BH1(-17.85,-15.05) BH2(-17.15,-15.05) BH3(-16.45,-15.05) BH4(-15.75,-15.05) BH5(-15.05,-15.05) BH6(-14.35,-15.05) BH8(-12.95,-15.05) BH9(-12.25,-15.05) BH11(-10.85,-15.05) BH12(-10.15,-15.05) BH14(-8.75,-15.05) BH15(-8.05,-15.05) BH17(-6.65,-15.05) BH18(-5.95,-15.05) BH20(-4.55,-15.05) BH21(-3.85,-15.05) BH23(-2.45,-15.05) BH24(-1.75,-15.05) BH26(-0.35,-15.05) BH27(0.35,-15.05) BH29(1.75,-15.05) BH30(2.45,-15.05) BH32(3.85,-15.05) BH33(4.55,-15.05) BH35(5.95,-15.05) BH36(6.65,-15.05) BH38(8.05,-15.05) BH39(8.75,-15.05) BH41(10.15,-15.05) BH42(10.85,-15.05) BH44(12.25,-15.05) BH45(12.95,-15.05) BH47(14.35,-15.05) BH48(15.05,-15.05) BH49(15.75,-15.05) BH50(16.45,-15.05) BH51(17.15,-15.05) BH52(17.85,-15.05) BJ1(-17.85,-15.75) BJ2(-17.15,-15.75) BJ3(-16.45,-15.75) BJ4(-15.75,-15.75) BJ5(-15.05,-15.75) BJ6(-14.35,-15.75) BJ7(-13.65,-15.75) BJ8(-12.95,-15.75) BJ9(-12.25,-15.75) BJ10(-11.55,-15.75) BJ11(-10.85,-15.75) BJ12(-10.15,-15.75) BJ13(-9.45,-15.75) BJ14(-8.75,-15.75) BJ15(-8.05,-15.75) BJ16(-7.35,-15.75) BJ17(-6.65,-15.75) BJ18(-5.95,-15.75) BJ19(-5.25,-15.75) BJ20(-4.55,-15.75) BJ21(-3.85,-15.75) BJ22(-3.15,-15.75) BJ23(-2.45,-15.75) BJ24(-1.75,-15.75) BJ25(-1.05,-15.75) BJ26(-0.35,-15.75) BJ27(0.35,-15.75) BJ28(1.05,-15.75) BJ29(1.75,-15.75) BJ30(2.45,-15.75) BJ31(3.15,-15.75) BJ32(3.85,-15.75) BJ33(4.55,-15.75) BJ34(5.25,-15.75) BJ35(5.95,-15.75) BJ36(6.65,-15.75) BJ37(7.35,-15.75) BJ38(8.05,-15.75) BJ39(8.75,-15.75) BJ40(9.45,-15.75) BJ41(10.15,-15.75) BJ42(10.85,-15.75) BJ43(11.55,-15.75) BJ44(12.25,-15.75) BJ45(12.95,-15.75) BJ46(13.65,-15.75) BJ47(14.35,-15.75) BJ48(15.05,-15.75) BJ49(15.75,-15.75) BJ50(16.45,-15.75) BJ51(17.15,-15.75) BJ52(17.85,-15.75) BK1(-17.85,-16.45) BK2(-17.15,-16.45) BK3(-16.45,-16.45) BK4(-15.75,-16.45) BK5(-15.05,-16.45) BK6(-14.35,-16.45) BK8(-12.95,-16.45) BK9(-12.25,-16.45) BK11(-10.85,-16.45) BK12(-10.15,-16.45) BK14(-8.75,-16.45) BK15(-8.05,-16.45) BK17(-6.65,-16.45) BK18(-5.95,-16.45) BK20(-4.55,-16.45) BK21(-3.85,-16.45) BK23(-2.45,-16.45) BK24(-1.75,-16.45) BK26(-0.35,-16.45) BK27(0.35,-16.45) BK29(1.75,-16.45) BK30(2.45,-16.45) BK32(3.85,-16.45) BK33(4.55,-16.45) BK35(5.95,-16.45) BK36(6.65,-16.45) BK38(8.05,-16.45) BK39(8.75,-16.45) BK41(10.15,-16.45) BK42(10.85,-16.45) BK44(12.25,-16.45) BK45(12.95,-16.45) BK47(14.35,-16.45) BK48(15.05,-16.45) BK49(15.75,-16.45) BK50(16.45,-16.45) BK51(17.15,-16.45) BK52(17.85,-16.45) BL1(-17.85,-17.15) BL2(-17.15,-17.15) BL3(-16.45,-17.15) BL4(-15.75,-17.15) BL5(-15.05,-17.15) BL6(-14.35,-17.15) BL7(-13.65,-17.15) BL8(-12.95,-17.15) BL9(-12.25,-17.15) BL10(-11.55,-17.15) BL11(-10.85,-17.15) BL12(-10.15,-17.15) BL13(-9.45,-17.15) BL14(-8.75,-17.15) BL15(-8.05,-17.15) BL16(-7.35,-17.15) BL17(-6.65,-17.15) BL18(-5.95,-17.15) BL19(-5.25,-17.15) BL20(-4.55,-17.15) BL21(-3.85,-17.15) BL22(-3.15,-17.15) BL23(-2.45,-17.15) BL24(-1.75,-17.15) BL25(-1.05,-17.15) BL26(-0.35,-17.15) BL27(0.35,-17.15) BL28(1.05,-17.15) BL29(1.75,-17.15) BL30(2.45,-17.15) BL31(3.15,-17.15) BL32(3.85,-17.15) BL33(4.55,-17.15) BL34(5.25,-17.15) BL35(5.95,-17.15) BL36(6.65,-17.15) BL37(7.35,-17.15) BL38(8.05,-17.15) BL39(8.75,-17.15) BL40(9.45,-17.15) BL41(10.15,-17.15) BL42(10.85,-17.15) BL43(11.55,-17.15) BL44(12.25,-17.15) BL45(12.95,-17.15) BL46(13.65,-17.15) BL47(14.35,-17.15) BL48(15.05,-17.15) BL49(15.75,-17.15) BL50(16.45,-17.15) BL51(17.15,-17.15) BL52(17.85,-17.15) BM2(-17.15,-17.85) BM3(-16.45,-17.85) BM4(-15.75,-17.85) BM5(-15.05,-17.85) BM6(-14.35,-17.85) BM8(-12.95,-17.85) BM9(-12.25,-17.85) BM11(-10.85,-17.85) BM12(-10.15,-17.85) BM14(-8.75,-17.85) BM15(-8.05,-17.85) BM17(-6.65,-17.85) BM18(-5.95,-17.85) BM20(-4.55,-17.85) BM21(-3.85,-17.85) BM23(-2.45,-17.85) BM24(-1.75,-17.85) BM26(-0.35,-17.85) BM27(0.35,-17.85) BM29(1.75,-17.85) BM30(2.45,-17.85) BM32(3.85,-17.85) BM33(4.55,-17.85) BM35(5.95,-17.85) BM36(6.65,-17.85) BM38(8.05,-17.85) BM39(8.75,-17.85) BM41(10.15,-17.85) BM42(10.85,-17.85) BM44(12.25,-17.85) BM45(12.95,-17.85) BM47(14.35,-17.85) BM48(15.05,-17.85) BM49(15.75,-17.85) BM50(16.45,-17.85) BM51(17.15,-17.85) C1(-17.85,16.45) C2(-17.15,16.45) C3(-16.45,16.45) C4(-15.75,16.45) C5(-15.05,16.45) C6(-14.35,16.45) C8(-12.95,16.45) C9(-12.25,16.45) C11(-10.85,16.45) C12(-10.15,16.45) C14(-8.75,16.45) C15(-8.05,16.45) C17(-6.65,16.45) C18(-5.95,16.45) C20(-4.55,16.45) C21(-3.85,16.45) C23(-2.45,16.45) C24(-1.75,16.45) C26(-0.35,16.45) C27(0.35,16.45) C29(1.75,16.45) C30(2.45,16.45) C32(3.85,16.45) C33(4.55,16.45) C35(5.95,16.45) C36(6.65,16.45) C38(8.05,16.45) C39(8.75,16.45) C41(10.15,16.45) C42(10.85,16.45) C44(12.25,16.45) C45(12.95,16.45) C47(14.35,16.45) C48(15.05,16.45) C49(15.75,16.45) C50(16.45,16.45) C51(17.15,16.45) C52(17.85,16.45) D1(-17.85,15.75) D2(-17.15,15.75) D3(-16.45,15.75) D4(-15.75,15.75) D5(-15.05,15.75) D6(-14.35,15.75) D7(-13.65,15.75) D8(-12.95,15.75) D9(-12.25,15.75) D10(-11.55,15.75) D11(-10.85,15.75) D12(-10.15,15.75) D13(-9.45,15.75) D14(-8.75,15.75) D15(-8.05,15.75) D16(-7.35,15.75) D17(-6.65,15.75) D18(-5.95,15.75) D19(-5.25,15.75) D20(-4.55,15.75) D21(-3.85,15.75) D22(-3.15,15.75) D23(-2.45,15.75) D24(-1.75,15.75) D25(-1.05,15.75) D26(-0.35,15.75) D27(0.35,15.75) D28(1.05,15.75) D29(1.75,15.75) D30(2.45,15.75) D31(3.15,15.75) D32(3.85,15.75) D33(4.55,15.75) D34(5.25,15.75) D35(5.95,15.75) D36(6.65,15.75) D37(7.35,15.75) D38(8.05,15.75) D39(8.75,15.75) D40(9.45,15.75) D41(10.15,15.75) D42(10.85,15.75) D43(11.55,15.75) D44(12.25,15.75) D45(12.95,15.75) D46(13.65,15.75) D47(14.35,15.75) D48(15.05,15.75) D49(15.75,15.75) D50(16.45,15.75) D51(17.15,15.75) D52(17.85,15.75) E1(-17.85,15.05) E2(-17.15,15.05) E3(-16.45,15.05) E4(-15.75,15.05) E5(-15.05,15.05) E6(-14.35,15.05) E8(-12.95,15.05) E9(-12.25,15.05) E11(-10.85,15.05) E12(-10.15,15.05) E14(-8.75,15.05) E15(-8.05,15.05) E17(-6.65,15.05) E18(-5.95,15.05) E20(-4.55,15.05) E21(-3.85,15.05) E23(-2.45,15.05) E24(-1.75,15.05) E26(-0.35,15.05) E27(0.35,15.05) E29(1.75,15.05) E30(2.45,15.05) E32(3.85,15.05) E33(4.55,15.05) E35(5.95,15.05) E36(6.65,15.05) E38(8.05,15.05) E39(8.75,15.05) E41(10.15,15.05) E42(10.85,15.05) E44(12.25,15.05) E45(12.95,15.05) E47(14.35,15.05) E48(15.05,15.05) E49(15.75,15.05) E50(16.45,15.05) E51(17.15,15.05) E52(17.85,15.05) F1(-17.85,14.35) F2(-17.15,14.35) F3(-16.45,14.35) F4(-15.75,14.35) F5(-15.05,14.35) F6(-14.35,14.35) F7(-13.65,14.35) F8(-12.95,14.35) F9(-12.25,14.35) F10(-11.55,14.35) F11(-10.85,14.35) F12(-10.15,14.35) F13(-9.45,14.35) F14(-8.75,14.35) F15(-8.05,14.35) F16(-7.35,14.35) F17(-6.65,14.35) F18(-5.95,14.35) F19(-5.25,14.35) F20(-4.55,14.35) F21(-3.85,14.35) F22(-3.15,14.35) F23(-2.45,14.35) F24(-1.75,14.35) F25(-1.05,14.35) F26(-0.35,14.35) F27(0.35,14.35) F28(1.05,14.35) F29(1.75,14.35) F30(2.45,14.35) F31(3.15,14.35) F32(3.85,14.35) F33(4.55,14.35) F34(5.25,14.35) F35(5.95,14.35) F36(6.65,14.35) F37(7.35,14.35) F38(8.05,14.35) F39(8.75,14.35) F40(9.45,14.35) F41(10.15,14.35) F42(10.85,14.35) F43(11.55,14.35) F44(12.25,14.35) F45(12.95,14.35) F46(13.65,14.35) F47(14.35,14.35) F48(15.05,14.35) F49(15.75,14.35) F50(16.45,14.35) F51(17.15,14.35) F52(17.85,14.35) G2(-17.15,13.65) G4(-15.75,13.65) G6(-14.35,13.65) G8(-12.95,13.65) G9(-12.25,13.65) G11(-10.85,13.65) G12(-10.15,13.65) G14(-8.75,13.65) G15(-8.05,13.65) G17(-6.65,13.65) G18(-5.95,13.65) G20(-4.55,13.65) G21(-3.85,13.65) G23(-2.45,13.65) G24(-1.75,13.65) G26(-0.35,13.65) G27(0.35,13.65) G29(1.75,13.65) G30(2.45,13.65) G32(3.85,13.65) G33(4.55,13.65) G35(5.95,13.65) G36(6.65,13.65) G38(8.05,13.65) G39(8.75,13.65) G41(10.15,13.65) G42(10.85,13.65) G44(12.25,13.65) G45(12.95,13.65) G47(14.35,13.65) G49(15.75,13.65) G51(17.15,13.65) H1(-17.85,12.95) H2(-17.15,12.95) H3(-16.45,12.95) H4(-15.75,12.95) H5(-15.05,12.95) H6(-14.35,12.95) H7(-13.65,12.95) H10(-11.55,12.95) H11(-10.85,12.95) H12(-10.15,12.95) H13(-9.45,12.95) H14(-8.75,12.95) H15(-8.05,12.95) H16(-7.35,12.95) H17(-6.65,12.95) H18(-5.95,12.95) H19(-5.25,12.95) H20(-4.55,12.95) H21(-3.85,12.95) H22(-3.15,12.95) H23(-2.45,12.95) H24(-1.75,12.95) H25(-1.05,12.95) H26(-0.35,12.95) H27(0.35,12.95) H28(1.05,12.95) H29(1.75,12.95) H30(2.45,12.95) H31(3.15,12.95) H32(3.85,12.95) H33(4.55,12.95) H34(5.25,12.95) H35(5.95,12.95) H36(6.65,12.95) H37(7.35,12.95) H38(8.05,12.95) H39(8.75,12.95) H40(9.45,12.95) H41(10.15,12.95) H42(10.85,12.95) H43(11.55,12.95) H46(13.65,12.95) H47(14.35,12.95) H48(15.05,12.95) H49(15.75,12.95) H50(16.45,12.95) H51(17.15,12.95) H52(17.85,12.95) J1(-17.85,12.25) J2(-17.15,12.25) J3(-16.45,12.25) J4(-15.75,12.25) J5(-15.05,12.25) J6(-14.35,12.25) J7(-13.65,12.25) J12(-10.15,12.25) J14(-8.75,12.25) J15(-8.05,12.25) J17(-6.65,12.25) J18(-5.95,12.25) J20(-4.55,12.25) J21(-3.85,12.25) J23(-2.45,12.25) J24(-1.75,12.25) J26(-0.35,12.25) J27(0.35,12.25) J29(1.75,12.25) J30(2.45,12.25) J32(3.85,12.25) J33(4.55,12.25) J35(5.95,12.25) J36(6.65,12.25) J38(8.05,12.25) J39(8.75,12.25) J41(10.15,12.25) J46(13.65,12.25) J47(14.35,12.25) J48(15.05,12.25) J49(15.75,12.25) J50(16.45,12.25) J51(17.15,12.25) J52(17.85,12.25) K2(-17.15,11.55) K4(-15.75,11.55) K6(-14.35,11.55) K8(-12.95,11.55) K12(-10.15,11.55) K13(-9.45,11.55) K14(-8.75,11.55) K15(-8.05,11.55) K16(-7.35,11.55) K17(-6.65,11.55) K18(-5.95,11.55) K19(-5.25,11.55) K20(-4.55,11.55) K21(-3.85,11.55) K22(-3.15,11.55) K23(-2.45,11.55) K24(-1.75,11.55) K25(-1.05,11.55) K26(-0.35,11.55) K27(0.35,11.55) K28(1.05,11.55) K29(1.75,11.55) K30(2.45,11.55) K31(3.15,11.55) K32(3.85,11.55) K33(4.55,11.55) K34(5.25,11.55) K35(5.95,11.55) K36(6.65,11.55) K37(7.35,11.55) K38(8.05,11.55) K39(8.75,11.55) K40(9.45,11.55) K41(10.15,11.55) K45(12.95,11.55) K47(14.35,11.55) K49(15.75,11.55) K51(17.15,11.55) L1(-17.85,10.85) L2(-17.15,10.85) L3(-16.45,10.85) L4(-15.75,10.85) L5(-15.05,10.85) L6(-14.35,10.85) L7(-13.65,10.85) L8(-12.95,10.85) L14(-8.75,10.85) L15(-8.05,10.85) L17(-6.65,10.85) L18(-5.95,10.85) L20(-4.55,10.85) L21(-3.85,10.85) L23(-2.45,10.85) L24(-1.75,10.85) L26(-0.35,10.85) L27(0.35,10.85) L29(1.75,10.85) L30(2.45,10.85) L32(3.85,10.85) L33(4.55,10.85) L35(5.95,10.85) L36(6.65,10.85) L38(8.05,10.85) L39(8.75,10.85) L45(12.95,10.85) L46(13.65,10.85) L47(14.35,10.85) L48(15.05,10.85) L49(15.75,10.85) L50(16.45,10.85) L51(17.15,10.85) L52(17.85,10.85) M1(-17.85,10.15) M2(-17.15,10.15) M3(-16.45,10.15) M4(-15.75,10.15) M5(-15.05,10.15) M6(-14.35,10.15) M7(-13.65,10.15) M8(-12.95,10.15) M9(-12.25,10.15) M10(-11.55,10.15) M43(11.55,10.15) M44(12.25,10.15) M45(12.95,10.15) M46(13.65,10.15) M47(14.35,10.15) M48(15.05,10.15) M49(15.75,10.15) M50(16.45,10.15) M51(17.15,10.15) M52(17.85,10.15) N2(-17.15,9.45) N4(-15.75,9.45) N6(-14.35,9.45) N8(-12.95,9.45) N10(-11.55,9.45) N14(-8.75,9.45) N18(-5.95,9.45) N22(-3.15,9.45) N26(-0.35,9.45) N27(0.35,9.45) N31(3.15,9.45) N35(5.95,9.45) N39(8.75,9.45) N43(11.55,9.45) N45(12.95,9.45) N47(14.35,9.45) N49(15.75,9.45) N51(17.15,9.45) P1(-17.85,8.75) P2(-17.15,8.75) P3(-16.45,8.75) P4(-15.75,8.75) P5(-15.05,8.75) P6(-14.35,8.75) P7(-13.65,8.75) P8(-12.95,8.75) P9(-12.25,8.75) P10(-11.55,8.75) P11(-10.85,8.75) P13(-9.45,8.75) P14(-8.75,8.75) P15(-8.05,8.75) P16(-7.35,8.75) P17(-6.65,8.75) P18(-5.95,8.75) P19(-5.25,8.75) P20(-4.55,8.75) P21(-3.85,8.75) P22(-3.15,8.75) P23(-2.45,8.75) P24(-1.75,8.75) P25(-1.05,8.75) P26(-0.35,8.75) P27(0.35,8.75) P28(1.05,8.75) P29(1.75,8.75) P30(2.45,8.75) P31(3.15,8.75) P32(3.85,8.75) P33(4.55,8.75) P34(5.25,8.75) P35(5.95,8.75) P36(6.65,8.75) P37(7.35,8.75) P38(8.05,8.75) P39(8.75,8.75) P40(9.45,8.75) P42(10.85,8.75) P43(11.55,8.75) P44(12.25,8.75) P45(12.95,8.75) P46(13.65,8.75) P47(14.35,8.75) P48(15.05,8.75) P49(15.75,8.75) P50(16.45,8.75) P51(17.15,8.75) P52(17.85,8.75) R1(-17.85,8.05) R2(-17.15,8.05) R3(-16.45,8.05) R4(-15.75,8.05) R5(-15.05,8.05) R6(-14.35,8.05) R7(-13.65,8.05) R8(-12.95,8.05) R9(-12.25,8.05) R10(-11.55,8.05) R11(-10.85,8.05) R14(-8.75,8.05) R15(-8.05,8.05) R16(-7.35,8.05) R17(-6.65,8.05) R18(-5.95,8.05) R19(-5.25,8.05) R20(-4.55,8.05) R21(-3.85,8.05) R22(-3.15,8.05) R23(-2.45,8.05) R24(-1.75,8.05) R25(-1.05,8.05) R26(-0.35,8.05) R27(0.35,8.05) R28(1.05,8.05) R29(1.75,8.05) R30(2.45,8.05) R31(3.15,8.05) R32(3.85,8.05) R33(4.55,8.05) R34(5.25,8.05) R35(5.95,8.05) R36(6.65,8.05) R37(7.35,8.05) R38(8.05,8.05) R39(8.75,8.05) R42(10.85,8.05) R43(11.55,8.05) R44(12.25,8.05) R45(12.95,8.05) R46(13.65,8.05) R47(14.35,8.05) R48(15.05,8.05) R49(15.75,8.05) R50(16.45,8.05) R51(17.15,8.05) R52(17.85,8.05) T2(-17.15,7.35) T4(-15.75,7.35) T6(-14.35,7.35) T8(-12.95,7.35) T10(-11.55,7.35) T14(-8.75,7.35) T15(-8.05,7.35) T16(-7.35,7.35) T17(-6.65,7.35) T18(-5.95,7.35) T19(-5.25,7.35) T20(-4.55,7.35) T21(-3.85,7.35) T22(-3.15,7.35) T23(-2.45,7.35) T24(-1.75,7.35) T25(-1.05,7.35) T26(-0.35,7.35) T27(0.35,7.35) T28(1.05,7.35) T29(1.75,7.35) T30(2.45,7.35) T31(3.15,7.35) T32(3.85,7.35) T33(4.55,7.35) T34(5.25,7.35) T35(5.95,7.35) T36(6.65,7.35) T37(7.35,7.35) T38(8.05,7.35) T39(8.75,7.35) T43(11.55,7.35) T45(12.95,7.35) T47(14.35,7.35) T49(15.75,7.35) T51(17.15,7.35) U1(-17.85,6.65) U2(-17.15,6.65) U3(-16.45,6.65) U4(-15.75,6.65) U5(-15.05,6.65) U6(-14.35,6.65) U7(-13.65,6.65) U8(-12.95,6.65) U9(-12.25,6.65) U10(-11.55,6.65) U11(-10.85,6.65) U14(-8.75,6.65) U15(-8.05,6.65) U16(-7.35,6.65) U17(-6.65,6.65) U18(-5.95,6.65) U19(-5.25,6.65) U20(-4.55,6.65) U21(-3.85,6.65) U22(-3.15,6.65) U23(-2.45,6.65) U24(-1.75,6.65) U25(-1.05,6.65) U26(-0.35,6.65) U27(0.35,6.65) U28(1.05,6.65) U29(1.75,6.65) U30(2.45,6.65) U31(3.15,6.65) U32(3.85,6.65) U33(4.55,6.65) U34(5.25,6.65) U35(5.95,6.65) U36(6.65,6.65) U37(7.35,6.65) U38(8.05,6.65) U39(8.75,6.65) U42(10.85,6.65) U43(11.55,6.65) U44(12.25,6.65) U45(12.95,6.65) U46(13.65,6.65) U47(14.35,6.65) U48(15.05,6.65) U49(15.75,6.65) U50(16.45,6.65) U51(17.15,6.65) U52(17.85,6.65) V1(-17.85,5.95) V2(-17.15,5.95) V3(-16.45,5.95) V4(-15.75,5.95) V5(-15.05,5.95) V6(-14.35,5.95) V7(-13.65,5.95) V8(-12.95,5.95) V9(-12.25,5.95) V10(-11.55,5.95) V11(-10.85,5.95) V13(-9.45,5.95) V14(-8.75,5.95) V15(-8.05,5.95) V16(-7.35,5.95) V17(-6.65,5.95) V18(-5.95,5.95) V19(-5.25,5.95) V20(-4.55,5.95) V21(-3.85,5.95) V22(-3.15,5.95) V23(-2.45,5.95) V24(-1.75,5.95) V25(-1.05,5.95) V26(-0.35,5.95) V27(0.35,5.95) V28(1.05,5.95) V29(1.75,5.95) V30(2.45,5.95) V31(3.15,5.95) V32(3.85,5.95) V33(4.55,5.95) V34(5.25,5.95) V35(5.95,5.95) V36(6.65,5.95) V37(7.35,5.95) V38(8.05,5.95) V39(8.75,5.95) V40(9.45,5.95) V42(10.85,5.95) V43(11.55,5.95) V44(12.25,5.95) V45(12.95,5.95) V46(13.65,5.95) V47(14.35,5.95) V48(15.05,5.95) V49(15.75,5.95) V50(16.45,5.95) V51(17.15,5.95) V52(17.85,5.95) W2(-17.15,5.25) W4(-15.75,5.25) W6(-14.35,5.25) W8(-12.95,5.25) W10(-11.55,5.25) W14(-8.75,5.25) W15(-8.05,5.25) W16(-7.35,5.25) W17(-6.65,5.25) W18(-5.95,5.25) W19(-5.25,5.25) W20(-4.55,5.25) W21(-3.85,5.25) W22(-3.15,5.25) W23(-2.45,5.25) W24(-1.75,5.25) W25(-1.05,5.25) W26(-0.35,5.25) W27(0.35,5.25) W28(1.05,5.25) W29(1.75,5.25) W30(2.45,5.25) W31(3.15,5.25) W32(3.85,5.25) W33(4.55,5.25) W34(5.25,5.25) W35(5.95,5.25) W36(6.65,5.25) W37(7.35,5.25) W38(8.05,5.25) W39(8.75,5.25) W43(11.55,5.25) W45(12.95,5.25) W47(14.35,5.25) W49(15.75,5.25) W51(17.15,5.25) Y1(-17.85,4.55) Y2(-17.15,4.55) Y3(-16.45,4.55) Y4(-15.75,4.55) Y5(-15.05,4.55) Y6(-14.35,4.55) Y7(-13.65,4.55) Y8(-12.95,4.55) Y9(-12.25,4.55) Y10(-11.55,4.55) Y11(-10.85,4.55) Y14(-8.75,4.55) Y15(-8.05,4.55) Y16(-7.35,4.55) Y17(-6.65,4.55) Y18(-5.95,4.55) Y19(-5.25,4.55) Y20(-4.55,4.55) Y21(-3.85,4.55) Y22(-3.15,4.55) Y23(-2.45,4.55) Y24(-1.75,4.55) Y25(-1.05,4.55) Y26(-0.35,4.55) Y27(0.35,4.55) Y28(1.05,4.55) Y29(1.75,4.55) Y30(2.45,4.55) Y31(3.15,4.55) Y32(3.85,4.55) Y33(4.55,4.55) Y34(5.25,4.55) Y35(5.95,4.55) Y36(6.65,4.55) Y37(7.35,4.55) Y38(8.05,4.55) Y39(8.75,4.55) Y42(10.85,4.55) Y43(11.55,4.55) Y44(12.25,4.55) Y45(12.95,4.55) Y46(13.65,4.55) Y47(14.35,4.55) Y48(15.05,4.55) Y49(15.75,4.55) Y50(16.45,4.55) Y51(17.15,4.55) Y52(17.85,4.55)
C_0201NEW
  rect 0.33x0.305 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0402-NV
  rect 0.4x0.5 smd: 1(-0.4,0) 2(0.4,0)
C_0402-NV_S
  rect 0.4x0.5 smd: 1(-0.4,0) 2(0.4,0)
C_0402NEW
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0603NEW
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0603NEW_S
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_0805NEW
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_EEEFK1E680P
  oval 3.2x1.6 smd: 1(0,0) 2(5,0)
CONN76-0_4-33_35X4_9X1_3MM
  rect 0.234x0.813 smd: 1(-15,0) 2(-14.6,0) 3(-14.2,0) 4(-13.8,0) 5(-13.4,0) 6(-13,0) 7(-12.6,0) 8(-12.2,0) 9(-11.8,0) 10(-11.4,0) 11(-11,0) 12(-10.6,0) 13(-10.2,0) 14(-9.8,0) 15(-9.4,0) 16(-9,0) 17(-8.6,0) 18(-8.2,0) 19(-7.8,0) 20(-7.4,0) 21(-7,0) 22(-6.6,0) 23(-6.2,0) 24(-5.8,0) 25(-5.4,0) 26(-5,0) 27(-4.6,0) 28(-4.2,0) 29(-3.8,0) 30(-3.4,0) 31(-3,0) 32(-2.6,0) 33(-2.2,0) 34(-1.8,0) 35(-1.4,0) 36(-1,0) 37(-0.6,0) 38(-0.2,0) 39(0.2,0) 40(0.6,0) 41(1,0) 42(1.4,0) 43(1.8,0) 44(2.2,0) 45(2.6,0) 46(3,0) 47(3.4,0) 48(3.8,0) 49(4.2,0) 50(4.6,0) 51(5,0) 52(5.4,0) 53(5.8,0) 54(6.2,0) 55(6.6,0) 56(7,0) 57(7.4,0) 58(7.8,0) 59(8.2,0) 60(8.6,0) 61(9,0) 62(9.4,0) 63(9.8,0) 64(10.2,0) 65(10.6,0) 66(11,0) 67(11.4,0) 68(11.8,0) 69(12.2,0) 70(12.6,0) 71(13,0) 72(13.4,0) 73(13.8,0) 74(14.2,0) 75(14.6,0) 76(15,0)
  rect 0.61x1.499 smd: 77(16.3,-3.45) 78(-16.3,-3.45)
CYNTE_PCMB053T-1R0MS_2P
  rect 2.007x2.489 smd: 1(0,0) 2(5,0)
CYNTE_PCMC065T-2R2MN_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
D-4_315X3_62-2_3H
  rect 1.27x2.108 smd: 1(-1.98,0) 2(1.98,0)
DDR-5_2-80886-100-260P
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(33.8,12) 262(-33.8,12)
DDR-5_2-80888-100-260P
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
DDR-80886-100-260P
  round 1.092 hole 1.092 unplated: (-34.4,0)
  round 1.6 hole 1.6 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(33.375,4.1) 2(33.125,-4.1) 3(32.875,4.1) 4(32.625,-4.1) 5(32.375,4.1) 6(32.125,-4.1) 7(31.875,4.1) 8(31.625,-4.1) 9(31.375,4.1) 10(31.125,-4.1) 11(30.875,4.1) 12(30.625,-4.1) 13(30.375,4.1) 14(30.125,-4.1) 15(29.875,4.1) 16(29.625,-4.1) 17(29.375,4.1) 18(29.125,-4.1) 19(28.875,4.1) 20(28.625,-4.1) 21(28.375,4.1) 22(28.125,-4.1) 23(27.875,4.1) 24(27.625,-4.1) 25(27.375,4.1) 26(27.125,-4.1) 27(26.875,4.1) 28(26.625,-4.1) 29(26.375,4.1) 30(26.125,-4.1) 31(25.875,4.1) 32(25.625,-4.1) 33(25.375,4.1) 34(25.125,-4.1) 35(24.875,4.1) 36(24.625,-4.1) 37(24.375,4.1) 38(24.125,-4.1) 39(23.875,4.1) 40(23.625,-4.1) 41(23.375,4.1) 42(23.125,-4.1) 43(22.875,4.1) 44(22.625,-4.1) 45(22.375,4.1) 46(22.125,-4.1) 47(21.875,4.1) 48(21.625,-4.1) 49(21.375,4.1) 50(21.125,-4.1) 51(20.875,4.1) 52(20.625,-4.1) 53(20.375,4.1) 54(20.125,-4.1) 55(19.875,4.1) 56(19.625,-4.1) 57(19.375,4.1) 58(19.125,-4.1) 59(18.875,4.1) 60(18.625,-4.1) 61(18.375,4.1) 62(18.125,-4.1) 63(17.875,4.1) 64(17.625,-4.1) 65(17.375,4.1) 66(17.125,-4.1) 67(16.875,4.1) 68(16.625,-4.1) 69(16.375,4.1) 70(16.125,-4.1) 71(15.875,4.1) 72(15.625,-4.1) 73(15.375,4.1) 74(15.125,-4.1) 75(14.875,4.1) 76(14.625,-4.1) 77(14.375,4.1) 78(14.125,-4.1) 79(13.875,4.1) 80(13.625,-4.1) 81(13.375,4.1) 82(13.125,-4.1) 83(12.875,4.1) 84(12.625,-4.1) 85(12.375,4.1) 86(12.125,-4.1) 87(11.875,4.1) 88(11.625,-4.1) 89(11.375,4.1) 90(11.125,-4.1) 91(10.875,4.1) 92(10.625,-4.1) 93(10.375,4.1) 94(10.125,-4.1) 95(9.875,4.1) 96(9.625,-4.1) 97(9.375,4.1) 98(9.125,-4.1) 99(8.875,4.1) 100(8.625,-4.1) 101(8.375,4.1) 102(8.125,-4.1) 103(7.875,4.1) 104(7.625,-4.1) 105(7.375,4.1) 106(7.125,-4.1) 107(6.875,4.1) 108(6.625,-4.1) 109(6.375,4.1) 110(6.125,-4.1) 111(5.875,4.1) 112(5.625,-4.1) 113(5.375,4.1) 114(5.125,-4.1) 115(4.875,4.1) 116(4.625,-4.1) 117(4.375,4.1) 118(4.125,-4.1) 119(3.875,4.1) 120(3.625,-4.1) 121(3.375,4.1) 122(3.125,-4.1) 123(2.875,4.1) 124(2.625,-4.1) 125(2.375,4.1) 126(2.125,-4.1) 127(1.875,4.1) 128(1.625,-4.1) 129(1.375,4.1) 130(1.125,-4.1) 131(0.875,4.1) 132(0.625,-4.1) 133(0.375,4.1) 134(0.125,-4.1) 135(-0.125,4.1) 136(-0.375,-4.1) 137(-0.625,4.1) 138(-0.875,-4.1) 139(-1.125,4.1) 140(-1.375,-4.1) 141(-1.625,4.1) 142(-1.875,-4.1) 143(-2.125,4.1) 144(-2.375,-4.1) 145(-4.625,4.1) 146(-4.875,-4.1) 147(-5.125,4.1) 148(-5.375,-4.1) 149(-5.625,4.1) 150(-5.875,-4.1) 151(-6.125,4.1) 152(-6.375,-4.1) 153(-6.625,4.1) 154(-6.875,-4.1) 155(-7.125,4.1) 156(-7.375,-4.1) 157(-7.625,4.1) 158(-7.875,-4.1) 159(-8.125,4.1) 160(-8.375,-4.1) 161(-8.625,4.1) 162(-8.875,-4.1) 163(-9.125,4.1) 164(-9.375,-4.1) 165(-9.625,4.1) 166(-9.875,-4.1) 167(-10.125,4.1) 168(-10.375,-4.1) 169(-10.625,4.1) 170(-10.875,-4.1) 171(-11.125,4.1) 172(-11.375,-4.1) 173(-11.625,4.1) 174(-11.875,-4.1) 175(-12.125,4.1) 176(-12.375,-4.1) 177(-12.625,4.1) 178(-12.875,-4.1) 179(-13.125,4.1) 180(-13.375,-4.1) 181(-13.625,4.1) 182(-13.875,-4.1) 183(-14.125,4.1) 184(-14.375,-4.1) 185(-14.625,4.1) 186(-14.875,-4.1) 187(-15.125,4.1) 188(-15.375,-4.1) 189(-15.625,4.1) 190(-15.875,-4.1) 191(-16.125,4.1) 192(-16.375,-4.1) 193(-16.625,4.1) 194(-16.875,-4.1) 195(-17.125,4.1) 196(-17.375,-4.1) 197(-17.625,4.1) 198(-17.875,-4.1) 199(-18.125,4.1) 200(-18.375,-4.1) 201(-18.625,4.1) 202(-18.875,-4.1) 203(-19.125,4.1) 204(-19.375,-4.1) 205(-19.625,4.1) 206(-19.875,-4.1) 207(-20.125,4.1) 208(-20.375,-4.1) 209(-20.625,4.1) 210(-20.875,-4.1) 211(-21.125,4.1) 212(-21.375,-4.1) 213(-21.625,4.1) 214(-21.875,-4.1) 215(-22.125,4.1) 216(-22.375,-4.1) 217(-22.625,4.1) 218(-22.875,-4.1) 219(-23.125,4.1) 220(-23.375,-4.1) 221(-23.625,4.1) 222(-23.875,-4.1) 223(-24.125,4.1) 224(-24.375,-4.1) 225(-24.625,4.1) 226(-24.875,-4.1) 227(-25.125,4.1) 228(-25.375,-4.1) 229(-25.625,4.1) 230(-25.875,-4.1) 231(-26.125,4.1) 232(-26.375,-4.1) 233(-26.625,4.1) 234(-26.875,-4.1) 235(-27.125,4.1) 236(-27.375,-4.1) 237(-27.625,4.1) 238(-27.875,-4.1) 239(-28.125,4.1) 240(-28.375,-4.1) 241(-28.625,4.1) 242(-28.875,-4.1) 243(-29.125,4.1) 244(-29.375,-4.1) 245(-29.625,4.1) 246(-29.875,-4.1) 247(-30.125,4.1) 248(-30.375,-4.1) 249(-30.625,4.1) 250(-30.875,-4.1) 251(-31.125,4.1) 252(-31.375,-4.1) 253(-31.625,4.1) 254(-31.875,-4.1) 255(-32.125,4.1) 256(-32.375,-4.1) 257(-32.625,4.1) 258(-32.875,-4.1) 259(-33.125,4.1) 260(-33.375,-4.1)
  rect 3.505x4.597 smd: 261(33.8,12) 262(-33.8,12)
