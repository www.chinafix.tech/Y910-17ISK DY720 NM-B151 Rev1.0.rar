# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_RSENSE: length 1.2
  TOP w0.254: R2035.1 50.21,88.62 v2(49.92,88.33)
  BOTTOM w0.178: v2(49.92,88.33) U2005.J6
TBT_SLP_S3_N: length 25.5
  TOP w0.097: R2034.1 49.17,92.59 v2(48.84,92.26) 48.48,91.9 48.48,91.14 47.98,90.63 47.72,90.63 v2(47.32,90.23) ; R2033.2 v1(28.54,87.07)
  IN05 w0.089: v2(47.32,90.23) 44.67,90.23
  IN05 w0.091: 44.67,90.23 44.15,90.76 38.63,90.76 35.46,87.58 29.05,87.58 v1(28.54,87.07)
  BOTTOM w0.178: v2(47.32,90.23) 47.22,90.34 U2005.D2
TBT_SNK0_CFG1: length 14.9
  TOP w0.097: v1(61.56,90.76) 61.95,91.14 R2082.1
  IN03 w0.089: v2(51.22,89.63) 51.22,90.19 51.66,90.63 54.83,90.63
  IN03 w0.091: v1(61.56,90.76) 61.31,90.76 58.9,88.34 56.61,88.34 55.09,89.87 55.09,90.38 54.83,90.63
  BOTTOM w0.178: v2(51.22,89.63) U2005.N4
TBT_SNK0_DDC_CLK: length 8.3
  TOP w0.089: v2(54.47,89.63) 54.47,89.71 55.36,90.6 v2(55.72,90.6) 55.72,90.6 55.72,91.14 56.25,91.67 56.79,91.67
  TOP w0.097: 56.79,91.67 57.29,91.67 57.31,91.65 58.14,91.65 58.45,91.97 59.55,91.97 R2118.1
  BOTTOM w0.178: v2(54.47,89.63) 54.8,89.31 U2005.Y5
TBT_SNK0_DDC_DATA: length 13.7
  TOP w0.097: v1(61.69,89.36) 61.44,89.36 61.18,89.61 R2119.1
  IN03 w0.089: 54.07,87.96 53.56,87.96 51.89,89.63 v2(51.87,89.63)
  IN03 w0.091: 54.07,87.96 54.71,87.33 60.17,87.33 61.69,88.85 v1(61.69,89.36)
  BOTTOM w0.178: v2(51.87,89.63) U2005.R4
TBT_SNK1_DDC_CLK: length 1.6
  TOP w0.089: R2054.1 54.48,88.34 v2(54.47,88.33)
  BOTTOM w0.178: U2005.Y8 54.8,88.01 v2(54.47,88.33)
TBT_SRC_CFG1: length 4.8
  TOP w0.097: R2120.2 R2023.1
  TOP w0.102: R2023.1 57.93,92.84 v2(57.12,92.03)
  BOTTOM w0.076: 55.85,91.9 55.72,91.9 55.04,91.21 U2005.AA1
  BOTTOM w0.178: 55.85,91.9 55.98,92.03 v2(57.12,92.03)
TBT_SRC_HPD: length 3.4
  TOP w0.097: R2121.2 v2(47.85,93.55)
  BOTTOM w0.102: U2005.G1 48.6,92.42 48.36,92.66 48.36,93.04 v2(47.85,93.55)
TBT_SVR_IND:
  vias: v2(45.89,93.86)
TBT_TCK: length 4
  TOP w0.102: v2(53.17,89.63) 53.08,89.72 v2(53.08,90.2) 53.08,90.4 53.59,90.91 53.59,92.61 R2013.1
  BOTTOM w0.178: v2(53.17,89.63) 52.85,89.96 U2005.T4
TBT_TDI: length 3.9
  TOP w0.102: v2(54.47,90.23) 54.47,90.47 v2(55.87,91.88) 56.48,92.48 R2011.1
  BOTTOM w0.178: U2005.Y4 54.75,89.96 v2(54.47,90.23)
TBT_TDO: length 3.8
  TOP w0.102: v2(53.82,90.26) 53.9,90.26 55.42,91.77 55.42,92.66 R2014.1
  BOTTOM w0.178: U2005.W4 54.12,89.96 v2(53.82,90.26)
TBT_TEST_EN: length 1.9
  TOP w0.097: v2(47.21,92.14) 47.2,92.15 R2025.1
  BOTTOM w0.102: U2005.E1 47.68,91.18 47.21,91.65 v2(47.21,92.14)
TBT_TEST_PWG: length 4.4
  BOTTOM w0.076: U2005.AB5 55.73,89.05 56.02,89.05
  BOTTOM w0.089: 56.91,89.05 56.02,89.05 56.02,89.05
  BOTTOM w0.097: 56.91,89.05 56.97,89.11 58.32,89.11 v2(58.67,89.46) 58.83,89.61 R2027.1
TBT_TMS: length 4.3
  TOP w0.102: R2012.1 54.35,92.48 54.35,91.29 v2(54.27,91.21) 53.46,90.4 53.46,89.99 v2(53.82,89.63)
  BOTTOM w0.178: v2(53.82,89.63) 53.5,89.96 U2005.V4
TBT_TMU_CLK_OUT: length 2.6
  BOTTOM w0.076: 54.33,92.05 54.33,91.89 53.88,91.45 53.88,90.89 U2005.V2
  BOTTOM w0.097: R2038.1 54.33,92.46 54.33,92.05
TBT_USB_PWR_EN: length 212.1
  TOP w0.089: v2(45.05,87.96) 44.9,87.81
  TOP w0.097: 44.9,87.81 44.6,87.51 R2043.2
  IN03 w0.091: v1(51.73,68.08) 59.96,68.08 63.34,71.45 68.68,71.45 69.06,71.07 73.5,71.07 73.63,71.2 77.19,71.2 77.95,70.44 78.46,70.44 81.5,67.39 85.57,67.39 88.87,70.69 103.09,70.69 103.69,71.29 114.4,71.29 115.76,69.93 119.86,69.93 119.95,70.02 125.41,70.02 126.46,71.07 127.6,71.07 128.62,70.06 128.62,68.91 130.43,67.1 210.28,67.1 214.69,62.69 217.77,62.69 220.91,65.83 222.06,65.83 v3(224.12,67.9)
  IN10 w0.091: v2(45.05,87.96) 45.44,87.58 45.44,82.5 51.02,76.91 51.02,74.37 53.06,72.34 53.06,69.4 v1(51.73,68.08)
  BOTTOM w0.097: U2.L44 226.02,68.39 225.52,67.9 v3(224.12,67.9)
TBT_WAKE_N: length 6.1
  TOP w0.097: 58.47,91.21 R2094.1
  TOP w0.102: v3(57.12,91.27) 57.25,91.27 57.63,90.88 58.14,90.88 58.47,91.21
  IN08 w0.091: v3(57.12,91.27) 56.1,92.28 v2(54.86,92.28)
  BOTTOM w0.076: 54.73,92.05 54.73,92.05 54.58,91.9 54.15,91.46 54.15,91.15 U2005.W1
  BOTTOM w0.097: v2(54.86,92.28) 54.86,92.18 54.73,92.05
TBT_XTAL_25_IN: length 7.3
  BOTTOM w0.076: U2005.D22 47.44,81.23 47.44,80.72
  BOTTOM w0.097: 47.44,80.72 46.17,79.45 R2010.2
  BOTTOM w0.102: Y2001.1 45.76,76.27 45.92,76.43 45.92,77.58 45.23,78.26 C2048.1 45.23,79.05 R2010.2
TBT_XTAL_25_OUT: length 5.8
  BOTTOM w0.097: U2005.D23 47.22,80.85 46.32,79.96 45.23,79.96 R2010.1 44.72,78.92 C2046.1 44.37,77.14 Y2001.3
TBTA_CC1: length 29.2
  TOP w0.254: JTYPC1.A5 8.62,80.07 8.86,79.84 13.43,79.84 14.57,80.98 v2(14.83,80.98) 17.74,80.98 D59.2 v1(18.63,80.99) ; C2130.1 30.21,76.86 29.53,76.86 v2(29.18,77.22)
  IN03 w0.254: v2(29.18,77.22) 29.1,77.3 28.29,77.3 27.27,78.31 27.27,79.58 26.96,79.9 26.96,80.53 25.37,82.12 19.76,82.12 v1(18.63,80.99)
  BOTTOM w0.203: U2007.L9 30.85,76.38 30.35,76.89 29.51,76.89 v2(29.18,77.22)
TBTA_CC2: length 41.2
  TOP w0.203: JTYPC1.B5 6.1,78.52 4.49,76.91 4.49,74.25 5.07,73.66 10.56,73.66 10.83,73.4 D56.2 11.25,72.75 v1(11.65,72.34)
  TOP w0.254: C2129.1 v2(29.94,77.3)
  IN05 w0.254: v1(11.65,72.34) 11.65,72.72 12.54,73.61 16.99,73.61 19.91,70.69 27.78,70.69 29.18,72.09 29.18,73.87 30.45,75.14 30.45,76.79 v2(29.94,77.3)
  BOTTOM w0.203: 30.58,77.3 30.99,76.88 U2007.L10
  BOTTOM w0.254: v2(29.94,77.3) 30.58,77.3
TBTA_DEBUG1: length 6
  BOTTOM w0.102: U2007.L2 30.41,72.88 27.63,70.1 27.63,70.08 26.8,69.24 R2075.2
TBTA_DEBUG2: length 6
  BOTTOM w0.076: 30.09,72.22 30.5,72.62 31.49,72.62 U2007.K2
  BOTTOM w0.102: R2076.2 27.66,69.62 29.7,71.67 v2(29.9,71.67) 29.99,71.76 29.99,72.11 30.09,72.22
TBTA_DEBUG3: length 7.7
  BOTTOM w0.102: U2007.L3 30.24,73.38 27.6,70.74 26.23,70.74 v2(25.95,70.46) 25.55,70.46 R2071.2
TBTA_DEBUG4: length 7.9
  BOTTOM w0.076: U2007.K3 31.74,73.38 31.5,73.14 30.31,73.14
  BOTTOM w0.102: R2072.2 25.88,69.78 26.33,70.23 v2(27.22,70.23) 27.4,70.23 30.31,73.14
TBTA_DPSRC_AUX_N: length 5.8
  TOP w0.104: v2(29.56,69.96) 29.41,69.8 R2069.2
  BOTTOM w0.076: U2007.J2 31.99,72.62 31.99,72.2 31.34,71.54 31.26,71.54 31.26,71.53
  BOTTOM w0.104: 31.26,71.53 30.56,70.84 30.04,70.84 29.64,70.44 29.64,70.04 v2(29.56,69.96) 29.71,69.8 29.71,69.56 C2071.2
TBTA_DPSRC_AUX_P: length 5.7
  TOP w0.104: v2(30.12,69.96) 30.3,69.78 R2080.1
  BOTTOM w0.076: 31.44,71.35 31.45,71.36 31.45,71.37 31.42,71.4 31.45,71.44 32.25,72.24 U2007.J1
  BOTTOM w0.104: C2070.2 29.99,69.54 29.99,69.83 v2(30.12,69.96) 29.9,70.18 29.9,70.33 30.15,70.58 30.66,70.58 30.85,70.77 31,70.77 31.13,70.64 31.28,70.64 31.43,70.79 31.43,70.93 31.3,71.06 31.3,71.21 31.44,71.35
TBTA_HPD: length 21.8
  TOP w0.089: R2049.1 50.26,90.81 50.26,89.94 v2(50.57,89.63)
  IN03 w0.091: v1(39.21,77.4) 38.7,77.91 38.7,80.09 46.2,87.58 47.87,87.58 49.4,89.11 50.04,89.11 v2(50.57,89.63)
  BOTTOM w0.097: v1(39.21,77.4) 39.03,77.22 R2063.1
  BOTTOM w0.178: U2005.M4 v2(50.57,89.63)
TBTA_I2C_INT: length 43.2
  TOP w0.097: 48.86,91.71 48.86,90.04 v2(49.27,89.63)
  TOP w0.102: 48.86,91.71 49.66,92.51 50.54,92.51 v2(51.07,93.04) 51.84,93.04 R2037.1
  IN03 w0.089: 38.4,80.29 38.32,80.22 38.32,74.5 38.4,74.43 ; v2(35.66,69.68) 35.91,69.68 37.69,71.45 38.07,71.45 38.4,71.78
  IN03 w0.091: 38.4,74.43 38.68,74.15 38.68,72.06 38.4,71.78 ; 38.4,80.29 41.63,83.52 41.63,86.69 40.48,87.84 40.48,90.12 41.37,91.01 47.89,91.01 v2(49.27,89.63)
  BOTTOM w0.102: U2007.C1 35.28,72.36 35.28,70.06 v2(35.66,69.68)
  BOTTOM w0.178: U2005.J4 49.6,89.96 v2(49.27,89.63)
TBTA_LDO_BMC: length 4.3
  BOTTOM w0.178: C2117.1 32.1,70.06 32.86,70.82 33.04,70.82 34.13,71.91 34.13,72.26 U2007.E1
TBTA_LSRX: length 38.4
  TOP w0.089: v2(45.05,89.61) 44.9,89.77
  TOP w0.097: R2045.2 44.04,90.63 44.9,89.77
  IN05 w0.089: 27.15,80.72 27.15,78.95 28.04,78.06 28.04,72.85 26.97,71.78 ; 44.9,88.34 45.31,88.34 45.44,88.47 45.44,89.23 v2(45.05,89.61)
  IN05 w0.091: v1(25.09,71.45) 26.64,71.45 26.97,71.78 ; 44.9,88.34 44.67,88.34 44.42,88.6 37.09,88.6 33.92,85.42 31.29,85.42 27.15,81.28 27.15,80.72
  BOTTOM w0.097: R2088.1 v1(25.09,71.45)
  BOTTOM w0.102: U2005.A4 45.18,89.74 v2(45.05,89.61)
TBTA_LSTX: length 36.5
  TOP w0.102: R2048.2 45.74,90.17 45.44,89.87 45.44,89.11 v2(45.05,88.73)
  IN05 w0.091: v2(45.05,88.73) 44.93,88.85 37.04,88.85 34.04,85.86 31.29,85.86 27.73,82.3 26.89,81.47 26.89,78.84 27.86,77.88 27.86,72.98 27.22,72.34 v1(25.37,72.34)
  BOTTOM w0.097: R2087.1 v1(25.37,72.34)
  BOTTOM w0.203: U2005.A5 45.61,89.28 v2(45.05,88.73)
TBTA_MRESET_R: length 7.7
  TOP w0.089: 33.09,80.72 R2099.2 33.88,80.52 v2(34.3,80.1) 34.67,79.73 v2(34.67,78.82)
  TOP w0.097: R2093.2 33.09,80.72
  BOTTOM w0.089: R2103.2 R2065.2 34.51,78.97 v2(34.67,78.82) 34.25,78.41 U2007.E11
TBTA_ROSC: length 4.5
  BOTTOM w0.076: 32.48,71.2 32.48,71.62 32.99,72.13 32.99,72.62 U2007.G2
  BOTTOM w0.178: 32.48,71.2 v2(31.72,70.44) 31.36,70.08 31.36,69.8 31.21,69.64 R2079.1
TBTA_RX0_N: length 41.9
  BOTTOM w0.076: U2005.A21 45.93,81.92 arc(46.04,82.03) 45.93,82.15 45.78,82.15 arc(45.69,82.11) 45.6,82.07
  BOTTOM w0.097: JTYPC1.B11 6.18,81.64 arc(6.33,81.54) 6.5,81.51 9.03,81.51 arc(9.12,81.52) 9.19,81.58 10.61,83 arc(10.87,83.16) 11.17,83.22 13.71,83.22 arc(13.77,83.23) 13.81,83.26 arc(13.91,83.33) 14.03,83.36 D62.2 14.43,83.36 arc(14.46,83.35) 14.5,83.33 14.57,83.25 arc(14.6,83.23) 14.64,83.22 15.97,83.22 15.98,83.23 35.74,83.23 arc(36.86,83.01) 37.82,82.38 arc(39.04,81.55) 40.49,81.27 43.76,81.27 arc(44.36,81.39) 44.88,81.73 arc(45.09,81.89) 45.33,81.97 arc(45.47,82.01) 45.6,82.07
TBTA_RX0_P: length 41.9
  BOTTOM w0.076: 45.66,81.69 45.95,81.69 arc(46.06,81.71) 46.14,81.77 U2005.B21
  BOTTOM w0.097: 45.66,81.69 45.51,81.72 arc(45.45,81.71) 45.39,81.71 arc(45.22,81.64) 45.07,81.54 arc(44.47,81.13) 43.76,80.99 40.49,80.99 arc(38.94,81.3) 37.62,82.18 arc(36.76,82.76) 35.74,82.96 15.98,82.96 15.97,82.95 14.64,82.95 arc(14.6,82.94) 14.57,82.92 14.5,82.85 arc(14.46,82.83) 14.43,82.82 D63.2 13.97,82.82 arc(13.88,82.84) 13.81,82.88 arc(13.74,82.93) 13.65,82.95 11.17,82.95 arc(10.97,82.91) 10.81,82.8 9.39,81.38 arc(9.22,81.27) 9.03,81.23 6.41,81.23 arc(6.19,81.14) JTYPC1.B10
TBTA_RX1_N: length 41.8
  TOP w0.097: v1(40.42,84.87) 40.34,84.79 arc(40.12,84.64) 39.86,84.59 39.24,84.59 arc(39.07,84.55) 38.93,84.46 arc(38.84,84.4) 38.73,84.38 33.99,84.38 arc(28.59,83.3) 24.02,80.25 23.24,79.47 arc(22.71,79.12) 22.09,78.99 arc(21.38,78.85) 20.77,78.45 19.49,77.16 arc(18.42,76.45) 17.16,76.2 16.61,76.2 arc(16.45,76.23) 16.32,76.32 15.51,77.13 arc(15.12,77.39) 14.65,77.48 14.54,77.48 arc(14.5,77.49) 14.47,77.51 14.39,77.59 arc(14.36,77.61) 14.33,77.62 D66.2 13.84,77.62 arc(13.76,77.6) 13.69,77.55 arc(13.61,77.5) 13.53,77.48 8.7,77.48 arc(8.68,77.48) 8.65,77.48 arc(8.57,77.49) 8.49,77.54 arc(8.45,77.56) 8.41,77.57 JTYPC1.A10
  BOTTOM w0.076: 45.66,84.91 45.96,84.91 arc(45.98,84.91) 46,84.9 46.07,84.89 arc(46.11,84.88) 46.15,84.86 arc(46.19,84.83) 46.22,84.8 46.26,84.76 arc(46.29,84.72) U2005.B15
  BOTTOM w0.097: v1(40.42,84.87) 40.68,84.62 arc(40.71,84.6) 40.74,84.59 41.02,84.59 arc(41.18,84.62) 41.32,84.71 arc(41.43,84.78) 41.55,84.81 45.12,84.81 arc(45.16,84.81) 45.19,84.81 arc(45.26,84.82) 45.33,84.84 45.5,84.89 arc(45.54,84.9) 45.59,84.91 45.66,84.91
TBTA_RX1_P: length 41.8
  TOP w0.097: JTYPC1.A11 8.37,77.07 arc(8.5,77.1) 8.61,77.17 arc(8.65,77.2) 8.7,77.21 13.59,77.21 arc(13.64,77.2) 13.69,77.17 arc(13.79,77.1) 13.9,77.08 D67.2 14.33,77.08 arc(14.36,77.09) 14.39,77.11 14.47,77.18 arc(14.5,77.2) 14.54,77.21 14.65,77.21 arc(15.01,77.14) 15.32,76.93 16.12,76.13 arc(16.35,75.98) 16.61,75.92 17.16,75.92 arc(18.53,76.19) 19.68,76.97 20.96,78.25 arc(21.48,78.6) 22.09,78.72 arc(22.82,78.86) 23.43,79.27 24.21,80.05 arc(28.7,83.05) 33.99,84.1 38.73,84.1 arc(38.94,84.15) 39.12,84.27 arc(39.17,84.3) 39.24,84.31 39.86,84.31 arc(40.12,84.26) 40.34,84.12 v1(40.42,84.03)
  BOTTOM w0.076: U2005.A15 45.94,84.68 arc(46.06,84.56) 45.94,84.45 45.67,84.45
  BOTTOM w0.097: v1(40.42,84.03) 40.68,84.29 arc(40.71,84.31) 40.74,84.31 41.02,84.31 arc(41.25,84.35) 41.46,84.47 arc(41.53,84.52) 41.62,84.53 45.12,84.53 arc(45.17,84.54) 45.22,84.54 45.22,84.53 arc(45.45,84.51) 45.67,84.45
TBTA_SBU1: length 30
  TOP w0.089: 26.97,71.45 27.53,72.01 27.53,74.96 R2089.2
  TOP w0.097: JTYPC1.A8 9.4,78.57 9.67,78.85 11.85,78.85 11.97,78.72 v2(12.16,78.72) 13.66,78.72 13.81,78.57 17.5,78.57 17.5,78.58 D58.2 18.78,78.58 v1(18.79,78.57) ; v1(18.94,74.63) 18.94,73.43 21.43,70.95 26.46,70.95 26.97,71.45
  IN03 w0.091: v1(18.79,78.57) 18.94,78.41 v1(18.94,74.63)
TBTA_SBU2: length 39.3
  TOP w0.097: v1(6.65,72.75) D57.2 7.3,73.14 7.07,73.36 4.74,73.36 4.08,74.03 4.08,78.51 5.69,80.12 JTYPC1.B8 ; v1(13.18,74.25) 13.74,74.81 v2(14.45,74.81) 17.06,74.81 21.36,70.51 26.97,70.51 28.09,71.63 R2090.1
  IN03 w0.091: v1(6.65,72.75) 7.26,73.36 12.29,73.36 v1(13.18,74.25)
TBTA_TX0_N: length 39.4
  TOP w0.097: JTYPC1.A2 8,81.57 8.4,81.57 arc(8.43,81.56) 8.47,81.54 8.52,81.49 arc(8.55,81.46) 8.59,81.46 8.69,81.46 8.8,81.5 arc(8.82,81.51) 8.83,81.51 9.23,81.92 arc(9.48,82.08) 9.77,82.14 arc(9.83,82.15) 9.88,82.19 arc(11.03,82.95) 12.38,83.22 13.67,83.22 arc(13.71,83.23) 13.74,83.25 13.81,83.33 arc(13.85,83.35) 13.88,83.36 D61.2 14.47,83.36 14.6,83.22 23.13,83.22 arc(24.2,83.33) 25.22,83.64 27.87,84.74 arc(30.38,85.5) 32.98,85.75 40.39,85.75 arc(40.99,85.64) 41.5,85.3 arc(41.61,85.13) 41.65,84.93 41.65,82.95 arc(41.67,82.84) 41.73,82.75 arc(41.83,82.69) 41.94,82.67 42.01,82.67 arc(42.21,82.75) v1(42.29,82.95)
  BOTTOM w0.097: v1(42.29,82.95) 42.49,82.75 arc(42.58,82.69) 42.69,82.67 43.17,82.67 arc(43.36,82.7) C2069.2
TBTA_TX0_P: length 39.4
  TOP w0.097: JTYPC1.A3 8,81.07 8.4,81.07 arc(8.43,81.08) 8.47,81.1 8.52,81.15 arc(8.55,81.18) 8.59,81.18 8.73,81.18 arc(8.75,81.18) 8.77,81.19 8.9,81.25 arc(8.95,81.27) 9,81.3 9.43,81.73 9.43,81.73 arc(9.59,81.83) 9.77,81.87 arc(9.94,81.9) 10.08,81.99 arc(11.14,82.7) 12.38,82.95 13.67,82.95 arc(13.71,82.94) 13.74,82.92 13.81,82.85 arc(13.85,82.83) 13.88,82.82 D60.2 14.47,82.82 14.6,82.95 23.13,82.95 arc(24.25,83.06) 25.32,83.38 27.98,84.48 arc(30.43,85.23) 32.98,85.48 40.39,85.48 arc(40.89,85.38) 41.3,85.1 arc(41.36,85.02) 41.38,84.93 41.38,82.95 arc(41.42,82.74) 41.54,82.55 arc(41.72,82.43) 41.94,82.39 42.01,82.39 arc(42.21,82.31) v1(42.29,82.11)
  BOTTOM w0.097: v1(42.29,82.11) 42.48,82.31 arc(42.58,82.37) 42.69,82.39 43.17,82.39 arc(43.36,82.35) C2068.2
TBTA_TX1_N: length 49.1
  BOTTOM w0.097: JTYPC1.B3 5.77,77.72 arc(5.66,77.67) 5.61,77.55 arc(5.58,77.49) 5.51,77.46 5.31,77.46 arc(5.21,77.48) 5.12,77.53 D65.2 4.85,77.54 arc(4.65,77.5) 4.54,77.67 4.54,79.4 arc(4.58,79.51) 4.69,79.55 4.71,79.55 arc(4.82,79.6) 4.87,79.71 4.87,79.78 arc(4.82,79.89) 4.71,79.94 4.69,79.94 arc(4.58,79.99) 4.54,80.1 4.54,80.17 arc(4.58,80.28) 4.69,80.33 arc(4.8,80.37) 4.85,80.48 4.85,80.56 arc(4.8,80.67) 4.69,80.71 arc(4.58,80.76) 4.54,80.87 4.54,83.95 arc(4.56,84.08) 4.63,84.18 5.16,84.71 arc(5.37,84.85) 5.61,84.9 6.77,84.9 arc(6.97,84.86) 7.14,84.74 arc(7.34,84.61) 7.58,84.56 35.58,84.56 arc(37.11,84.3) 38.46,83.54 arc(39.04,83.16) 39.72,83.03 40.38,83.03 arc(41.11,83.17) 41.73,83.59 arc(41.82,83.65) 41.92,83.67 42.91,83.67 arc(43.24,83.6) C2067.2
TBTA_TX1_P: length 49.1
  BOTTOM w0.097: JTYPC1.B2 5.7,76.92 arc(5.64,76.95) 5.61,77.02 5.61,77.09 arc(5.59,77.14) 5.55,77.17 arc(5.53,77.18) 5.51,77.18 5.08,77.18 arc(5.02,77.17) D64.2 4.79,77.14 arc(4.42,77.3) 4.26,77.67 4.26,83.95 arc(4.31,84.18) 4.44,84.37 4.96,84.9 arc(5.26,85.1) 5.61,85.17 6.77,85.17 arc(7.08,85.11) 7.34,84.94 arc(7.45,84.86) 7.58,84.84 35.58,84.84 arc(37.21,84.56) 38.64,83.75 arc(39.13,83.42) 39.72,83.3 40.38,83.3 arc(41.01,83.43) 41.54,83.78 arc(41.72,83.9) 41.92,83.94 43.44,83.94 arc(43.48,83.95) C2066.2
TBTA_UART_RX: length 4.9
  BOTTOM w0.076: 34.51,71.98 34.51,72.73 34.35,72.88 U2007.E2
  BOTTOM w0.102: R2064.2 v2(32.99,70.18) 32.99,70.26 34.51,71.78 34.51,71.98
  BOTTOM w0.178: U2007.F2 U2007.E2
TBTA_USB2_D_N: length 39.5
  IN03 w0.102: v2(47.32,81.88) 47.32,81.96 arc(47.32,81.99) 47.33,82.01 47.35,82.07 arc(47.4,82.13) 47.46,82.18 47.5,82.19 arc(47.51,82.2) 47.53,82.2 47.67,82.2 arc(47.79,82.14) 47.85,82.02 47.85,81.48 arc(47.73,81.2) 47.45,81.08 arc(46.5,80.89) 45.7,80.36 44.04,78.69 43.15,77.8 arc(42.92,77.47) 42.84,77.07 42.84,72.27 arc(42.8,72.06) 42.68,71.87 39.57,68.76 arc(37.82,67.6) 35.76,67.19 34,67.19 arc(33.85,67.21) 33.71,67.27 33.5,67.4 arc(33.41,67.47) 33.35,67.57 33.31,67.66 arc(33.3,67.71) 33.29,67.75 33.29,68.07 arc(33.22,68.45) 33,68.78 28.95,72.83 arc(28.15,73.36) 27.21,73.55 arc(27.08,73.61) v2(27.02,73.74)
  BOTTOM w0.076: 30.12,74.45 30.68,74.45 arc(30.78,74.47) 30.87,74.53 arc(30.98,74.61) 31.12,74.64 31.22,74.64 arc(31.48,74.59) 31.69,74.44 U2007.K5
  BOTTOM w0.097: 30.12,74.45 30.11,74.45 arc(29.69,74.37) 29.32,74.12 arc(28.94,73.87) 28.49,73.78 v1(27.78,73.78) 27.12,73.78 arc(27.06,73.77) v2(27.02,73.74) ; v2(47.32,81.88) 47.04,82.16 U2005.D20
TBTA_USB2_D_P: length 39.6
  IN03 w0.102: v2(47.97,82.48) arc(48.07,82.33) 48.1,82.16 48.1,81.96 48.1,81.92 48.1,81.48 arc(47.91,81.02) 47.45,80.83 arc(46.6,80.66) 45.88,80.18 44.22,78.51 43.33,77.62 arc(43.16,77.37) 43.1,77.07 43.1,72.27 arc(43.04,71.96) 42.86,71.7 39.75,68.59 arc(37.92,67.36) 35.76,66.93 34,66.93 arc(33.78,66.96) 33.58,67.05 33.36,67.18 arc(33.22,67.31) 33.12,67.47 33.08,67.57 arc(33.05,67.66) 33.04,67.75 33.04,68.07 arc(32.98,68.35) 32.82,68.6 28.77,72.65 arc(28.05,73.13) 27.21,73.3 arc(27.08,73.24) v2(27.02,73.1)
  BOTTOM w0.076: U2007.L5 31.26,74.38 arc(31.38,74.26) 31.26,74.14 29.99,74.14 arc(29.74,74.09) 29.53,73.95
  BOTTOM w0.097: v2(47.97,82.48) U2005.E20 ; 29.53,73.95 arc(29.06,73.62) 28.49,73.51 27.39,73.51 arc(27.31,73.47) 27.27,73.38 27.27,73.35 arc(27.2,73.18) v2(27.02,73.1)
TBTA_USB2_N_B: length 33
  IN08 w0.102: v1(10.6,80.44) 10.79,80.44 11.04,80.19 11.04,79.71 10.78,79.45 7.96,79.45 7.82,79.58 7.55,79.58 7.41,79.45 7.07,79.45 JTYPC1.B7
  BOTTOM w0.076: U2007.L7 30.89,75.38 30.88,75.37
  BOTTOM w0.097: v1(10.6,80.44) 10.88,80.16 10.88,80.02 10.84,79.99 D2006.2 10.84,79.53 10.51,79.2 10.51,78.29 11.04,77.75 11.04,76.8 arc(11.17,76.18) 11.52,75.65 11.53,75.64 arc(12.37,75.08) 13.37,74.88 16.23,74.88 arc(16.58,74.95) 16.87,75.15 18.94,77.21 arc(20.01,77.93) 21.28,78.18 v1(22.7,78.18) 24.24,78.18 arc(25.17,78) 25.95,77.48 arc(26.35,77.21) 26.82,77.12 arc(27.04,77.07) 27.24,76.94 28.26,75.92 arc(28.63,75.63) 29.07,75.44 arc(29.33,75.39) 29.59,75.37 30.88,75.37
TBTA_USB2_N_T: length 26.7
  TOP w0.097: JTYPC1.A7 8.55,79.07 arc(8.59,79.08) 8.62,79.1 8.67,79.15 arc(8.69,79.17) 8.71,79.18 arc(8.72,79.18) 8.74,79.18 v1(10.64,79.18) 13.18,79.18 13.19,79.17 13.5,79.17 13.54,79.13 D2005.1 14.09,78.91 arc(14.13,78.88) 14.18,78.87 15.21,78.87 arc(15.4,78.91) 15.56,79.01 arc(15.72,79.12) 15.91,79.16 19.87,79.16 arc(20.04,79.09) v1(20.11,78.92)
  IN05 w0.102: v2(26.59,75.14) 26.59,75.41 arc(26.53,75.51) 26.41,75.49 arc(26.37,75.46) 26.33,75.45 26.19,75.45 arc(26.01,75.47) 25.85,75.54 25.83,75.54 arc(25.72,75.61) 25.62,75.7 arc(25.41,76.02) 25.34,76.39 arc(24.52,78.38) 22.53,79.2 20.39,79.2 arc(20.19,79.12) v1(20.11,78.92)
  BOTTOM w0.076: U2007.L6 31.24,74.88 30.67,74.88 arc(30.59,74.86) 30.53,74.82 arc(30.46,74.77) 30.38,74.75 30.14,74.75 30.14,74.75 30.12,74.75
  BOTTOM w0.097: 30.12,74.75 30.02,74.75 28.72,74.75 arc(28.2,74.85) 27.77,75.14 arc(27.51,75.31) 27.21,75.37 27.18,75.37 arc(27.03,75.38) 26.88,75.41 arc(26.83,75.43) 26.79,75.44 arc(26.65,75.43) 26.59,75.31 v2(26.59,75.14)
TBTA_USB2_P_B: length 33.1
  IN08 w0.102: JTYPC1.B6 7.07,79.19 10.88,79.19 11.3,79.61 11.3,80.3 v1(11.44,80.44)
  BOTTOM w0.076: U2007.K7 31.5,75.64 30.89,75.64 30.88,75.64
  BOTTOM w0.097: v1(11.44,80.44) 11.16,80.16 11.16,80.02 11.19,79.99 D2006.1 11.19,79.53 11.53,79.2 11.53,78.18 11.32,77.98 11.32,76.79 11.71,75.85 11.72,75.84 arc(12.48,75.33) 13.37,75.16 16.23,75.16 arc(16.47,75.21) 16.68,75.34 18.74,77.41 arc(19.91,78.19) 21.28,78.46 24.24,78.46 arc(25.27,78.25) 26.14,77.67 arc(26.45,77.46) 26.82,77.39 arc(27.15,77.33) 27.43,77.14 28.46,76.11 arc(28.77,75.87) 29.14,75.71 arc(29.36,75.66) 29.59,75.64 30.88,75.64
TBTA_USB2_P_T: length 26.8
  TOP w0.097: JTYPC1.A6 8.55,79.57 arc(8.59,79.56) 8.62,79.54 8.67,79.49 arc(8.71,79.46) 8.74,79.46 13.29,79.46 13.31,79.44 13.5,79.44 13.54,79.48 D2005.2 14.07,79.68 arc(14.13,79.72) 14.21,79.74 15.03,79.74 arc(15.31,79.68) 15.55,79.52 arc(15.65,79.45) 15.76,79.43 19.61,79.43 arc(19.75,79.46) 19.87,79.54 v1(20.11,79.78)
  IN05 w0.102: v2(26.59,75.89) 26.57,75.87 arc(26.28,75.72) 25.95,75.77 arc(25.87,75.82) 25.8,75.88 arc(25.65,76.12) 25.6,76.39 arc(24.7,78.56) 22.53,79.45 20.42,79.45 20.13,79.74 arc(20.12,79.76) v1(20.11,79.78)
  BOTTOM w0.076: 30.12,75.02 30.14,75.02 30.14,75.01 30.36,75.01 arc(30.51,75.1) 30.67,75.13 31.38,75.13 arc(31.49,75.11) 31.59,75.04 U2007.K6
  BOTTOM w0.097: 30.12,75.02 30.02,75.02 28.72,75.02 arc(28.31,75.1) 27.96,75.33 arc(27.62,75.56) 27.21,75.64 27.18,75.64 arc(26.86,75.71) v2(26.59,75.89)
TBTA_VBUS: length 12.5
  TOP w0.254: JTYPC1.A9 7.49,78.07 ; JTYPC1.A4 7.36,80.57 7.34,80.6
  IN05 w0.508: v2(29.69,78.44) 29.69,79.33 30.32,79.96 31.72,79.96 34.01,77.68 36.04,77.68 v2(37.05,76.66)
  BOTTOM w0.254: U2007.B10 U2007.A10 36.42,76.88 36.64,76.66 v2(37.05,76.66)
  vias: v1(13.08,80.6) v1(13.35,78.29) v1(15.29,80.47) v1(16.05,80.47) v1(16.1,78.06) v1(16.63,77.58) v1(16.81,80.47) v1(16.94,78.13) v2(28.42,78.44) v2(28.42,77.8) v2(29.05,78.44) v2(29.05,77.8) v2(29.69,77.8)
TBTB_HPD: length 5.8
  TOP w0.097: R2050.1 47.59,94.44 v3(48.1,94.95)
  BOTTOM w0.076: 48.83,91.39 48.83,90.89 U2005.G2
  BOTTOM w0.102: v3(48.1,94.95) 48.1,93.98 48.61,93.48 48.61,92.66 48.83,92.45 48.83,91.39
TBTB_LSRX: length 3
  BOTTOM w0.076: 44.9,88.34 45.31,88.34 45.56,88.6 45.56,88.9 45.71,89.05 46.07,89.05 U2005.B5
  BOTTOM w0.097: R2052.1 44.37,88.34 44.9,88.34
TBTB_LSTX: length 4
  TOP w0.097: v3(44.29,89.61) 43.23,90.68 R2051.1
  BOTTOM w0.076: 44.9,89.23 45.18,89.23 45.46,89.51 46.07,89.51 U2005.B4
  BOTTOM w0.097: 44.9,89.23 44.67,89.23 v3(44.29,89.61)
TBTB_RX0_N: length 45
  TOP w0.097: CM13.2 22.69,57.44 arc(22.87,57.56) 23.08,57.6 23.32,57.6 arc(23.52,57.52) v1(23.6,57.32)
  IN05 w0.102: v1(23.6,57.32) 23.65,57.37 arc(23.91,57.55) 24.23,57.61 24.43,57.61 arc(24.59,57.64) 24.73,57.74 arc(24.94,57.87) 25.18,57.92 26.9,57.92 arc(27.7,58.26) 28.04,59.06 28.04,59.39 arc(28.08,59.62) 28.22,59.82 31.59,63.2 arc(32.01,63.48) 32.51,63.58 33.23,63.58 arc(33.71,63.67) 34.13,63.91 34.16,63.91 40.52,70.27 40.52,70.31 arc(40.59,70.46) 40.61,70.61 40.61,71.95 arc(40.77,72.78) 41.24,73.49 arc(42.18,74.89) 42.51,76.55 42.51,79.93 arc(42.41,80.43) 42.13,80.85 41.73,81.25 arc(41.46,81.65) 41.37,82.12 41.37,83.39 arc(41.6,84.54) 42.24,85.51 arc(42.25,85.53) 42.26,85.54 arc(42.5,85.82) 42.85,85.92 43.11,85.92 arc(43.32,85.84) v1(43.4,85.63)
  BOTTOM w0.076: 45.66,85.37 45.9,85.37 arc(46.13,85.43) U2005.B13
  BOTTOM w0.097: v1(43.4,85.63) 43.4,85.68 arc(43.47,85.84) 43.63,85.91 44.11,85.91 arc(44.17,85.9) 44.22,85.86 44.35,85.74 arc(44.67,85.52) 45.05,85.45 45.29,85.45 arc(45.35,85.44) 45.41,85.43 arc(45.53,85.39) 45.66,85.37
TBTB_RX0_N_R: length 11.5
  TOP w0.104: CM13.1 20.73,57.45 arc(20.55,57.57) 20.34,57.61 20.25,57.61 arc(20.12,57.64) 20,57.72 19.83,57.89 arc(19.59,57.99) 19.36,57.89 D54.6 D54.5 arc(18.46,57.96) 18.32,57.99 arc(18.03,57.93) 17.78,57.77 arc(17.14,56.81) 16.91,55.68 16.91,55.26 arc(16.74,54.37) 16.24,53.63 15.03,52.42 arc(14.75,52.24) 14.43,52.17 14.2,52.17 arc(14.12,52.14) 14.09,52.07 JUSB1.5
TBTB_RX0_P: length 45
  TOP w0.097: CM13.3 22.66,58.07 arc(22.87,57.93) 23.12,57.88 23.32,57.88 arc(23.52,57.96) v1(23.6,58.16)
  IN05 w0.102: v1(23.6,58.16) 23.78,57.98 arc(23.91,57.9) 24.06,57.86 24.43,57.86 arc(24.49,57.88) 24.55,57.91 24.55,57.92 arc(24.84,58.11) 25.18,58.18 26.9,58.18 arc(27.52,58.43) 27.78,59.06 27.78,59.39 arc(27.85,59.72) 28.04,60 31.41,63.38 arc(31.92,63.72) 32.51,63.83 33.23,63.83 arc(33.62,63.9) 33.97,64.11 arc(34,64.13) 34.03,64.17 34.06,64.17 40.27,70.37 40.27,70.4 arc(40.29,70.42) 40.31,70.45 arc(40.34,70.53) 40.36,70.61 40.36,71.95 arc(40.54,72.88) 41.06,73.67 arc(41.95,74.99) 42.26,76.55 42.26,79.93 arc(42.18,80.33) 41.95,80.67 41.55,81.07 arc(41.23,81.56) 41.12,82.12 41.12,83.39 arc(41.36,84.63) 42.05,85.69 arc(42.13,85.81) 42.22,85.91 arc(42.51,86.11) 42.85,86.18 43.11,86.18 arc(43.32,86.26) v1(43.4,86.47)
  BOTTOM w0.076: 45.67,85.83 45.95,85.83 arc(46.03,85.8) 46.06,85.71 arc(46.03,85.63) 45.95,85.6 U2005.A13
  BOTTOM w0.097: v1(43.4,86.47) 43.51,86.36 arc(43.7,86.23) 43.92,86.19 44.11,86.19 arc(44.28,86.15) 44.42,86.06 44.55,85.93 arc(44.78,85.78) 45.05,85.72 45.32,85.72 arc(45.4,85.73) 45.46,85.77 arc(45.56,85.82) 45.67,85.83
TBTB_RX0_P_R: length 11.5
  TOP w0.104: JUSB1.6 14.09,52.53 arc(14.12,52.46) 14.2,52.43 14.43,52.43 arc(14.66,52.47) 14.85,52.6 14.92,52.67 16.05,53.81 arc(16.5,54.47) 16.65,55.26 16.65,55.68 arc(16.9,56.9) 17.6,57.95 arc(17.91,58.16) 18.28,58.25 18.28,58.25 arc(18.44,58.29) D54.4 D54.7 arc(19.67,58.32) 19.94,58.14 20.18,57.9 arc(20.21,57.88) 20.25,57.87 20.29,57.87 arc(20.54,57.92) 20.76,58.06 CM13.4
TBTB_TX0_N: length 42.6
  TOP w0.097: v1(25.58,59.48) arc(25.5,59.68) 25.3,59.76 25.08,59.76 arc(24.82,59.65) C621.1
  IN05 w0.102: v1(25.58,59.48) 25.84,59.74 arc(25.88,59.77) 25.92,59.77 26.02,59.77 arc(26.57,59.88) 27.05,60.2 33.13,66.26 arc(33.82,66.72) 34.63,66.88 35.28,66.88 arc(35.63,66.95) 35.93,67.15 38.58,69.8 arc(38.67,69.94) 38.7,70.11 38.7,83.09 arc(38.81,84.16) 39.12,85.19 39.58,86.29 arc(39.58,86.3) 39.59,86.31 39.75,86.47 arc(40.55,87) 41.5,87.19 41.84,87.19 arc(42.05,87.11) v1(42.13,86.9)
  BOTTOM w0.076: 45.71,86.29 45.98,86.29 arc(46.06,86.31) 46.13,86.35 U2005.B11
  BOTTOM w0.097: 45.71,86.29 45.71,86.29 45.43,86.29 arc(44.98,86.38) 44.59,86.64 44.39,86.84 arc(44.02,87.09) 43.57,87.18 42.81,87.18 arc(42.44,87.11) v1(42.13,86.9)
TBTB_TX0_N_R: length 8.2
  TOP w0.097: JUSB1.8 14.09,58.07 arc(14.12,58.13) 14.19,58.16 14.68,58.16 arc(15.13,58.25) 15.51,58.51 15.56,58.55 arc(15.93,58.8) 16.37,58.89 16.46,58.89 arc(16.86,58.96) 17.2,59.19 17.2,59.19 arc(17.54,59.42) 17.93,59.5 18.31,59.5 arc(18.46,59.47) D54.2 D54.9 arc(19.48,59.47) 19.63,59.5 19.69,59.5 arc(19.85,59.53) 19.99,59.62 arc(20.13,59.72) 20.29,59.75 20.39,59.75 arc(20.57,59.71) 20.72,59.61 CM14.1
TBTB_TX0_P: length 42.5
  TOP w0.097: v1(25.58,60.32) arc(25.5,60.12) 25.3,60.04 25.08,60.04 arc(24.82,60.15) C648.1
  IN05 w0.102: v1(25.58,60.32) 25.84,60.06 arc(25.88,60.03) 25.92,60.03 26.02,60.03 arc(26.48,60.12) 26.87,60.38 32.95,66.44 arc(33.72,66.96) 34.63,67.14 35.28,67.14 arc(35.53,67.19) 35.75,67.33 38.4,69.98 arc(38.44,70.04) 38.45,70.11 38.45,83.09 arc(38.56,84.21) 38.89,85.29 39.34,86.39 arc(39.37,86.44) 39.41,86.49 39.57,86.65 arc(40.45,87.24) 41.5,87.45 41.84,87.45 arc(42.05,87.53) v1(42.13,87.74)
  BOTTOM w0.076: U2005.A11 45.89,86.52 arc(45.97,86.55) 46,86.64 46,86.67 arc(45.98,86.73) 45.93,86.75 45.73,86.75
  BOTTOM w0.097: v1(42.13,87.74) arc(42.44,87.53) 42.81,87.46 43.57,87.46 arc(44.12,87.35) 44.58,87.04 44.78,86.84 arc(45.02,86.67) 45.3,86.58 arc(45.43,86.59) 45.55,86.67 arc(45.63,86.73) 45.73,86.75
TBTB_TX0_P_R: length 8.2
  TOP w0.097: JUSB1.9 14.09,58.53 arc(14.12,58.47) 14.19,58.44 14.68,58.44 arc(15.03,58.51) 15.32,58.7 15.36,58.74 arc(15.82,59.05) 16.37,59.16 16.46,59.16 arc(16.75,59.22) 17,59.38 17,59.39 arc(17.43,59.67) 17.93,59.77 18.31,59.77 arc(18.46,59.8) D54.1 D54.10 arc(19.48,59.8) 19.63,59.77 19.69,59.77 arc(19.75,59.78) 19.8,59.82 arc(20.02,59.97) 20.29,60.02 20.31,60.02 arc(20.54,60.07) 20.73,60.2 CM14.4
TBTB_USB2_D_N: length 56.9
  IN03 w0.102: v2(47.32,82.49) 46.99,82.82 46.18,82.82 42.39,79.02 42.39,78.33 40.74,76.68 40.74,71.98 36.9,68.15 34.51,68.15 31.34,71.33 31.34,72.34 29.56,74.12 25.62,74.12 23.97,72.47 23.97,61.82 22.05,59.9 18.41,59.9 18.13,60.17 18.13,60.57 v1(17.91,60.79)
  BOTTOM w0.097: CM15.2 17.65,59.56 17.94,59.85 17.94,60.05 18.2,60.31 18.2,60.5 v1(17.91,60.79) ; U2005.D19 47,82.81 v2(47.32,82.49)
TBTB_USB2_D_N_R: length 9.2
  BOTTOM w0.097: JUSB1.2 12.31,56.02 12.31,55.58 12.55,55.35 13,55.35 13.79,54.56 15.97,54.56 v1(16.73,55.32) 17.24,55.83 17.68,55.83 17.75,55.9 D33.2 17.96,56.24 17.99,56.27 17.99,56.54 17.94,56.59 17.94,56.9 17.65,57.19 CM15.1
TBTB_USB2_D_P: length 56.9
  IN03 w0.102: v1(18.77,60.79) 18.49,60.79 18.38,60.68 18.38,60.28 18.51,60.15 21.94,60.15 23.72,61.93 23.72,72.58 25.52,74.37 29.67,74.37 31.59,72.45 31.59,71.43 34.62,68.41 36.8,68.41 40.48,72.09 40.48,76.79 42.13,78.44 42.13,79.13 46.07,83.07 46.87,83.07 46.93,83.13 46.93,83.25 47.02,83.34 47.22,83.34 47.32,83.24 v2(47.32,83.13)
  BOTTOM w0.097: v2(47.32,83.13) 47.64,82.81 U2005.E19 ; v1(18.77,60.79) 18.48,60.5 18.48,60.19 18.22,59.93 18.22,59.8 18.5,59.51 CM15.3
TBTB_USB2_D_P_R: length 9.3
  BOTTOM w0.097: CM15.4 18.5,57.19 18.22,56.9 18.22,56.7 18.27,56.65 18.27,56.27 18.31,56.24 D33.1 18.31,55.8 18.06,55.56 17.35,55.56 16.08,54.29 v1(15.58,54.29) 13.67,54.29 12.89,55.07 12.67,55.07 12.59,54.99 JUSB1.3
TGR_1.2V: length 5.4
  BOTTOM w0.508: v1(112.87,87.58) v1(112.24,87.58) 112.11,87.46 110.46,87.46 v2(109.82,86.82) 108.65,85.65 PQ401.4
TGR_3V: length 13.6
  TOP w0.203: v1(47.09,13.8) 46.83,13.8 46.58,14.05 PU301.8
  TOP w0.508: PC310.1 v1(47.09,13.8)
  IN03 w0.762: v1(47.09,13.8) 47.98,14.68 47.98,24.46 48.36,24.84 48.36,24.97
  vias: v1(48.36,26.37) v1(48.36,25.73) v2(47.72,25.73)
TGR_5V: length 15.9
  TOP w0.254: 42.01,13.41 42.01,13.54 42.51,14.05 PU301.18
  TOP w0.508: v1(42.03,13.41) PC309.2
  IN10 w0.762: v1(42.03,13.41) 40.74,13.41 38.7,15.45 38.7,19.57 38.38,19.89 34.77,19.89 34.13,20.53 v1(34.13,21.16)
  vias: v2(33.6,21.42)
THERM_ALERT_N: length 10.3
  TOP w0.097: Q93.1 244.52,108.57 R982.2 244.52,109.55 244.04,110.03 243.54,110.03 241.73,111.84 239.87,111.84 238.86,112.86 238.86,113.74 238.33,114.27 v3(238.29,114.27)
  BOTTOM w0.097: v3(238.29,114.27) G2.BJ3
THERMDA: length 0.5
  BOTTOM w0.178: U2005.AC23 U2005.AB23
TP_LED_GND: length 2.3
  BOTTOM w0.356: JTPBL1.6 v1(284.85,22.79) ; JTPBL1.1 v1(289.85,22.79)
TP_PS2_CLK: length 283.9
  TOP w0.097: v1(275.69,19.13) 275.86,19.31 R576.1
  IN03 w0.091: v1(39.97,43.39) 40.48,42.88 45.82,42.88 46.2,42.5 52.17,42.5 54.96,45.29 62.58,45.29 64.99,47.7 66.19,47.7 66.57,47.32 66.57,44.85 68.6,42.82 71.11,42.82 71.42,43.13 73.88,43.13 75.53,41.48 82.39,41.48 83.56,42.65 90.49,42.65 91.16,41.99 106.41,41.99 107.42,40.97 108.25,40.97 118.6,51.32 152.3,51.32 159.6,44.02 209.91,44.02 215.08,38.86 256.03,38.86 259.55,42.37 263,42.37 266.03,39.33 266.03,25.86 267.3,24.59 267.3,21.67 270.35,18.62 275.18,18.62 v1(275.69,19.13)
  BOTTOM w0.097: U5.A11 37.28,47.99 38.58,46.69 39.29,46.69 R241.1 40.64,45.11 40.36,44.83 40.36,43.77 v1(39.97,43.39)
TP_PS2_CLK_R: length 4.6
  TOP w0.097: v1(276.32,22.81) 276.84,22.29 D40.2 276.84,21.22 276.78,21.16 C643.1 R576.2
  BOTTOM w0.097: JTP1.2 275.85,23.28 v1(276.32,22.81)
TP_PS2_DAT: length 280
  TOP w0.097: R575.1 274.24,19.31 v1(274.42,19.13)
  IN03 w0.091: v1(274.42,19.13) 270.35,19.13 267.81,21.67 267.81,24.44 266.29,25.97 266.29,39.44 263.1,42.62 259.44,42.62 255.89,39.07 215.22,39.07 210.01,44.28 159.7,44.28 152.44,51.54 118.5,51.54 112.38,45.42 109.95,45.42 107.97,43.44 106.95,43.44 105.76,42.24 91.41,42.24 90.78,42.87 83.27,42.87 82.39,41.99 78.33,41.99 76.8,43.51 71.49,43.51 71.02,43.04 68.77,43.04 66.79,45.02 66.79,47.41 66.25,47.96 64.87,47.96 62.45,45.55 54.71,45.55 52.67,43.51 46.58,43.51 46.28,43.81 42.31,43.81 v1(41.88,43.39)
  BOTTOM w0.076: U5.B11 37.52,50.16 37.52,49.61
  BOTTOM w0.097: 37.52,49.61 37.52,48.15 38.6,47.07 39.47,47.07 40.99,45.55 41.32,45.55 R242.1 42.26,44.61 42.26,43.77 v1(41.88,43.39)
TP_PS2_DAT_R: length 5.2
  TOP w0.097: R575.2 C644.1 273.32,21.03 273.26,21.1 D41.2 273.26,22.17 273.91,22.81 v1(274.54,22.81)
  BOTTOM w0.097: JTP1.3 274.85,23.12 v1(274.54,22.81)
TP_SKL_BJ13: length 3.5
  TOP w0.097: TP14.1 155.16,140.36 v1(155.29,140.24)
  BOTTOM w0.097: U1.BJ13 153.82,139.24 153.55,139.52 153.55,139.91 153.67,140.03 154.3,140.03 154.5,140.24 v1(155.29,140.24)
TP_SKL_BJ14: length 1.4
  TOP w0.097: v1(154.62,139.78) 154.49,139.65 TP13.1
  BOTTOM w0.097: v1(154.62,139.78) 154.5,139.67 U1.BJ14
TP_SKL_BJ16: length 2
  TOP w0.097: TP20.1 155.09,141.48 v1(155.11,141.51)
  BOTTOM w0.097: v1(155.11,141.51) 154.91,141.3 154.22,141.3 154.12,141.2 U1.BJ16
TP_SKL_BJ24: length 3
  TOP w0.097: v1(155.32,146.18) 155.82,146.18 TP27.1
  BOTTOM w0.097: v1(155.32,146.18) 155.32,147.02 154.93,147.4 154.3,147.4 154.2,147.5 U1.BJ24
TP_SKL_BJ33: length 2.7
  TOP w0.097: v1(153.88,153.87) 154.03,153.87 154.27,153.62 154.27,152.1 TP37.1
  BOTTOM w0.097: U1.BJ33 153.55,154.19 v1(153.88,153.87)
TP_SKL_BJ34: length 2
  TOP w0.097: v2(153.51,153.24) 153.5,153.25 153.5,154.14 v1(153.88,154.52)
  BOTTOM w0.097: v1(153.88,154.52) 153.55,154.84 U1.BJ34
TP_SKL_BK16: length 2.1
  TOP w0.097: v3(152.88,140.81) 153.13,140.81 153.4,140.54 153.77,140.54 TP22.1
  BOTTOM w0.097: U1.BK16 152.88,140.86 v3(152.88,140.81)
TP_SKL_BK24: length 2.6
  TOP w0.097: v2(154.15,148.57) 154.15,148.35 v1(154.66,147.83)
  BOTTOM w0.102: U1.BK24 153.63,147.91 154.59,147.91 v1(154.66,147.83)
TP_SKL_BL33: length 1.3
  TOP w0.097: v1(153.09,154.52) 152.96,154.38 TP8.1
  BOTTOM w0.097: v1(153.09,154.52) 152.77,154.19 U1.BL33
TP_SKL_BM33: length 2.1
  TOP w0.097: TP6.1 150.67,153.8 151.2,153.8 v1(151.59,154.2)
  BOTTOM w0.097: U1.BM33 151.92,153.87 v1(151.59,154.2)
TP_SKL_BR1: length 3.3
  BOTTOM w0.097: TP11.1 148.56,129.49 149.88,130.82 U1.BR1
TP_SKL_BT2: length 3.1
  BOTTOM w0.097: U1.BT2 148.44,130.51 147.67,130.51 147.16,131.02 TP12.1
TP_SKL_D1: length 6.4
  BOTTOM w0.097: U1.D1 187.96,130.74 188.39,130.31 190.16,130.31 190.85,129.62 193.64,129.62 TP5.1
TP_SKL_E1: length 9.9
  BOTTOM w0.097: U1.E1 187.5,130.82 188.18,130.13 189.83,130.13 190.6,129.37 193.9,129.37 195.42,130.89 TP7.1
TP_SKL_E2: length 5.1
  BOTTOM w0.097: TP10.1 191.1,130.76 190.83,130.49 188.46,130.49 188.31,130.64 188.31,131.02 187.86,131.47 U1.E2
TP_SKL_E3: length 6.5
  BOTTOM w0.097: U1.E3 187.47,132.11 188.41,131.17 188.97,131.17 189.12,131.02 190.62,131.02 191.26,131.65 TP9.1
TP_SMB_CLK: length 2.7
  TOP w0.097: v1(272.38,22.81) R573.2
  BOTTOM w0.097: v1(272.38,22.81) 272.85,23.28 JTP1.5
TP_SMB_DAT: length 4
  TOP w0.097: v1(270.48,22.81) 270.48,22.79 271.5,21.77 R572.2
  BOTTOM w0.097: JTP1.6 271.85,23.96 270.99,23.96 270.48,23.45 v1(270.48,22.81)
TSENSE_1PH_A: length 5.4
  TOP w0.203: v1(121.71,188.5) 121.71,189.13 122.58,190 PU1101.11
  TOP w0.254: PC1163.1 121.03,187.4 121.71,188.09 v1(121.71,188.5)
  BOTTOM w0.254: PR1182.2 121.53,188.32 v1(121.71,188.5)
TSENSE_3PH_A: length 4.7
  TOP w0.203: v1(131.59,194.14) 131.29,194.14 130.35,193.2 PU1101.37
  BOTTOM w0.254: PC1162.1 130.45,193.88 PR1180.2 131.41,193.96 v1(131.59,194.14)
TURBO_BTN_N: length 38.2
  IN10 w0.091: v3(70.33,18.44) 70.33,20.15 69.18,21.29 57.5,21.29 v1(55.72,23.07)
  BOTTOM w0.097: v1(55.72,23.07) 55.21,23.57 55.21,29.8 v2(55.47,30.05) 55.47,37.42 54.96,37.93 R832.2 ; JKB1.44 70.09,16.19 69.69,16.59 69.69,16.84 69.87,17.02 69.87,18.16 70.15,18.44 v3(70.33,18.44)
TURBO_GPIO1: length 26.5
  IN08 w0.091: v1(45.82,37.04) 45.82,37.42 45.05,38.18 45.05,41.86 44.8,42.12 44.8,49.61 43.4,51.01 v1(43.28,51.01)
  BOTTOM w0.097: v1(45.82,37.04) 46.32,36.53 47.21,36.53 48.48,37.8 53.18,37.8 54.07,38.69 R833.2 ; R546.1 v1(43.28,51.01)
TURBO_GPIO3: length 43.9
  TOP w0.097: R526.1 29.3,48.27 v2(29.81,47.76)
  IN03 w0.091: v1(57.5,44.78) 55.34,44.78 52.72,42.16 48.78,42.16 48.1,41.48 45.61,41.48 44.46,42.62 39.97,42.62 39.64,42.95 37.26,42.95 36.55,42.24 36.55,41.77 34.86,40.08 33.88,40.08 v1(33.24,39.45)
  IN08 w0.089: v2(29.81,47.76) 29.81,47.45 30.58,46.69
  IN08 w0.091: v1(33.24,39.45) 32.04,40.66 32.04,45.23 30.58,46.69
  BOTTOM w0.097: R844.1 56.79,47.53 57.5,46.82 v1(57.5,44.78)
TURBO_LED: length 20.9
  TOP w0.097: R896.2 68.55,3.25 v1(68.42,3.13)
  IN05 w0.089: 69.57,5.54 69.69,5.67 69.69,6.05 72.74,9.1 72.74,13.29 71.98,14.05 67.41,14.05 v2(67.03,14.43)
  IN05 w0.091: 69.57,5.54 68.42,4.4 v1(68.42,3.13)
  BOTTOM w0.089: v2(67.03,14.43) 67.41,14.81 67.79,14.81 68.04,15.07
  BOTTOM w0.097: 68.04,15.07 68.09,15.12 JKB1.48
UG_3V: length 11.9
  IN05 w0.762: 50.52,25.48 49.25,25.48 48.66,24.9 48.66,17.28 v1(47.09,15.7)
  vias: v1(50.39,26.6) v1(51.02,26.6)
UG_5V: length 10.4
  BOTTOM w0.762: 36.65,21.29 37.69,21.29 38.7,20.27 38.7,15.9 39.21,15.4 v1(42.06,15.4)
  vias: v1(35.15,21.29) v1(35.78,21.29) v2(35.78,21.92)
USB2_CHG_PN: length 6.3
  TOP w0.104: U21.11 19.65,39.71 19.53,39.83 19.53,40.05 19.37,40.21 v1(18.89,40.21) 18.39,40.21 18,40.59 18,41.74 17.88,41.86 16.96,41.86 16.86,41.76 16.86,41.61 16.99,41.48 17.16,41.48 17.28,41.35 CM12.2
USB2_CHG_PN_R: length 22.5
  TOP w0.104: JUSB2.2 10.68,30.07 10.68,29.29 10.45,29.06 8.8,29.06 8.23,29.63 8.23,36.91 9.24,37.93 v1(12.29,37.93) 13.12,37.93 14.09,36.96 15.31,36.96 15.6,37.25 15.6,37.44 D49.2 15.68,37.52 16.07,37.52 16.35,37.8 16.82,37.8 17.28,38.27 CM12.1
USB2_CHG_PP: length 6.3
  TOP w0.104: U21.10 19.73,40.21 19.47,40.47 18.49,40.47 18.26,40.7 18.26,41.84 17.98,42.12 v1(17.37,42.12) 16.86,42.12 16.61,41.87 16.61,41.35 16.44,41.18 CM12.3
USB2_CHG_PP_R: length 22.5
  TOP w0.104: JUSB2.3 9.95,28.8 8.7,28.8 7.97,29.53 7.97,37.02 9.13,38.18 v1(9.49,38.18) 13.23,38.18 14.19,37.21 15.2,37.21 15.35,37.36 15.35,37.65 15.54,37.85 D49.1 15.75,37.85 15.83,37.77 15.96,37.77 16.25,38.05 16.71,38.05 16.99,38.33 16.99,38.49 16.88,38.59 16.57,38.59 16.44,38.72 CM12.4
USB2_COMP: length 1.7
  TOP w0.097: R130.1 246.81,60.35 v3(246.35,59.9)
  BOTTOM w0.097: U2.AG3 246.46,60 v3(246.35,59.9)
USB2_DN1: length 90.9
  IN05 w0.114: v1(306.17,43.83) 306.17,43.7 305.81,43.34 304.57,43.34 298.04,49.86 298.04,52.91 289.14,61.81 280.88,61.81 280.51,62.18 280.51,67.77 279.37,68.91 276.58,68.91 274.17,66.5 260.54,66.5 260.09,66.95 258.23,66.95 256.91,65.62 255.89,65.62 253.34,63.07 248.25,63.07 247.49,62.31 247.49,60.15 246.75,59.41 245.45,59.41 245.32,59.53 245.32,59.77 245.45,59.9 v3(245.59,59.9)
  BOTTOM w0.104: v1(306.17,43.83) 305.91,43.58 304.62,43.58 301.5,40.45 301.09,40.45 301.02,40.52 JIO1.32 ; U2.AF5 245.58,59.95 245.58,59.9 v3(245.59,59.9)
USB2_DN2: length 257.1
  TOP w0.104: U21.2 23.79,39.71 23.99,39.91 24.48,39.91 24.61,39.78 v1(24.61,39.58)
  IN03 w0.076: v3(245.97,60.91) 245.77,60.72 245.77,60.57 245.57,60.37 243.35,60.37 243.2,60.22 243.2,60.14 243.2,60.13
  IN03 w0.114: 243.2,60.13 242.27,59.21 242.27,58.49 241.51,57.73 241.13,57.73 240.37,56.97 240.37,52.78 239.82,52.23 239.24,52.23 238.72,52.75 238.36,52.75 237.98,52.37 236.74,52.37 236.33,52.77 235.79,52.77 234.52,51.5 231.64,51.5 230.26,50.12 224.12,50.12 223.24,51.01 223.24,51.77 221.84,53.17 221.08,53.17 218.92,55.32 217.9,55.32 215.74,57.48 197.46,57.48 194.68,60.27 192.1,60.27 191.72,59.88 134.86,59.88 132.81,61.93 127.48,61.93 125.95,63.45 116.81,63.45 115.3,64.96 109.3,64.96 107.79,63.45 99.92,63.45 99.03,64.34 94.76,64.34 90.06,59.64 75.8,59.64 75.28,59.12 69.43,59.12 68.93,58.63 60.05,58.63 58.27,56.85 54.71,56.85 53.56,57.99 47.98,57.99 46.83,56.85 37.56,56.85 37.43,56.72 34.36,56.72 31.17,53.53 30.05,53.53 29.19,52.67 29.19,51.78 28.72,51.31 28.21,51.31 24.75,47.84 24.75,42.36 25.51,41.59 25.51,40.26 25.09,39.83 24.7,39.83 24.61,39.74 v1(24.61,39.58)
  BOTTOM w0.104: v3(245.97,60.91) 246.14,61.09 U2.AD5
USB2_DN3: length 233.2
  IN05 w0.076: 246.5,60.51 246.49,60.5 246.41,60.5 246.2,60.29 244.43,60.29 244.32,60.18 v3(244.32,59.9)
  IN05 w0.114: v1(160.6,195.98) 160.79,196.16 160.79,198.23 161.53,198.97 167.08,198.97 168.48,197.58 177.63,197.58 178.26,196.94 184.77,196.94 186.42,198.59 199.36,198.59 200.64,197.31 206.21,197.31 209.72,193.81 209.72,192.48 212.33,189.87 212.33,185.14 211.81,184.61 211.81,173.05 211.3,172.55 211.3,168.74 209.79,167.22 209.79,158.44 211.68,156.55 211.68,153.24 214.48,150.43 214.48,141.8 217.63,138.65 221.82,138.65 225.89,134.59 232.11,134.59 233.38,133.32 243.92,133.32 244.83,132.41 244.83,121.49 245.46,120.86 245.46,109.17 245.33,109.05 245.33,102.95 241.78,99.4 241.78,88.22 242.7,87.29 242.7,85.11 245.93,81.88 248.62,81.88 250.92,79.58 250.92,70.44 252.32,69.04 252.32,67.01 250.92,65.61 249.52,65.61 246.73,62.82 246.73,60.74 246.5,60.51
  BOTTOM w0.104: v1(160.6,195.98) 160.89,196.26 160.89,197.05 160.71,197.22 JCAM1.2 ; v3(244.32,59.9) 244.32,60.11 U2.AG8
USB2_DN4: length 236.1
  IN03 w0.114: v1(69.57,45.29) 69.31,45.55 69.31,45.8 69.95,46.43 72.99,46.43 75.9,49.34 77.8,49.34 79.58,51.12 81.61,51.12 82.12,51.63 89.36,51.63 90.9,53.17 94.46,53.17 95.1,52.53 99.03,52.53 100.81,54.31 105.13,54.31 106.65,55.83 125.09,55.83 126.61,54.32 154.01,54.32 159.75,48.58 174.73,48.58 175.5,47.82 200.9,47.82 201.79,46.93 210.17,46.93 215.96,41.14 240.54,41.14 242.54,43.13 242.54,46.05 242.29,46.31 242.29,47.32 242.92,47.96 244.32,47.96 244.57,48.21 247.37,48.21 248.38,49.23 250.16,49.23 251.31,50.38 251.31,60.39 250.67,61.04 250.01,61.04 249.64,61.42 249.64,61.98 v3(249.82,62.17)
  BOTTOM w0.104: R917.1 66.77,26.14 66.77,33.76 69.34,36.32 v1(69.34,44.02) 69.34,44.02 69.34,45.07 v1(69.57,45.29) ; U2.AE1 248.39,61.51 249.28,61.51 249.51,61.73 249.51,62.07 249.6,62.17 v3(249.82,62.17)
USB2_DN4_R: length 14.5
  BOTTOM w0.104: JKB1.40 72.09,16.1 71.97,16.22 71.97,20.4 71.53,20.85 70.83,20.85 70.07,21.61 68.63,21.61 68.45,21.78 D48.2 68.23,21.85 67.69,21.85 67.53,21.68 67.53,21.55 67.42,21.44 v1(67.13,21.44) 66.85,21.44 66.67,21.62 66.67,24.66 66.95,24.95 R917.2
USB2_DN5: length 45.7
  IN10 w0.114: v1(256.13,68.93) 255.91,68.93 255.79,68.82 255.79,68.48 255.98,68.29 258.3,68.29 258.67,68.66 264.26,68.66 265.8,70.2 271.46,70.2 271.61,70.05 273.44,70.05 273.65,70.26 v1(273.65,70.47)
  BOTTOM w0.076: U2.AC2 247.72,62.28 248.13,62.69 248.21,62.69 248.21,62.7
  BOTTOM w0.104: v1(256.13,68.93) 255.96,68.93 255.72,68.69 255.72,68.31 255.43,68.02 253.15,68.02 251.91,66.78 251.91,66.11 250.54,64.74 250.54,63.58 249.83,62.87 248.39,62.87 248.29,62.77 248.21,62.7 ; v1(273.65,70.47) 273.58,70.39 273.58,70.22 273.68,70.12 274.44,70.12 274.78,70.46 274.78,72.3 275.18,72.7 276.6,72.7 279.99,76.1 279.99,77.88 279.75,78.13 JWLAN1.5
USB2_DN6: length 77.1
  IN10 w0.114: v3(251.3,62.17) 251.04,62.17 250.92,62.05 250.92,61.87 251.04,61.75 256.32,61.75 257.53,62.96 257.53,63.71 258.16,64.34 263.88,64.34 264.78,65.24 268.81,65.24 270.21,63.85 270.68,63.85 270.79,63.96 270.79,64.92 271.06,65.19 271.74,65.19 272.01,64.92 272.01,63.96 272.12,63.85 272.58,63.85 272.7,63.96 272.7,64.92 272.97,65.19 273.64,65.19 273.91,64.92 273.91,63.96 274.03,63.85 275.8,63.85 280.75,58.89 284.43,58.89 284.81,58.51 286.08,58.51 287.24,57.36 288.39,57.36 288.88,56.86 289.89,56.86 290.67,56.08 290.67,48.47 291.43,47.7 291.81,47.7 292.34,47.18 292.34,46.04 292.96,45.41 292.96,44.4 294.46,42.9 295.64,42.9 295.76,43.01 v1(295.76,43.27)
  BOTTOM w0.104: v1(295.76,43.27) 296.09,42.93 297.86,42.93 299.14,41.65 299.77,41.65 299.85,41.72 JIO1.29 ; U2.AF2 247.65,60.57 248.26,60.57 248.6,60.91 249.65,60.91 250.08,61.34 250.69,61.34 250.97,61.62 250.97,62.05 251.09,62.17 v3(251.3,62.17)
USB2_DP1: length 90.9
  IN05 w0.114: v1(306.17,43.07) 304.46,43.07 297.77,49.75 297.77,52.8 289.02,61.55 280.77,61.55 280.25,62.07 280.25,67.66 279.25,68.65 276.69,68.65 274.28,66.23 260.43,66.23 259.98,66.68 258.34,66.68 257.02,65.36 256,65.36 253.45,62.81 248.36,62.81 247.76,62.2 247.76,60.04 246.86,59.14 245.32,59.14 245.05,59.42 245.05,59.8 v3(244.95,59.9)
  BOTTOM w0.104: v3(244.95,59.9) 244.95,60.12 245.24,60.41 U2.AG7 ; v1(306.17,43.07) 305.91,43.32 304.73,43.32 301.6,40.19 301.09,40.19 301.02,40.12 JIO1.33
USB2_DP2: length 257.1
  TOP w0.104: v1(24.61,40.59) 24.61,40.35 24.42,40.16 23.86,40.16 23.82,40.21 U21.3
  IN03 w0.076: 243.01,60.32 243.01,60.33 243.09,60.33 243.29,60.52 245.5,60.52 245.62,60.63 245.62,60.8 245.5,60.91 v3(245.33,60.91)
  IN03 w0.114: v1(24.61,40.59) 24.61,40.24 24.75,40.1 24.98,40.1 25.25,40.37 25.25,41.48 24.48,42.25 24.48,47.95 28.1,51.58 28.61,51.58 28.93,51.89 28.93,52.78 29.94,53.8 31.06,53.8 34.25,56.99 37.32,56.99 37.45,57.12 46.72,57.12 47.86,58.26 53.67,58.26 54.82,57.12 58.16,57.12 59.94,58.89 68.82,58.89 69.31,59.39 75.17,59.39 75.69,59.91 89.95,59.91 94.65,64.61 99.14,64.61 100.03,63.72 107.68,63.72 109.19,65.23 115.41,65.23 116.92,63.72 126.06,63.72 127.59,62.2 132.92,62.2 134.97,60.15 191.61,60.15 191.99,60.53 194.79,60.53 197.57,57.75 215.85,57.75 218.01,55.59 219.03,55.59 221.19,53.43 221.95,53.43 223.5,51.88 223.5,51.12 224.23,50.39 230.15,50.39 231.53,51.77 234.41,51.77 235.68,53.04 236.44,53.04 236.85,52.63 237.87,52.63 238.25,53.01 238.83,53.01 239.35,52.49 239.71,52.49 240.1,52.89 240.1,57.08 241.02,57.99 241.4,57.99 242.01,58.6 242.01,59.32 243.01,60.32
  BOTTOM w0.104: v3(245.33,60.91) 245.45,61.03 245.45,61.44 U2.AD7
USB2_DP3: length 233.2
  IN05 w0.076: v1(243.68,59.9) 243.56,60.02 243.56,60.16 243.69,60.29 244.21,60.29 244.36,60.44 246.13,60.44 246.33,60.64 246.3,60.68 246.3,60.69 246.31,60.7
  IN05 w0.114: v1(161.42,195.98) 161.35,195.91 161.17,195.91 161.06,196.02 161.06,198.12 161.64,198.71 166.97,198.71 168.37,197.31 177.52,197.31 178.15,196.68 184.88,196.68 186.53,198.33 199.25,198.33 200.53,197.04 206.1,197.04 209.45,193.7 209.45,192.37 212.06,189.76 212.06,185.25 211.54,184.73 211.54,173.16 211.03,172.66 211.03,168.85 209.52,167.33 209.52,158.33 211.41,156.44 211.41,153.13 214.22,150.32 214.22,141.68 217.52,138.38 221.71,138.38 225.78,134.32 232,134.32 233.27,133.05 243.81,133.05 244.56,132.3 244.56,121.38 245.19,120.75 245.19,109.28 245.07,109.16 245.07,103.06 241.51,99.51 241.51,88.11 242.44,87.18 242.44,85 245.82,81.61 248.51,81.61 250.65,79.47 250.65,70.33 252.05,68.93 252.05,67.12 250.81,65.88 249.41,65.88 246.46,62.93 246.46,60.85 246.31,60.7
  BOTTOM w0.104: v1(243.68,59.9) 243.94,60.16 243.94,60.32 U2.AG10 ; v1(161.42,195.98) 161.15,196.25 161.15,197.07 161.31,197.24 JCAM1.3
USB2_DP4: length 236.1
  IN03 w0.114: v3(249.08,62.17) 249.37,61.88 249.37,61.31 249.9,60.77 250.56,60.77 251.05,60.28 251.05,50.49 250.05,49.5 248.27,49.5 247.25,48.48 244.46,48.48 244.21,48.23 242.81,48.23 242.02,47.43 242.02,46.2 242.27,45.94 242.27,43.24 240.43,41.4 216.07,41.4 210.28,47.2 201.9,47.2 201.01,48.09 175.61,48.09 174.84,48.85 159.86,48.85 154.12,54.59 126.72,54.59 125.2,56.1 106.54,56.1 105.01,54.58 100.7,54.58 98.92,52.8 95.21,52.8 94.57,53.43 90.79,53.43 89.25,51.9 82.01,51.9 81.5,51.39 79.47,51.39 77.69,49.61 75.79,49.61 72.88,46.7 69.84,46.7 69.04,45.91 69.04,45.46 v1(68.88,45.29)
  BOTTOM w0.104: R918.1 66.52,26.22 66.52,33.86 69.08,36.43 v1(69.08,42.5) 69.08,45.09 v1(68.88,45.29) ; U2.AE2 247.84,61.46 247.98,61.46 248.29,61.77 249.18,61.77 249.25,61.84 249.25,62 v3(249.08,62.17)
USB2_DP4_R: length 14.5
  BOTTOM w0.104: R918.2 66.41,24.7 v1(66.41,23.91) 66.41,21.52 66.74,21.19 67.82,21.19 68.09,20.92 D37.2 68.4,20.82 68.76,20.82 68.95,21.01 68.95,21.27 69.03,21.35 69.96,21.35 70.72,20.59 71.42,20.59 71.72,20.29 71.72,16.22 71.59,16.1 JKB1.41
USB2_DP5: length 45.7
  IN10 w0.114: v1(273.65,69.65) 273.52,69.78 271.5,69.78 271.35,69.93 265.91,69.93 264.37,68.39 258.78,68.39 258.41,68.02 255.87,68.02 255.6,68.3 255.6,68.65 v1(255.33,68.91)
  BOTTOM w0.076: 248.03,62.88 248.02,62.87 248.02,62.8 247.77,62.54 247.19,62.54 U2.AC3
  BOTTOM w0.104: 248.03,62.88 248.1,62.95 248.28,63.13 249.72,63.13 250.28,63.69 250.28,64.85 251.66,66.22 251.66,66.89 253.05,68.28 255.32,68.28 255.46,68.41 255.46,68.69 255.33,68.82 v1(255.33,68.91) ; v1(273.65,69.65) 273.86,69.86 274.54,69.86 275.03,70.35 275.03,72.19 275.29,72.45 276.7,72.45 280.25,75.99 JWLAN1.3
USB2_DP6: length 77.1
  IN10 w0.114: v1(295.76,42.37) 295.76,42.39 295.51,42.63 294.35,42.63 292.69,44.29 292.69,45.3 292.07,45.93 292.07,47.07 291.7,47.44 291.32,47.44 290.41,48.36 290.41,55.97 289.78,56.59 288.77,56.59 288.28,57.09 287.13,57.09 285.97,58.25 284.7,58.25 284.32,58.63 280.64,58.63 275.69,63.58 273.92,63.58 273.65,63.85 273.65,64.81 273.53,64.92 273.08,64.92 272.96,64.81 272.96,63.85 272.69,63.58 272.01,63.58 271.74,63.85 271.74,64.81 271.63,64.92 271.17,64.92 271.06,64.81 271.06,63.85 270.79,63.58 270.1,63.58 268.7,64.98 264.89,64.98 263.99,64.08 258.27,64.08 257.79,63.6 257.79,62.85 256.43,61.48 250.93,61.48 250.65,61.76 250.65,62.07 v2(250.55,62.17)
  BOTTOM w0.104: JIO1.30 299.84,41.32 299.77,41.39 299.03,41.39 297.75,42.67 296.06,42.67 v1(295.76,42.37) ; U2.AF3 247.4,60.82 248.15,60.82 248.49,61.17 249.54,61.17 249.97,61.6 250.58,61.6 250.72,61.73 250.72,62 v2(250.55,62.17)
USB2_OTG_ID: length 4.2
  BOTTOM w0.097: U2.AG2 247.6,60 247.87,60.28 248.46,60.28 248.74,60.56 v2(250.16,60.56) 250.74,60.56 R63.2
USB3_RX_DN1: length 99.3
  IN10 w0.114: v1(303.98,39.96) 304.16,39.96 304.36,40.15 304.36,40.68 304.21,40.83 304.21,41.11 304.36,41.26 304.36,41.59 304.21,41.74 304.21,42.03 304.36,42.17 304.36,42.51 304.21,42.65 304.21,42.94 304.36,43.09 304.36,44.81 303.25,45.93 298.8,45.93 296.88,47.84 296.88,55.08 290.28,61.69 290.28,68.04 288.25,70.07 288.25,72.61 287.5,73.36 284.96,73.36 283.81,72.22 275.67,72.22 275.17,72.72 270.86,72.72 270.47,73.12 270.47,74.39 269.72,75.14 267.81,75.14 266.67,73.99 264.64,73.99 262.48,71.83 258.93,71.83 258.54,72.22 258.54,73.36 257.54,74.36 253.32,74.36 252.45,73.49 250.27,73.49 249.54,74.22 246.03,74.22 245.5,73.76 245.48,73.52 v1(245.54,73.46)
  BOTTOM w0.104: JIO1.38 300.87,38.12 300.95,38.04 303.49,38.04 304.37,38.92 304.37,39.96 304.25,40.07 304.09,40.07 v1(303.98,39.96) ; v1(245.54,73.46) 245.36,73.28 245.36,72.75 245.15,72.54 U2.B7
USB3_RX_DN3: length 282.3
  TOP w0.104: R530.1 18.29,27.47 CM10.2 18.94,27.47 19.23,27.76 19.68,27.76 19.91,27.54 v1(19.91,27.46)
  IN03 w0.114: v1(19.91,27.46) 20.1,27.46 20.23,27.59 20.23,27.84 20.1,27.96 19.73,27.96 19.55,28.13 19.28,28.13 19.07,27.92 19.07,27.33 19.64,26.76 21.83,26.76 24.09,29.02 24.09,34.16 23.93,34.32 23.26,34.32 22.83,34.75 22.83,38.81 23.07,39.06 23.07,47.82 25.36,50.1 25.36,52.39 26.78,53.81 27.42,53.81 28.28,54.67 28.28,56.45 28.94,57.12 33.01,57.12 34.01,58.12 45.31,58.12 46.59,59.4 54.31,59.4 55.24,58.47 57.85,58.47 60.69,61.31 68.57,61.31 68.69,61.43 85.08,61.43 90.54,66.89 101.93,66.89 102.82,66.01 105.02,66.01 105.91,66.89 109.43,66.89 110.06,66.26 115.65,66.26 116.94,64.98 126.21,64.98 127.99,63.2 136.75,63.2 137.76,62.18 195.79,62.18 199.33,58.64 216.36,58.64 218.39,56.61 220.71,56.61 222.27,58.17 236.03,58.17 236.79,58.93 236.79,61.18 237.5,61.89 240.45,61.89 241.9,63.35 241.9,65.87 243.45,67.42 243.45,68.05 243.92,68.52 243.92,72.07 244.38,72.53 244.38,73.17 244.25,73.29 244.11,73.29 243.99,73.42 v3(243.99,73.54)
  BOTTOM w0.104: v3(243.99,73.54) 243.99,73.32 243.8,73.13 243.8,72.84 243.93,72.71 U2.B10
