# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_PRX_C_GTX_N6: length 18.3
  TOP w0.104: v3(238.44,134.49) 238.33,134.38 238.18,134.38 237.82,134.75 229.87,134.75 227.5,137.12 224.18,137.12 223.93,137.37 223.28,137.37 223.06,137.6 222.6,137.6 222.5,137.7 222.5,137.93 222.57,138 C680.1
  BOTTOM w0.104: G2.BH32 238.69,134.74 v3(238.44,134.49)
PEG_PRX_C_GTX_N7: length 17.3
  TOP w0.104: v3(241.09,134.57) 240.98,134.68 240.98,134.96 240.69,135.25 236.5,135.25 236.29,135.45 230.41,135.45 227.46,138.4 226.35,138.4 C682.1
  BOTTOM w0.104: v3(241.09,134.57) G2.BE32
PEG_PRX_C_GTX_N8: length 19.3
  TOP w0.104: C868.1 222.75,140.34 223.03,140.34 223.13,140.23 223.13,139.89 223.23,139.78 223.72,139.78 223.98,139.53 227.58,139.53 230.97,136.13 236.45,136.13 236.84,135.74 238.42,135.74 238.79,136.11 238.98,136.11 239.09,136 v3(239.09,135.87)
  BOTTOM w0.104: G2.BG33 239.39,135.57 v3(239.09,135.87)
PEG_PRX_C_GTX_N9: length 15.4
  TOP w0.104: v3(238.44,136.42) 238.44,136.22 238.33,136.12 238.19,136.12 238.03,136.27 238.03,136.51 237.92,136.62 231.39,136.62 227.47,140.54 226.49,140.54 C870.1
  BOTTOM w0.104: G2.BH35 238.44,136.72 v3(238.44,136.42)
PEG_PRX_C_GTX_N10: length 21.5
  TOP w0.104: v3(241.09,136.67) 241.05,136.71 241.05,137.04 240.75,137.34 236.47,137.34 236.21,137.6 232.02,137.6 227.68,141.94 224.05,141.94 223.53,142.46 222.91,142.46 C875.1
  BOTTOM w0.104: v3(241.09,136.67) G2.BE35
PEG_PRX_C_GTX_N11: length 16.8
  TOP w0.104: C877.1 226.53,143 227.5,143 232.41,138.09 236.3,138.09 236.82,137.56 239.34,137.56 239.41,137.64 239.41,137.87 239.28,138 239.12,138 v3(239.09,137.97)
  BOTTOM w0.104: v3(239.09,137.97) 239.39,137.67 G2.BG36
PEG_PRX_C_GTX_N12: length 19.5
  TOP w0.104: v3(238.42,138.69) 238.33,138.6 238.19,138.6 237.79,138.99 236,138.99 235.87,139.12 235.59,139.12 235.46,138.99 235.17,138.99 235.04,139.12 234.75,139.12 234.62,138.99 234.34,138.99 234.21,139.12 233.92,139.12 233.79,138.99 233.14,138.99 227.78,144.35 224.25,144.35 223.99,144.61 223.22,144.61 223.12,144.71 223.12,144.98 223.02,145.09 222.83,145.09 C879.1
  BOTTOM w0.104: G2.BH38 238.44,138.82 238.44,138.7 v3(238.42,138.69)
PEG_PRX_C_GTX_N13: length 18.9
  TOP w0.076: 240.05,138.91 240.05,138.49 240.16,138.37 240.78,138.37 v3(241.13,138.72)
  TOP w0.104: C881.1 226.18,145.11 226.4,145.33 227.68,145.33 233.49,139.53 236.17,139.53 236.5,139.2 239.76,139.2 240.05,138.91
  BOTTOM w0.104: v3(241.13,138.72) G2.BE38
PEG_PRX_C_GTX_N14: length 20.9
  TOP w0.104: v3(239.09,140.07) 239.17,140.07 239.28,140.17 239.28,140.34 239.17,140.45 238.94,140.45 238.47,139.98 236.87,139.98 236.28,140.56 234.06,140.56 227.72,146.9 223.88,146.9 223.35,147.43 223.03,147.43 C884.1
  BOTTOM w0.117: G2.BG39 v3(239.09,140.07)
PEG_PRX_C_GTX_N15: length 16.8
  TOP w0.104: C885.1 226.22,147.53 226.43,147.74 227.77,147.74 234.45,141.05 237.6,141.05 238.26,140.39 238.58,140.39 239.06,140.87 v3(239.09,140.87)
  BOTTOM w0.117: v3(239.09,140.87) 239.09,140.94 239.31,141.17 G2.BG41
PEG_PRX_C_GTX_P0: length 18.3
  TOP w0.104: C650.1 222.83,129.87 223.03,130.08 223.29,130.08 223.94,129.42 229.92,129.42 230.5,130 232.96,130 233.31,129.65 236.09,129.65 236.7,130.25 237.67,130.25 238.12,129.8 238.66,129.8 239.09,130.22 v3(239.09,130.37)
  BOTTOM w0.104: v3(239.09,130.37) G2.BG26
PEG_PRX_C_GTX_P1: length 16.5
  TOP w0.104: v3(239.79,130.37) 239.94,130.37 240.23,130.66 240.23,130.88 240.12,130.98 239.84,130.98 239.61,130.76 236.17,130.76 235.71,130.31 233.71,130.31 233.28,130.73 230.1,130.73 229.67,130.31 227.04,130.31 226.48,130.87 226.34,130.87 226.23,130.76 226.23,130.64 C663.1
  BOTTOM w0.104: v3(239.79,130.37) G2.BF26
PEG_PRX_C_GTX_P2: length 18.8
  TOP w0.076: v3(239.79,131.67) 239.39,132.06 238.93,132.06 238.41,131.53 238.37,131.53
  TOP w0.104: 238.37,131.53 236.67,131.53 236.48,131.72 229.33,131.72 229.06,131.45 227.5,131.45 226.66,132.29 224.04,132.29 223.39,132.94 222.91,132.94 C653.1
  BOTTOM w0.104: v3(239.79,131.67) G2.BF27
PEG_PRX_C_GTX_P3: length 14.3
  TOP w0.104: C670.1 226.9,132.92 227.7,132.13 236.54,132.13 236.83,132.42 237.71,132.42 238.14,131.98 238.58,131.98 239.06,132.47 v3(239.09,132.47)
  BOTTOM w0.117: v3(239.09,132.47) 239.09,132.56 239.29,132.77 G2.BG29
PEG_PRX_C_GTX_P4: length 20.4
  TOP w0.104: C672.1 222.68,134.83 222.96,135.12 223.33,135.12 224,134.45 226.73,134.45 227.88,133.3 228.6,133.3 229,132.9 239.78,132.9 239.93,133.04 239.98,133.08 240.5,133.08 240.72,132.86 240.72,132.59 240.59,132.47 v3(240.39,132.47)
  BOTTOM w0.117: G2.BF29 v3(240.39,132.47)
PEG_PRX_C_GTX_P5: length 15.3
  TOP w0.104: v3(239.79,133.77) 239.4,133.38 236.29,133.38 235.94,133.73 229.28,133.73 227.39,135.61 226.38,135.61 C674.1
  BOTTOM w0.117: G2.BF30 v3(239.79,133.77)
PEG_PRX_C_GTX_P6: length 18.3
  TOP w0.104: C679.1 223.82,137.11 224.07,136.86 227.39,136.86 229.76,134.49 237.71,134.49 238.11,134.09 238.61,134.09 v3(239.09,134.57)
  BOTTOM w0.104: G2.BG32 239.32,134.87 239.09,134.63 v3(239.09,134.57)
PEG_PRX_C_GTX_P7: length 17.2
  TOP w0.104: v3(240.39,134.57) 240.43,134.52 240.58,134.52 240.71,134.65 240.71,134.86 240.58,134.99 236.39,134.99 236.19,135.2 230.3,135.2 227.36,138.14 226.39,138.14 226.11,137.86 C681.1
  BOTTOM w0.104: v3(240.39,134.57) G2.BF32
PEG_PRX_C_GTX_P8: length 19.4
  TOP w0.104: v3(239.79,135.87) 239.4,135.48 236.73,135.48 236.34,135.88 230.86,135.88 227.47,139.27 223.87,139.27 223.62,139.53 C869.1
  BOTTOM w0.104: G2.BF33 240.09,135.57 v3(239.79,135.87)
PEG_PRX_C_GTX_P9: length 15.4
  TOP w0.104: v3(238.98,136.51) 238.98,136.51 238.61,136.88 231.5,136.88 227.58,140.8 226.36,140.8 C874.1
  BOTTOM w0.104: G2.BG35 239.39,136.91 238.98,136.51 v3(238.98,136.51)
PEG_PRX_C_GTX_P10: length 21.5
  TOP w0.104: v3(240.39,136.67) 240.59,136.67 240.73,136.81 240.73,136.98 240.63,137.08 236.37,137.08 236.1,137.35 231.91,137.35 227.57,141.68 223.94,141.68 223.42,142.21 222.91,142.21 222.68,141.97 C876.1
  BOTTOM w0.104: v3(240.39,136.67) G2.BF35
PEG_PRX_C_GTX_P11: length 16.8
  TOP w0.104: C878.1 226.31,143.25 227.61,143.25 232.52,138.34 236.4,138.34 236.92,137.82 238.4,137.82 238.93,138.36 239.4,138.36 v3(239.79,137.97)
  BOTTOM w0.104: G2.BF36 240.09,137.67 v3(239.79,137.97)
PEG_PRX_C_GTX_P12: length 19.6
  TOP w0.104: C880.1 223.89,144.35 224.14,144.1 227.68,144.1 233.04,138.73 237.67,138.73 238.12,138.28 238.56,138.28 239.04,138.76 v3(239.07,138.76)
  BOTTOM w0.104: G2.BG38 239.29,139.07 239.07,138.85 v3(239.07,138.76)
PEG_PRX_C_GTX_P13: length 18.8
  TOP w0.104: v3(240.42,138.74) 240.68,139 240.76,139 240.9,139.15 240.9,139.29 240.73,139.46 236.6,139.46 236.28,139.78 233.6,139.78 227.79,145.59 226.52,145.59 C882.1
  BOTTOM w0.104: v3(240.42,138.74) 240.09,139.07 G2.BF38
PEG_PRX_C_GTX_P14: length 20.9
  TOP w0.104: C883.1 222.96,147.17 223.24,147.17 223.77,146.64 227.62,146.64 233.95,140.31 236.18,140.31 236.76,139.72 238.89,139.72 238.95,139.66 239.38,139.66 v3(239.79,140.07)
  BOTTOM w0.117: G2.BF39 v3(239.79,140.07)
PEG_PRX_C_GTX_P15: length 16.8
  TOP w0.104: v3(238.44,140.79) 238.52,140.79 238.71,140.98 238.71,141.17 238.58,141.31 234.56,141.31 227.87,148 226.26,148 226.11,148.15 C886.1
  BOTTOM w0.117: G2.BH41 238.44,140.92 v3(238.44,140.79)
PEG_PRX_GTX_N0: length 38.1
  TOP w0.104: C662.2 221.45,130.45 212.76,130.45 207.93,135.27 v1(201.39,135.27) 190.18,135.27 189.09,136.35 188.23,136.35 187.88,136.71 187.55,136.71 187.45,136.6 187.45,136.42 187.55,136.32 v3(187.67,136.32)
  BOTTOM w0.104: v3(187.67,136.32) 187.35,136.64 U1.E10
PEG_PRX_GTX_N1: length 41.6
  TOP w0.076: 190.09,136.6 190.09,136.62 190.04,136.68 190.04,136.85 189.23,137.66 188.14,137.66 187.92,137.43 187.92,137.35 v3(187.67,137.1)
  TOP w0.104: 190.09,136.6 190.09,136.25 190.19,136.15 v1(207.87,136.15) 208.43,136.15 213.05,131.53 v1(217.65,131.53) 220.99,131.53 221.12,131.65 223.41,131.65 223.98,131.08 224.87,131.08 C664.2
  BOTTOM w0.104: U1.E11 187.35,137.43 v3(187.67,137.1)
PEG_PRX_GTX_N2: length 37.5
  TOP w0.076: 190.74,137.42 190.72,137.42 190.67,137.47 190.43,137.47 189.77,138.13 187.72,138.13 187.64,138.05 187.64,137.92 v3(187.67,137.89)
  TOP w0.104: 190.74,137.42 190.87,137.42 191.51,136.78 v1(198.85,136.78) 209.08,136.78 212.69,133.18 220.46,133.18 220.72,132.92 221.14,132.92 221.24,132.82 221.24,132.39 221.35,132.29 C654.2
  BOTTOM w0.104: v3(187.67,137.89) 187.35,138.22 U1.E12
PEG_PRX_GTX_N3: length 40.8
  TOP w0.076: 191.19,138.59 191.17,138.6 191.1,138.6 191.03,138.68 190.81,138.89 189.62,138.89 189.29,139.22 188.2,139.22 187.92,138.95 187.92,138.93 v3(187.67,138.68)
  TOP w0.104: 191.19,138.59 191.26,138.52 191.84,137.94 v1(203.93,137.94) 209.94,137.94 213.55,134.32 221.08,134.32 221.33,134.07 223.49,134.07 224.07,133.49 224.87,133.49 C671.2
  BOTTOM w0.104: U1.E13 187.35,139 v3(187.67,138.68)
PEG_PRX_GTX_N4: length 37.5
  TOP w0.076: v3(187.67,139.46) 187.48,139.46 187.39,139.56 187.39,139.81 187.46,139.88 187.93,139.88 188.09,139.72 190.08,139.72 190.41,139.4 190.98,139.4 191.3,139.08 191.53,139.08
  TOP w0.104: 191.53,139.08 v1(205.96,139.08) 210.33,139.08 214.14,135.27 221.45,135.27 C673.2
  BOTTOM w0.104: U1.E14 187.35,139.79 v3(187.67,139.46)
PEG_PRX_GTX_N5: length 40.3
  TOP w0.076: v3(187.67,140.25) 188.04,140.62 188.88,140.62 188.96,140.54 190.68,140.54 191.24,139.98 191.55,139.98 191.6,140.04 191.61,140.04
  TOP w0.104: 191.61,140.04 v1(200.88,140.04) 210.98,140.04 214.54,136.48 223.57,136.48 224.14,135.91 224.87,135.91 C675.2
  BOTTOM w0.104: v3(187.67,140.25) 187.35,140.58 U1.E15
PEG_PRX_GTX_N6: length 37.1
  TOP w0.076: 192.07,140.93 192.05,140.93 192,140.87 191.05,140.87 190.9,141.02 188.23,141.02 187.83,141.43 187.55,141.43 187.45,141.33 187.45,141.12 187.52,141.04 v3(187.67,141.04)
  TOP w0.104: C680.2 221.45,137.69 214.96,137.69 211.72,140.93 v1(206.73,140.93) 192.07,140.93
  BOTTOM w0.104: U1.E16 187.35,141.37 v3(187.67,141.04)
PEG_PRX_GTX_N7: length 40.8
  TOP w0.076: 191.37,141.58 191.36,141.59 191.29,141.59 190.91,141.96 189.01,141.96 188.6,142.37 187.95,142.37 187.83,142.24 187.44,142.24 v3(187.02,141.83)
  TOP w0.104: C682.2 225.12,138.56 223.65,138.56 223.32,138.89 215.55,138.89 212.63,141.81 209.37,141.81 209.37,141.81 v1(208.93,141.81) 192.14,141.81 191.83,141.51 191.44,141.51 191.37,141.58
  BOTTOM w0.104: U1.E17 187.35,142.15 v3(187.02,141.83)
PEG_PRX_GTX_N8: length 36.8
  TOP w0.076: 190.51,142.52 190.5,142.52 190.45,142.47 189.49,142.47 188.98,142.98 187.39,142.98 v3(187.02,142.62)
  TOP w0.104: 190.51,142.52 191.2,142.52 191.38,142.7 v1(206.47,142.7) 213.23,142.7 215.62,140.31 221.66,140.31 C868.2
  BOTTOM w0.104: v3(187.02,142.62) 186.7,142.94 U1.F18
PEG_PRX_GTX_N9: length 40.2
  TOP w0.076: 192.26,143.29 192.25,143.29 192.2,143.35 190.28,143.35 190.19,143.26 189.72,143.26 189.63,143.35 189.06,143.35 188.63,143.78 187.97,143.78 187.67,143.48 v3(187.67,143.4)
  TOP w0.104: C870.2 224.85,140.16 224.75,140.26 224.75,140.69 224.64,140.79 223.59,140.79 223.41,140.97 216.2,140.97 213.76,143.42 v1(201.77,143.42) 193.6,143.42 193.48,143.29 192.26,143.29
  BOTTOM w0.104: v3(187.67,143.4) 188,143.73 U1.D19
PEG_PRX_GTX_N10: length 36.6
  TOP w0.076: 192.42,144.56 192.4,144.56 192.35,144.5 192.13,144.5 191.75,144.12 189.82,144.12 189.33,144.61 187.42,144.61 187.02,144.21 v3(187.02,144.19)
  TOP w0.104: C875.2 216.36,142.7 214.5,144.56 v1(204.82,144.56) 192.42,144.56
  BOTTOM w0.104: U1.F20 186.7,144.52 v3(187.02,144.19)
PEG_PRX_GTX_N11: length 40
  TOP w0.076: v3(187.67,144.98) 187.6,145.05 187.6,145.19 187.67,145.27 188.03,145.27 188.13,145.37 188.49,145.37 188.88,144.98 192.18,144.98 192.45,145.25 192.52,145.25 192.53,145.26
  TOP w0.104: C877.2 225.19,142.89 225.09,142.99 224.85,142.99 224.63,143.21 223.76,143.21 223.63,143.34 216.65,143.34 214.72,145.26 v1(198.6,145.26) 192.53,145.26
  BOTTOM w0.104: U1.D21 188,145.3 v3(187.67,144.98)
PEG_PRX_GTX_N12: length 36.7
  TOP w0.076: 191.91,145.82 191.9,145.8 191.9,145.73 191.82,145.65 190.46,145.65 189.93,146.18 187.44,146.18 187.28,146.01 187.27,146.01 v3(187.02,145.76)
  TOP w0.104: C879.2 221.64,145.12 216.8,145.12 215.35,146.57 v1(205.78,146.57) 192.67,146.57 192.54,146.44 191.91,145.82
  BOTTOM w0.104: U1.F22 186.7,146.09 v3(187.02,145.76)
PEG_PRX_GTX_N13: length 39.9
  TOP w0.076: v3(187.67,146.55) 187.67,146.7 187.77,146.8 187.97,146.8 188.13,146.97 188.77,146.97 188.92,147.12 188.99,147.12 189,147.13
  TOP w0.104: 189,147.13 189.15,147.27 190.09,147.27 190.34,147.02 190.55,147.02 190.65,146.92 191.12,146.92 191.22,147.02 191.79,147.02 192.13,147.35 v1(201.9,147.35) 215.63,147.35 217.24,145.74 224.65,145.74 224.76,145.64 224.76,145.23 224.87,145.11 C881.2
  BOTTOM w0.104: U1.D23 188,146.88 v3(187.67,146.55)
PEG_PRX_GTX_N14: length 36.4
  TOP w0.076: v3(187.02,147.34) 187.12,147.34 187.46,147.68 187.61,147.68 187.69,147.76 188.59,147.76 189.04,148.2 189.03,148.27 189.05,148.29
  TOP w0.104: C884.2 221.56,147.58 217.28,147.58 216.24,148.62 v1(199.49,148.62) 189.38,148.62 189.05,148.29
  BOTTOM w0.104: v3(187.02,147.34) 186.7,147.66 U1.F24
PEG_PRX_GTX_N15: length 39.6
  TOP w0.076: v3(187.67,148.13) 187.67,148.31 187.75,148.39 188.01,148.39 188.3,148.68 188.31,148.69 188.72,149.1 189.3,149.1 189.35,149.05 189.37,149.05
  TOP w0.104: 189.37,149.05 191.34,149.05 191.54,149.25 v1(207.49,149.25) 217.07,149.25 217.65,148.67 223.1,148.67 223.61,148.16 224.55,148.16 224.66,148.06 224.66,147.63 224.76,147.53 C885.2
  BOTTOM w0.104: v3(187.67,148.13) 188,148.45 U1.D25
PEG_PRX_GTX_P0: length 38.1
  TOP w0.104: C650.2 221.45,130.19 212.65,130.19 207.83,135.01 v1(198.6,135.01) 190.07,135.01 188.99,136.1 188.11,136.1 187.96,135.95 187.39,135.95 v3(187.02,136.32)
  BOTTOM w0.104: v3(187.02,136.32) 186.7,136.64 U1.F10
PEG_PRX_GTX_P1: length 41.6
  TOP w0.076: v3(188.32,137.1) 188.17,137.1 188.07,137.2 188.07,137.37 188.21,137.51 189.17,137.51 189.88,136.79 189.88,136.68 189.83,136.62 189.83,136.6
  TOP w0.104: 189.83,136.6 189.83,136.15 190.09,135.89 v1(203.68,135.89) 208.33,135.89 212.95,131.27 221.1,131.27 221.22,131.4 223.3,131.4 223.88,130.82 224.87,130.82 C663.2
  BOTTOM w0.104: v3(188.32,137.1) 188,137.43 U1.D11
PEG_PRX_GTX_P2: length 37.6
  TOP w0.076: 190.74,137.68 190.72,137.68 190.67,137.63 190.49,137.63 189.84,138.28 187.52,138.28 187.13,137.89 v3(187.02,137.89)
  TOP w0.104: 190.74,137.68 190.97,137.68 191.61,137.04 v1(201.65,137.04) 209.19,137.04 212.79,133.43 220.57,133.43 220.82,133.18 221.24,133.18 221.24,133.18 C653.2
  BOTTOM w0.104: U1.F12 186.7,138.22 v3(187.02,137.89)
PEG_PRX_GTX_P3: length 40.7
  TOP w0.076: v3(188.32,138.68) 188.15,138.68 188.11,138.72 188.11,138.92 188.26,139.07 189.22,139.07 189.55,138.74 190.75,138.74 190.92,138.57 190.99,138.5 190.99,138.42 191,138.41
  TOP w0.104: 191,138.41 191.08,138.34 191.73,137.68 v1(208.12,137.68) 209.83,137.68 213.45,134.06 220.97,134.06 221.22,133.81 223.39,133.81 223.96,133.24 224.87,133.24 C670.2
  BOTTOM w0.104: v3(188.32,138.68) 188,139 U1.D13
PEG_PRX_GTX_P4: length 37.6
  TOP w0.076: v3(187.02,139.46) 187.37,139.12 187.85,139.12 188.3,139.57 190.02,139.57 190.34,139.25 190.91,139.25 191.29,138.87 191.46,138.87 191.51,138.82 191.53,138.82
  TOP w0.104: 191.53,138.82 v1(198.72,138.82) 210.23,138.82 214.03,135.02 221.45,135.02 C672.2
  BOTTOM w0.104: U1.F14 186.7,139.79 v3(187.02,139.46)
PEG_PRX_GTX_P5: length 40.3
  TOP w0.076: 191.61,139.78 191.59,139.78 191.54,139.83 191.18,139.83 190.62,140.39 188.77,140.39 188.69,140.31 188.69,139.98 188.61,139.91 188.34,139.91 188.24,140 188.24,140.17 v3(188.32,140.25)
  TOP w0.104: C674.2 224.87,135.65 224.04,135.65 223.46,136.22 214.43,136.22 210.88,139.78 v1(209.9,139.78) 191.61,139.78
  BOTTOM w0.104: U1.D15 188,140.58 v3(188.32,140.25)
PEG_PRX_GTX_P6: length 37
  TOP w0.076: 192.3,140.67 192.3,140.67 ; v3(187.02,141.04) 187.37,140.69 187.85,140.69 188.03,140.87 190.84,140.87 190.99,140.72 192,140.72 192.05,140.67 192.07,140.67
  TOP w0.104: 192.3,140.67 v1(198.6,140.67) 211.61,140.67 214.85,137.43 221.45,137.43 C679.2 ; 192.07,140.67 192.3,140.67
  BOTTOM w0.104: v3(187.02,141.04) 186.7,141.37 U1.F16
PEG_PRX_GTX_P7: length 40.7
  TOP w0.076: 191.19,141.4 191.18,141.41 191.18,141.48 190.85,141.81 188.95,141.81 188.54,142.22 188.03,142.22 187.9,142.09 187.71,142.09 187.63,142.01 187.63,141.87 v3(187.67,141.83)
  TOP w0.104: 191.19,141.4 191.34,141.25 191.94,141.25 192.24,141.56 v1(200.93,141.56) 209.14,141.56 209.14,141.56 212.52,141.56 215.45,138.64 223.21,138.64 223.54,138.31 224.6,138.31 224.71,138.2 224.71,137.85 224.81,137.75 C681.2
  BOTTOM w0.104: U1.D17 188,142.15 v3(187.67,141.83)
PEG_PRX_GTX_P8: length 36.7
  TOP w0.076: 190.51,142.27 190.5,142.27 190.45,142.32 189.43,142.32 188.92,142.83 188.74,142.83 188.67,142.75 188.23,142.75 188.16,142.83 187.77,142.83 187.67,142.73 v3(187.67,142.62)
  TOP w0.104: 190.51,142.27 191.31,142.27 191.49,142.45 191.69,142.45 191.82,142.32 192.11,142.32 192.23,142.45 192.52,142.45 192.65,142.32 192.94,142.32 193.07,142.45 v1(203.55,142.45) 213.12,142.45 215.51,140.06 221.08,140.06 221.2,139.93 221.2,139.63 221.3,139.53 C869.2
  BOTTOM w0.104: U1.E18 187.35,142.94 v3(187.67,142.62)
PEG_PRX_GTX_P9: length 40.3
  TOP w0.076: 192.26,143.55 192.24,143.55 192.19,143.5 189.12,143.5 188.69,143.93 187.9,143.93 187.79,143.82 187.44,143.82 v3(187.02,143.4)
  TOP w0.104: 192.26,143.55 193.37,143.55 193.49,143.67 v1(209.77,143.67) 213.86,143.67 216.31,141.23 223.52,141.23 223.7,141.05 224.8,141.05 C874.2
  BOTTOM w0.104: U1.E19 187.35,143.73 v3(187.02,143.4)
PEG_PRX_GTX_P10: length 36.5
  TOP w0.076: 192.42,144.3 192.4,144.3 192.35,144.35 192.19,144.35 191.81,143.97 189.75,143.97 189.28,144.44 188.76,144.44 188.69,144.38 188.17,144.38 188.11,144.44 187.75,144.44 187.64,144.33 187.64,144.22 v3(187.67,144.19)
  TOP w0.104: C876.2 221.71,141.86 221.43,141.86 221.33,141.97 221.33,142.34 221.23,142.44 216.25,142.44 214.4,144.3 v1(212.82,144.3) 192.42,144.3
  BOTTOM w0.104: U1.E20 187.35,144.52 v3(187.67,144.19)
PEG_PRX_GTX_P11: length 40.1
  TOP w0.076: v3(187.02,144.98) 187.46,145.42 187.97,145.42 188.07,145.52 188.55,145.52 188.94,145.13 192.11,145.13 192.5,145.52 192.53,145.52
  TOP w0.104: 192.53,145.52 v1(209.27,145.52) 214.83,145.52 216.76,143.59 223.74,143.59 223.87,143.46 C878.2
  BOTTOM w0.104: v3(187.02,144.98) 187.35,145.3 U1.E21
PEG_PRX_GTX_P12: length 36.7
  TOP w0.076: v3(187.67,145.76) 187.67,145.94 187.75,146.01 188.27,146.01 188.36,145.93 188.72,145.93 188.8,146.01 189.15,146.01 189.24,145.93 189.63,145.93 189.72,146.01 189.88,146.01 190.39,145.5 191.89,145.5 192.01,145.62 192.08,145.62 192.09,145.63
  TOP w0.104: 192.09,145.63 192.77,146.31 v1(214.03,146.31) 215.25,146.31 216.7,144.86 221.12,144.86 221.23,144.76 221.23,144.34 221.34,144.22 221.63,144.22 C880.2
  BOTTOM w0.104: U1.E22 187.35,146.09 v3(187.67,145.76)
PEG_PRX_GTX_P13: length 40.1
  TOP w0.076: 188.82,147.31 188.81,147.3 188.81,147.22 188.7,147.12 188.03,147.12 187.87,146.96 187.49,146.96 187.08,146.55 v3(187.02,146.55)
  TOP w0.104: 188.82,147.31 189.04,147.53 190.19,147.53 190.45,147.28 191.68,147.28 192.02,147.61 v1(210.41,147.61) 215.74,147.61 217.35,146 224.74,146 224.74,146 C882.2
  BOTTOM w0.104: v3(187.02,146.55) 187.35,146.88 U1.E23
PEG_PRX_GTX_P14: length 36.3
  TOP w0.076: v3(187.67,147.34) 187.67,147.44 187.75,147.52 187.89,147.52 188.11,147.3 188.23,147.3 188.31,147.37 188.31,147.53 188.39,147.6 188.65,147.6 189.14,148.09 189.22,148.09 189.23,148.11
  TOP w0.104: 189.23,148.11 189.48,148.36 v1(205.07,148.36) 216.14,148.36 217.17,147.32 221.76,147.32 221.86,147.22 221.86,146.99 C883.2
  BOTTOM w0.104: U1.E24 187.35,147.66 v3(187.67,147.34)
PEG_PRX_GTX_P15: length 39.7
  TOP w0.076: v3(187.02,148.13) 187.44,148.54 187.95,148.54 188.19,148.78 188.19,148.79 188.66,149.25 189.3,149.25 189.35,149.31 189.37,149.31
  TOP w0.104: 189.37,149.31 191.23,149.31 191.43,149.5 v1(201.9,149.5) 217.18,149.5 217.75,148.93 223.2,148.93 223.71,148.42 C886.2
  BOTTOM w0.104: v3(187.02,148.13) 187.35,148.45 U1.E25
PEG_PTX_C_GRX_N0: length 37.1
  BOTTOM w0.104: G2.BK27 237.13,131.37 236.79,131.7 236.37,131.7 236.12,131.95 234.09,131.95 233.29,131.15 224.59,131.15 220.93,134.81 220.54,134.81 v1(210.61,134.81) 209.47,134.81 209.47,134.81 208.33,134.81 205.94,134.81 204.31,133.18 C32.1
PEG_PTX_C_GRX_N1: length 40.6
  BOTTOM w0.104: C30.1 199.59,134.93 199.92,134.93 200.04,134.8 200.04,134.47 200.2,134.32 204.19,134.32 205.56,135.69 v1(208.17,135.69) 210.71,135.69 219.13,135.69 221.36,135.69 224.99,132.06 228.97,132.06 229.12,131.91 233.16,131.91 233.87,132.62 234.94,132.62 235.12,132.45 236.04,132.45 236.19,132.59 236.19,132.87 236.26,132.95 236.4,132.95 G2.BL29
PEG_PTX_C_GRX_N2: length 35.4
  BOTTOM w0.104: C28.1 203.3,135.53 204.02,135.53 205.11,136.63 207.69,136.63 v1(210.67,136.63) 219.08,136.63 219.08,136.63 221.8,136.63 225.48,132.95 229.02,132.95 229.3,132.67 233.03,132.67 233.63,133.26 235.68,133.26 G2.BM30
PEG_PTX_C_GRX_N3: length 40.7
  BOTTOM w0.104: G2.BK30 237.1,133.47 236.79,133.15 236.44,133.15 236.27,133.33 236.27,133.59 236.06,133.79 235.65,133.79 235.57,133.71 233.55,133.71 233.01,133.17 229.47,133.17 229.12,133.53 225.93,133.53 222.2,137.26 v1(215.11,137.26) 204.56,137.26 204.04,136.73 200.9,136.73 200.71,136.92 199.63,136.92 C26.1
PEG_PTX_C_GRX_N4: length 36.6
  BOTTOM w0.104: C24.1 203.07,138.59 203.4,138.59 203.47,138.51 203.47,137.98 203.58,137.88 203.73,137.88 204.13,138.28 207.96,138.28 v1(211.68,138.28) 219.07,138.28 219.08,138.28 223.1,138.28 226.62,134.75 229.2,134.75 229.77,134.19 232.78,134.19 233.24,134.66 235.21,134.66 235.34,134.53 236.04,134.53 236.21,134.7 236.21,134.84 236.31,134.94 236.51,134.94 G2.BL32
PEG_PTX_C_GRX_N5: length 38.9
  BOTTOM w0.104: C22.1 199.77,139.82 201.33,139.82 201.62,139.53 203.91,139.53 204.22,139.22 204.27,139.17 v1(215.21,139.17) 218.26,139.17 218.26,139.17 219.05,139.17 223.72,139.17 227.18,135.72 229.13,135.72 229.89,134.96 232.65,134.96 233.03,135.33 235.65,135.33 G2.BM33
PEG_PTX_C_GRX_N6: length 37
  BOTTOM w0.104: C20.1 203.33,140.84 204,140.84 204.75,140.08 v1(210.1,140.08) 212.42,140.08 212.42,140.08 224.31,140.08 227.7,136.68 229.21,136.68 230.18,135.72 232.53,135.72 232.78,135.97 235.42,135.97 235.6,136.15 236.15,136.15 236.37,135.93 236.74,135.93 237.1,135.57 G2.BK33
PEG_PTX_C_GRX_N7: length 40.4
  BOTTOM w0.104: G2.BL35 236.59,137.02 236.48,137.13 236.28,137.13 236.2,137.05 236.2,136.72 236.12,136.64 232.44,136.64 232.27,136.48 230.36,136.48 229.24,137.6 228.15,137.6 224.66,141.08 214.94,141.08 213.01,141.09 212.91,141.09 v1(207.62,141.09) 207.62,141.09 205.02,141.09 204.04,142.07 200.1,142.07 199.99,142.17 199.99,142.5 199.92,142.57 C18.1
PEG_PTX_C_GRX_N8: length 35.8
  BOTTOM w0.104: G2.BM36 235.67,137.45 235.4,137.45 235.19,137.24 230.47,137.24 229.2,138.51 228.61,138.51 224.99,142.14 216.12,142.14 v1(214.82,142.14) 211.01,142.14 205.24,142.14 203.88,143.5 203.26,143.5 C16.1
PEG_PTX_C_GRX_N9: length 41.5
  BOTTOM w0.104: C14.1 199.69,144.94 203.42,144.94 205.43,142.93 210.88,142.93 v1(210.88,142.93) 210.88,142.93 225.35,142.93 230.53,137.75 235.17,137.75 235.41,137.98 236.05,137.98 236.21,137.81 236.21,137.61 236.47,137.35 236.97,137.35 G2.BK36
PEG_PTX_C_GRX_N10: length 38.3
  BOTTOM w0.104: G2.BL38 236.63,139.11 236.84,139.11 236.95,139.01 236.95,138.79 236.86,138.7 236.4,138.7 236.18,138.48 231.03,138.48 225.62,143.89 v1(216.63,143.89) 206.29,143.89 203.59,146.59 203.17,146.59 202.92,146.34 C12.1
PEG_PTX_C_GRX_N11: length 40.4
  BOTTOM w0.104: C10.1 199.49,148.92 199.81,148.6 200.8,148.6 201.24,148.16 203.67,148.16 206.78,145.06 208.82,145.06 208.82,145.06 v1(210.85,145.06) 210.85,145.06 226.06,145.06 231.6,139.52 235.64,139.52 G2.BM39
PEG_PTX_C_GRX_N12: length 38.7
  BOTTOM w0.104: G2.BK39 237.07,139.77 236.74,140.09 236.44,140.09 236.37,140.16 236.18,140.35 234.62,140.35 234.56,140.29 232.1,140.29 226.42,145.97 v1(208.47,145.97) 207.26,145.97 204.19,149.05 204.19,149.33 203.58,149.94 C8.1
PEG_PTX_C_GRX_N13: length 44.5
  BOTTOM w0.104: G2.BL41 236.59,141.19 236.44,141.33 236.29,141.33 236.19,141.23 236.19,141.01 236.03,140.85 235.34,140.85 235.14,141.05 232.6,141.05 226.69,146.96 220,146.96 v1(220,146.96) 220,146.96 207.81,146.96 204.54,150.22 204.54,150.71 202.42,152.83 201.64,152.83 200.88,152.08 200.88,151.44 200.14,150.7 199.99,150.7 199.75,150.94 199.51,150.94 199.44,151.02 C6.1
PEG_PTX_C_GRX_N14: length 44.7
  BOTTOM w0.104: G2.BM42 235.67,141.65 235.31,141.65 235.17,141.79 233.11,141.79 226.91,147.99 v1(224.04,147.99) 209.16,147.99 205.33,151.82 205.33,152.29 203.4,154.22 201.76,154.22 200.39,152.86 198.85,152.86 198.52,152.53 197.91,152.53 C4.1
PEG_PTX_C_GRX_N15: length 45.8
  BOTTOM w0.104: G2.BK42 236.98,141.56 236.44,141.56 236.23,141.76 236.23,141.99 235.96,142.27 233.56,142.27 227.19,148.63 v1(212,148.63) 209.48,148.63 206.22,151.89 206.22,152.96 204.93,154.25 204.93,154.98 204.11,155.8 202.3,155.8 200.34,153.83 199.88,153.83 199.81,153.83 199.77,153.83 C2.1
PEG_PTX_C_GRX_P0: length 37
  BOTTOM w0.104: C31.1 203.04,132.24 203.4,132.24 203.55,132.39 203.55,132.82 203.65,132.92 204.42,132.92 206.05,134.55 208.33,134.55 209.47,134.55 v1(218,134.55) 220.83,134.55 224.49,130.89 231.56,130.89 231.69,130.76 232.1,130.76 232.23,130.89 233.4,130.89 234.2,131.69 234.46,131.69 234.58,131.58 235,131.58 235.11,131.69 236.02,131.69 236.34,131.37 G2.BL27
PEG_PTX_C_GRX_P1: length 40.6
  BOTTOM w0.104: G2.BK29 236.95,132.43 236.4,132.43 236.15,132.19 235.01,132.19 234.84,132.36 233.98,132.36 233.27,131.65 229.02,131.65 228.86,131.8 224.88,131.8 221.25,135.43 v1(215.57,135.43) 210.71,135.43 205.66,135.44 204.29,134.06 200.09,134.06 199.96,134.19 C29.1
PEG_PTX_C_GRX_P2: length 35.5
  BOTTOM w0.104: C27.1 203.31,135.27 204.12,135.27 205.22,136.37 218.29,136.37 v1(220.61,136.37) 221.69,136.37 225.37,132.69 228.91,132.69 229.19,132.41 233.14,132.41 233.73,133.01 235.65,133.01 G2.BM29
PEG_PTX_C_GRX_P3: length 40.7
  BOTTOM w0.104: C25.1 199.44,137.28 199.54,137.18 200.82,137.18 201.01,136.99 203.93,136.99 204.46,137.51 v1(208.98,137.51) 222.31,137.51 226.04,133.79 229.22,133.79 229.58,133.43 232.91,133.43 233.44,133.97 235.46,133.97 235.54,134.05 236.18,134.05 236.42,133.81 236.74,133.81 236.87,133.68 236.87,133.56 236.75,133.45 236.61,133.45 G2.BL30
PEG_PTX_C_GRX_P4: length 36.6
  BOTTOM w0.104: G2.BK32 237.07,134.87 236.71,134.5 236.38,134.5 236.15,134.28 235.23,134.28 235.11,134.4 233.35,134.4 232.88,133.94 229.66,133.94 229.1,134.5 226.52,134.5 222.99,138.02 219.08,138.02 v1(219.07,138.02) 219.07,138.02 218.97,138.02 218.97,138.02 211.68,138.02 204.24,138.02 203.84,137.62 C23.1
PEG_PTX_C_GRX_P5: length 38.8
  BOTTOM w0.104: C21.1 199.73,139.57 201.22,139.57 201.52,139.27 203.8,139.27 204.16,138.91 219.05,138.91 219.05,138.92 v1(222.86,138.92) 223.61,138.92 227.07,135.46 229.02,135.46 229.79,134.7 232.76,134.7 233.14,135.08 235.67,135.08 G2.BM32
PEG_PTX_C_GRX_P6: length 37
  BOTTOM w0.104: G2.BL33 236.67,135.49 236.67,135.3 236.56,135.2 236.32,135.2 236.21,135.3 236.21,135.73 236.04,135.89 235.71,135.89 235.53,135.71 232.88,135.71 232.63,135.46 230.07,135.46 229.1,136.43 227.6,136.43 224.2,139.83 217.93,139.83 v1(217.5,139.83) 212.42,139.83 204.65,139.83 203.89,140.58 203.29,140.58 C19.1
PEG_PTX_C_GRX_P7: length 40.5
  BOTTOM w0.104: C17.1 199.56,141.81 203.93,141.81 204.91,140.83 207.19,140.83 212.91,140.83 v1(212.91,140.83) 212.91,140.83 213.01,140.83 214.94,140.83 224.55,140.83 228.04,137.34 229.14,137.34 230.25,136.22 232.38,136.22 232.54,136.39 236.23,136.39 236.49,136.64 236.8,136.64 237.12,136.97 G2.BK35
PEG_PTX_C_GRX_P8: length 35.9
  BOTTOM w0.104: G2.BM35 235.89,136.97 235.66,137.2 235.51,137.2 235.3,136.99 230.36,136.99 229.09,138.26 228.51,138.26 224.88,141.88 220.37,141.88 220.37,141.88 v1(219.93,141.88) 205.13,141.88 203.77,143.24 203.2,143.24 C15.1
PEG_PTX_C_GRX_P9: length 41.5
  BOTTOM w0.104: C13.1 199.49,145.51 199.8,145.2 203.52,145.2 205.53,143.19 v1(208.47,143.19) 225.46,143.19 230.64,138 235.07,138 235.3,138.24 236.15,138.24 236.36,138.03 236.78,138.03 236.94,137.87 236.94,137.71 236.84,137.61 236.65,137.61 G2.BL36
PEG_PTX_C_GRX_P10: length 38.4
  BOTTOM w0.104: C11.1 203.18,146.85 203.7,146.85 206.4,144.15 213.26,144.15 v1(213.26,144.15) 213.27,144.15 225.73,144.15 231.13,138.74 236.08,138.74 236.24,138.91 236.24,139.17 236.45,139.38 236.98,139.38 G2.BK38
PEG_PTX_C_GRX_P11: length 40.4
  BOTTOM w0.104: C9.1 199.49,148.04 199.79,148.35 200.7,148.35 201.14,147.91 203.57,147.91 206.67,144.8 v1(219.05,144.8) 225.95,144.8 231.49,139.26 235.69,139.26 G2.BM38
PEG_PTX_C_GRX_P12: length 38.6
  BOTTOM w0.104: G2.BL39 236.41,139.59 236.28,139.59 236.2,139.67 236.2,139.97 236.07,140.09 234.72,140.09 234.67,140.03 234.07,140.03 233.94,139.91 233.53,139.91 233.4,140.03 232.98,140.03 232.86,139.91 232.44,139.91 232.31,140.03 231.99,140.03 226.31,145.72 213.62,145.72 v1(213.62,145.72) 213.61,145.72 207.16,145.72 203.93,148.94 203.93,149.22 203.62,149.53 203.4,149.53 202.99,149.13 C7.1
PEG_PTX_C_GRX_P13: length 44.6
  BOTTOM w0.104: C5.1 200.25,150.45 201.14,151.34 201.14,151.97 201.74,152.58 202.31,152.58 204.29,150.6 204.29,150.12 207.7,146.7 v1(217.47,146.7) 226.59,146.7 232.49,140.79 235.03,140.79 235.23,140.6 236.14,140.6 236.38,140.83 236.72,140.83 236.74,140.85 236.75,140.85 237.07,141.17 G2.BK41
PEG_PTX_C_GRX_P14: length 44.7
  BOTTOM w0.104: C3.1 197.89,152.28 198.63,152.28 198.96,152.6 200.5,152.6 201.86,153.97 203.29,153.97 205.07,152.18 205.07,151.71 209.05,147.73 v1(225.87,147.73) 226.8,147.73 233,141.53 235.07,141.53 235.2,141.4 235.65,141.4 G2.BM41
PEG_PTX_C_GRX_P15: length 45.9
  BOTTOM w0.104: G2.BL42 236.81,141.87 236.91,141.97 236.91,142.12 236.77,142.26 236.45,142.26 236.18,142.52 233.66,142.52 227.3,148.89 209.98,148.89 v1(209.98,148.89) 209.97,148.89 209.58,148.89 206.47,151.99 206.47,153.07 205.19,154.35 205.19,155.08 204.21,156.06 202.2,156.06 200.23,154.09 199.88,154.09 199.82,154.09 199.77,154.09 199.69,154.09 199.56,154.22 C1.1
PEG_PTX_GRX_N0: length 16.4
  BOTTOM w0.076: U1.B10 189.03,136.71 188.92,136.6 188.92,136.49 189.03,136.38 190.32,136.38 190.42,136.27 191.03,136.27 191.08,136.32 191.1,136.32
  BOTTOM w0.104: 191.1,136.32 192.13,136.32 192.4,136.05 194.18,136.05 195.55,134.68 195.55,133.43 196.49,132.49 v1(197.84,132.49) 199.2,132.49 199.63,132.92 201.82,132.92 C32.2
PEG_PTX_GRX_N1: length 10.6
  BOTTOM w0.089: 192.76,137.01 192.74,137.01 192.7,136.96 191.63,136.96 191.06,137.53 190.3,137.53 190.06,137.77 189.57,137.77 U1.B11
  BOTTOM w0.104: C30.2 198.37,134.93 196.72,134.93 194.64,137.01 192.76,137.01
PEG_PTX_GRX_N2: length 15
  BOTTOM w0.076: U1.B12 189.3,138.43 189.43,138.56 190.27,138.56 190.37,138.66 190.82,138.66 191.1,138.39 191.1,138.39
  BOTTOM w0.104: C28.2 202.16,135.84 202.28,135.73 202.28,135.56 202.16,135.44 201.26,135.44 v1(201.06,135.64) 200.86,135.84 196.95,135.84 194.89,137.9 191.83,137.9 191.34,138.39 191.1,138.39
PEG_PTX_GRX_N3: length 10.3
  BOTTOM w0.076: U1.B13 189.6,138.76 190.09,138.76 190.22,138.89 190.85,138.89 190.92,138.82 191.16,138.82 191.21,138.76 191.23,138.76
  BOTTOM w0.104: C26.2 198.52,136.73 v1(197.47,136.73) 197.22,136.73 195.43,138.52 191.85,138.52 191.61,138.76 191.23,138.76
PEG_PTX_GRX_N4: length 14.5
  BOTTOM w0.076: 191.99,139.65 191.97,139.65 191.93,139.6 191.63,139.6 191.45,139.42 190.3,139.42 190.18,139.54 189.08,139.54 188.97,139.65 188.97,139.78 189.04,139.86 U1.B14
  BOTTOM w0.104: C24.2 202.08,138.47 201.82,138.22 201.54,138.22 201.25,138.51 197.2,138.51 v1(196.63,139.08) 196.06,139.65 191.99,139.65
PEG_PTX_GRX_N5: length 9.9
  BOTTOM w0.104: C22.2 198.27,139.91 198.26,139.91 198.25,139.91 197.6,139.91 v1(197.43,140.09) 196.84,140.67 190.81,140.67 190.65,140.82 190.5,140.97 189.62,140.97 U1.B15
PEG_PTX_GRX_N6: length 14.6
  BOTTOM w0.076: 192.37,141.4 192.35,141.4 192.3,141.34 191.58,141.34 190.93,142 190.22,142 190.13,141.91 189.69,141.91 189.57,141.79 189,141.79 188.93,141.72 188.93,141.42 189.03,141.32 189.18,141.32 U1.B16
  BOTTOM w0.104: C20.2 201.83,140.93 200.74,140.93 200.59,141.07 198.05,141.07 197.72,141.4 192.37,141.4
PEG_PTX_GRX_N7: length 9.8
  BOTTOM w0.076: U1.B17 189.45,142.37 189.45,142.45 189.7,142.7 190.23,142.7 190.41,142.52 190.8,142.52 190.86,142.58 190.88,142.58
  BOTTOM w0.104: C18.2 198.21,142.27 v1(197.2,142.27) 192.07,142.27 191.76,142.58 190.88,142.58
PEG_PTX_GRX_N8: length 14.1
  BOTTOM w0.076: 193.14,143.13 193.12,143.13 193.06,143.08 191.18,143.08 190.75,143.51 189.62,143.51 189.39,143.29 188.93,143.29 U1.C18
  BOTTOM w0.104: 193.14,143.13 v1(196.11,143.13) 196.87,143.13 197.33,143.59 201.8,143.59 C16.2
PEG_PTX_GRX_N9: length 10.2
  BOTTOM w0.076: U1.A19 189.95,143.84 190.02,143.92 190.26,143.92 190.38,143.79 191.03,143.79 191.08,143.74 191.1,143.74
  BOTTOM w0.104: C14.2 198.57,144.45 198.42,144.3 198.24,144.3 198.14,144.4 198.14,144.88 198.04,144.99 197.58,144.99 v1(197.35,144.76) 196.84,144.25 193.21,144.25 192.7,143.74 191.1,143.74
PEG_PTX_GRX_N10: length 14.8
  BOTTOM w0.076: 191.33,144.43 191.32,144.43 191.26,144.48 191.08,144.48 190.75,144.15 190.52,144.15 190.42,144.25 189.9,144.25 189.75,144.4 189.58,144.4 189.49,144.32 188.91,144.32 U1.C20
  BOTTOM w0.104: C12.2 201.72,146.54 v1(200.83,146.54) 197.53,146.54 196.16,145.16 192.63,145.16 191.89,144.43 191.33,144.43
PEG_PTX_GRX_N11: length 10.6
  BOTTOM w0.104: C10.2 198.2,148.92 198.13,148.85 198.13,148.4 198.02,148.29 196.41,148.29 v1(195.93,147.81) 194.22,146.11 193.74,146.11 193.62,146.23 193.2,146.23 193.08,146.11 192.66,146.11 192.54,146.23 192.12,146.23 191.99,146.11 191.71,146.11 191.1,145.5 190.07,145.5 U1.A21
PEG_PTX_GRX_N12: length 15.1
  BOTTOM w0.104: U1.C22 188.95,146.46 190.34,146.46 190.47,146.59 191.18,146.59 191.53,146.94 193.5,146.94 195.87,149.3 197.33,149.3 197.84,149.82 200.1,149.82 200.23,149.69 v1(201.01,149.69) 201.8,149.69 201.81,149.68 C8.2
PEG_PTX_GRX_N13: length 11.2
  BOTTOM w0.104: U1.A23 189.76,146.94 189.64,147.06 189.64,147.24 189.75,147.36 189.92,147.36 190.05,147.23 190.88,147.23 191.3,147.66 192.99,147.66 195.65,150.32 v1(196.06,150.32) 197.09,150.32 197.83,151.06 198.24,151.06 C6.2
PEG_PTX_GRX_N14: length 11.1
  BOTTOM w0.076: 190.88,148.37 190.86,148.37 190.8,148.31 190.24,148.31 190.11,148.19 189.06,148.19 188.84,147.97 188.84,147.83 188.74,147.73 U1.C24
  BOTTOM w0.104: C4.2 196.67,152.76 196.47,152.56 195.22,152.56 194.25,151.59 194.25,150.18 192.44,148.37 190.88,148.37
PEG_PTX_GRX_N15: length 12.8
  BOTTOM w0.076: 191.34,149.02 191.32,149.01 191.25,149.01 191.08,148.84 189.75,148.84 189.6,148.69 189.6,148.48 189.67,148.41 189.85,148.41 189.95,148.51 U1.A25
  BOTTOM w0.104: 191.34,149.02 191.41,149.09 191.6,149.28 192.46,149.28 193.62,150.44 193.62,151.94 195.58,153.9 v1(197.48,153.9) 198.37,153.9 C2.2
PEG_PTX_GRX_P0: length 16.4
  BOTTOM w0.076: U1.C10 188.77,136.59 188.77,136.43 188.97,136.22 190.25,136.22 190.36,136.12 191.03,136.12 191.08,136.06 191.1,136.06
  BOTTOM w0.104: 191.1,136.06 192.03,136.06 192.3,135.79 194.08,135.79 195.29,134.58 195.29,133.32 196.38,132.23 199.3,132.23 199.74,132.67 v1(200.72,132.67) 201.7,132.67 C31.2
PEG_PTX_GRX_P1: length 10.7
  BOTTOM w0.089: U1.A11 189.91,137.53 189.79,137.53 189.71,137.45 189.71,137.31 189.82,137.21 190.08,137.21 190.24,137.37 190.99,137.37 191.56,136.8 192.7,136.8 192.74,136.75 192.76,136.75
  BOTTOM w0.104: C29.2 198.04,134.67 v1(196.87,134.67) 196.61,134.67 194.53,136.75 192.76,136.75
PEG_PTX_GRX_P2: length 15
  BOTTOM w0.076: 191.1,138.13 190.98,138.13 190.72,137.87 190.34,137.87 190.22,138 188.93,138 U1.C12
  BOTTOM w0.104: C27.2 202.07,134.95 201.84,135.18 201.16,135.18 200.76,135.59 196.84,135.59 v1(196.46,135.97) 194.79,137.64 191.72,137.64 191.23,138.13 191.1,138.13
PEG_PTX_GRX_P3: length 10.3
  BOTTOM w0.076: 191.23,139.02 191.21,139.02 191.16,138.97 190.99,138.97 190.91,139.04 189.97,139.04 U1.A13
  BOTTOM w0.104: 191.23,139.02 191.72,139.02 191.96,138.78 195.53,138.78 v1(196.56,137.76) 197.33,136.99 197.96,136.99 198.06,137.09 198.06,137.72 198.14,137.8 198.34,137.8 C25.2
PEG_PTX_GRX_P4: length 14.6
  BOTTOM w0.076: U1.C14 188.82,139.69 188.82,139.59 189.02,139.39 190.12,139.39 190.23,139.27 191.53,139.27 191.69,139.44 191.93,139.44 191.97,139.39 191.99,139.39
  BOTTOM w0.104: 191.99,139.39 195.95,139.39 197.09,138.26 v1(200.89,138.26) 201.14,138.26 201.44,137.96 201.71,137.96 202.05,137.62 C23.2
PEG_PTX_GRX_P5: length 9.9
  BOTTOM w0.104: U1.A15 189.83,140.65 189.74,140.55 189.74,140.43 189.85,140.31 190.03,140.31 190.36,140.64 190.47,140.64 190.7,140.41 v1(196.06,140.41) 196.74,140.41 197.5,139.65 198.15,139.65 198.52,139.28 C21.2
PEG_PTX_GRX_P6: length 14.7
  BOTTOM w0.076: 192.37,141.14 192.35,141.14 192.3,141.19 191.52,141.19 190.86,141.85 190.28,141.85 190.19,141.76 189.76,141.76 189.66,141.66 189.66,141.35 189.45,141.15 188.93,141.15 U1.C16
  BOTTOM w0.104: C19.2 201.7,140.67 v1(200.88,140.67) 200.63,140.67 200.49,140.81 197.95,140.81 197.62,141.14 192.37,141.14
PEG_PTX_GRX_P7: length 9.8
  BOTTOM w0.076: 190.88,142.32 190.86,142.32 190.8,142.37 190.34,142.37 190.16,142.55 189.76,142.55 189.6,142.39 189.6,142.27 189.65,142.22 U1.A17
  BOTTOM w0.104: C17.2 198.2,142.01 191.96,142.01 191.65,142.32 190.88,142.32
PEG_PTX_GRX_P8: length 14.1
  BOTTOM w0.076: 193.14,142.88 193.13,142.88 193.07,142.93 191.12,142.93 190.69,143.36 189.76,143.36 189.62,143.22 189.62,142.86 189.5,142.74 189.37,142.74 189.3,142.82 U1.B18
  BOTTOM w0.104: 193.14,142.88 196.98,142.88 197.44,143.34 v1(200.88,143.34) 201.83,143.34 202,143.16 C15.2
PEG_PTX_GRX_P9: length 10.1
  BOTTOM w0.076: U1.B19 189.53,143.79 189.81,144.07 190.32,144.07 190.44,143.95 191.03,143.95 191.08,144 191.1,144
  BOTTOM w0.104: C13.2 198.22,145.27 197.5,145.27 197.47,145.24 196.74,144.51 v1(196.06,144.51) 193.11,144.51 192.6,144 191.1,144
PEG_PTX_GRX_P10: length 14.7
  BOTTOM w0.076: 191.33,144.68 191.31,144.68 191.26,144.63 191.08,144.63 190.76,144.95 190.41,144.95 190.31,144.85 189.46,144.85 189.37,144.95 189.15,144.95 189.04,144.84 189.04,144.66 189.12,144.58 U1.B20
  BOTTOM w0.104: 191.33,144.68 191.78,144.68 192.52,145.42 196.05,145.42 197.42,146.79 v1(199.55,146.79) 201.67,146.79 C11.2
PEG_PTX_GRX_P11: length 10.6
  BOTTOM w0.104: C9.2 v1(197.58,148.03) 196.51,148.03 194.33,145.85 191.81,145.85 191.21,145.24 190.37,145.24 190.19,145.06 189.6,145.06 U1.B21
PEG_PTX_GRX_P12: length 15.1
  BOTTOM w0.104: U1.B22 189.24,146.1 189.24,145.85 189.34,145.75 190.85,145.75 191.78,146.68 193.61,146.68 195.98,149.05 v1(196.21,149.05) 197.43,149.05 197.94,149.56 199.99,149.56 200.12,149.43 201.9,149.43 202.08,149.25 C7.2
PEG_PTX_GRX_P13: length 11.2
  BOTTOM w0.076: 190.42,146.94 190.11,146.64 189.6,146.64 U1.B23
  BOTTOM w0.104: 190.42,146.94 190.95,146.94 191.41,147.4 193.09,147.4 195.76,150.06 197.2,150.06 v1(197.58,150.45) 197.93,150.8 198.17,150.8 C5.2
PEG_PTX_GRX_P14: length 11.1
  BOTTOM w0.076: U1.B24 189.3,147.71 189.22,147.64 189.07,147.64 189,147.71 189,147.91 189.12,148.03 190.18,148.03 190.3,148.16 190.8,148.16 190.86,148.11 190.88,148.11
  BOTTOM w0.104: C3.2 196.67,152.05 196.42,152.3 195.33,152.3 194.51,151.48 194.51,150.07 192.55,148.11 190.88,148.11
PEG_PTX_GRX_P15: length 12.9
  BOTTOM w0.076: 191.16,149.2 191.14,149.19 191.14,149.11 191.02,148.99 189.68,148.99 189.44,148.75 189.44,148.55 189.41,148.52 U1.B25
  BOTTOM w0.104: C1.2 198.29,154.16 v1(196,154.16) 195.47,154.16 193.36,152.05 193.36,150.55 192.35,149.54 191.49,149.54 191.16,149.2
PEG_RCOMP: length 5.5
  BOTTOM w0.305: U1.G2 185.95,131.41 185.95,130.68 188.07,128.55 188.82,128.55 R1.2
PLT_RST_N: length 515.7
  TOP w0.089: 31.97,80.72 R2099.1 31.49,79.84 R2096.1
  TOP w0.097: v1(293.97,47.58) 296.64,47.58 298.67,49.61 298.67,53.93 299.05,54.31 v2(299.05,54.44) 299.05,59.64 298.67,60.02 298.67,61.67 304.39,67.39 304.39,70.82 303.89,71.31 U63.1 ; v1(253.08,46.05) 252.32,45.29 249.09,45.29 248.89,45.09 R117.2 247.03,45.09 v1(246.48,44.53) ; R458.2 v1(256.76,64.85) ; 31.97,80.72 31.64,81.05 v2(31.49,81.05) ; v1(62.96,89.23) 63.34,89.23 63.85,89.74 63.85,91.6 R2101.2 ; R274.1 v1(55.09,69.04)
  IN03 w0.091: v1(256.76,64.85) 254.58,62.67 254.58,62.41 253.25,61.09 253.25,49.15 249.4,45.29 247.24,45.29 v1(246.48,44.53) ; v1(55.09,69.04) 60.17,69.04 63.09,71.96 v1(69.06,71.96) 69.57,71.96 70.2,71.33 73.25,71.33 73.38,71.45 77.82,71.45 81.63,67.64 85.31,67.64 89,71.33 97.76,71.33 98.14,71.71 98.14,74.88 97.38,75.64 95.09,75.64 v1(94.58,76.15) ; v1(96.36,35.64) 107.67,35.64 119.99,47.96 146.91,47.96 153.77,41.1 153.77,40.72 v1(154.4,40.08)
  IN05 w0.091: v1(51.15,57.23) 50.62,56.7 41.27,56.7 39.47,58.5 34.26,58.5 33.62,59.13 33.62,59.77 32.86,60.53 32.74,60.53 v1(32.48,60.79) ; v1(293.97,47.58) 291.18,47.58 288.26,44.66 286.23,44.66 285.59,45.29 283.31,45.29 282.16,44.15 279.62,44.15 277.21,46.56 275.31,46.56 273.13,48.74 267.28,48.74 265.62,50.41 265.62,54.78 266.56,55.72 266.56,58.94 266.12,59.38 265.18,59.38 264.97,59.59 261.82,59.59 257.77,55.54 257.77,50.62 256.26,49.1 256.26,48.21 254.35,46.31 253.33,46.31 v1(253.08,46.05)
  IN08 w0.091: v1(47.98,43.01) 48.86,43.89 48.86,47.7 48.23,48.34 48.23,53.04 48.36,53.17 48.36,57.36 49.12,58.12 50.77,58.12 51.15,57.74 v1(51.15,57.23) ; v1(62.96,89.23) 62.45,88.73 62.45,88.09 63.39,87.16 63.39,78.65 66.52,75.52 66.52,73.23 67.79,71.96 v1(69.06,71.96)
  IN10 w0.089: 26.97,77.04 27.22,76.79 30.09,76.79 31.11,77.8 31.11,80.67 31.16,80.72
  IN10 w0.091: v1(55.09,69.04) 53.56,69.04 51.53,67.01 51.53,57.61 v1(51.15,57.23) ; v1(96.36,35.64) 96.36,39.7 91.92,44.15 91.92,58.5 92.3,58.88 92.3,66.25 93.57,67.52 93.57,72.47 94.58,73.49 v1(94.58,76.15) ; 31.16,80.72 v2(31.49,81.05) ; v1(154.4,40.08) 156.56,42.24 203.4,42.24 206.56,45.4 212.46,45.4 216,41.86 244.95,41.86 246.48,43.39 v1(246.48,44.53) ; 26.97,77.04 26.39,77.04 25.75,76.41 25.75,72.98 26.26,72.47 26.26,70.44 25.75,69.93 25.75,67.01 31.97,60.79 v1(32.48,60.79)
  BOTTOM w0.097: U4.4 246.69,44.74 v1(246.48,44.53) 246.78,44.22 R123.2 ; v1(32.48,60.79) 32.66,60.61 32.71,60.61 32.99,60.33 R478.2 R237.1 ; JIO1.17 299.47,46.52 298.55,47.45 294.1,47.45 v1(293.97,47.58) ; R483.2 95.55,75.19 v1(94.58,76.15) ; R840.2 v1(47.98,43.01)
PM_BATLOW_N: length 4.1
  BOTTOM w0.097: U2.BD13 242.36,51.67 242.23,51.53 242.23,50.44 242.03,50.24 242.03,49.61 v2(241.72,49.3) 241.02,48.59 R139.2
PM_PCH_PWROK: length 255.2
  TOP w0.097: R147.2 244.32,53.8 v3(243.81,53.29)
  IN03 w0.091: v1(47.09,37.04) 47.09,36.78 47.9,35.97 47.9,35.21 48.23,34.88 63.6,34.88 64.23,34.24 71.22,34.24 74.01,31.44 85.99,31.44 87.9,33.35 95.6,33.35 96.26,34.01 107.34,34.01 119.55,46.21 146.71,46.21 150.97,41.95 v1(150.97,40.08)
  IN05 w0.091: v1(26.13,47.32) 25.62,46.82 25.62,46.43 25.33,46.15 25.33,39.61 29.73,35.21 39.42,35.21 40.81,36.6 43.61,36.6 44.55,37.54 46.58,37.54 v1(47.09,37.04)
  IN10 w0.091: v3(243.81,53.29) 243.81,52.53 243.05,51.77 241.9,51.77 241.27,51.13 241.27,50.12 241.14,49.99 241.14,49.08 240.27,48.21 239.62,48.21 239.34,47.93 238.83,47.93 237.84,46.94 237.84,46.31 235.81,44.28 225.45,44.28 224.94,44.78 216.5,44.78 214.09,47.2 206.09,47.2 202.53,43.64 154.27,43.64 150.97,40.34 v1(150.97,40.08)
  BOTTOM w0.097: v1(26.13,47.32) 26.39,47.32 27.02,46.69 R262.2 ; v3(243.81,53.29) 243.81,53.49 U2.AW11
PM_PCH_PWROK_R: length 6.7
  BOTTOM w0.097: U5.C1 32,50.91 30.58,49.48 30.58,48.54 v2(30.35,48.32) 30.14,48.11 29.56,48.11 29.43,47.98 29.43,47.83 28.8,47.2 28.49,47.2 R262.1
PM_RSMRST_N: length 256.4
  TOP w0.097: v3(243.68,54.44) 243.25,54.87 R149.2
  IN05 w0.089: 37.73,56.59 37.6,56.47 33.62,56.47 32.43,57.66 32.43,58.63
  IN05 w0.091: v1(31.19,59.13) 31.19,59.56 31.28,59.65 32.09,59.65 32.43,59.31 32.43,58.63 ; 37.73,56.59 37.99,56.85 38.72,56.85 39.85,55.72 40.98,55.72 41.75,54.94 46.45,54.94 49.75,51.64 50.13,51.64 51.19,50.59 53.04,50.59 58.21,45.42 66.01,45.42 67.66,43.77 69.18,43.77 69.95,43.01 74.9,43.01 75.28,43.39 82.9,43.39 83.79,44.28 92.2,44.28 96.62,39.86 96.62,39.04 97.27,38.38 100.63,35.03 111.07,35.03 113.5,37.45 116.96,37.45 118.21,36.2 v1(118.21,35.51)
  IN08 w0.091: v1(143.99,38.81) 143.99,41.74 142.26,43.46 122.74,43.46 119.6,40.32 119.6,36.91 v1(118.21,35.51)
  IN10 w0.091: v3(243.68,54.44) 242.92,54.44 242.35,53.86 242.35,52.85 241.02,51.51 241.02,50.5 240.76,50.24 240.76,48.97 240.25,48.47 239.36,48.47 239.03,48.14 237.89,48.14 234.47,44.71 225.65,44.71 225.1,45.26 216.79,45.26 214.22,47.83 205.71,47.83 202.26,44.38 153.49,44.38 150.12,41.01 150.12,39.83 149.1,38.81 v1(143.99,38.81)
  BOTTOM w0.097: U5.N3 33.27,57.33 32.99,57.61 32.8,57.61 31.28,59.13 v1(31.19,59.13) ; U2.AV11 243.43,54.79 243.68,54.53 v3(243.68,54.44) 243.61,54.36 243.1,54.36 242.92,54.18 242.92,53.85 243.27,53.5 U2.BA11
POST_I2C_CLK: length 29.1
  TOP w0.097: U7.12 284.66,31.81 283.28,31.81 v1(282.8,31.32) ; U8.17 267.72,29.45 267.18,28.91 v1(267.18,27.77) R319.2 R321.2
  IN10 w0.091: v1(267.18,27.77) 269.59,25.35 270.99,25.35 272.03,24.31 279.98,24.31 281.27,25.61 281.27,30.43 282.16,31.32 v1(282.8,31.32)
POST_I2C_DATA: length 28.7
  TOP w0.097: U7.11 284.07,32.21 284.07,32.21 283.81,32.21 283.69,32.08 283.18,32.08 v1(282.8,32.46) ; R320.2 R318.2 v1(267.18,29.54) 267.59,29.95 U8.16
  IN10 w0.091: v1(267.18,29.54) 270.99,25.73 271.37,25.73 272.41,24.69 279.72,24.69 281.02,25.99 281.02,30.69 v1(282.8,32.46)
POST_I2S_BCLK: length 25.2
  TOP w0.097: v1(269.97,24.79) 269.97,25.86 269.38,26.45 U8.23 ; v1(280.51,37.67) 280.51,37.67 R298.1
  IN03 w0.091: v1(269.97,24.79) 270.43,24.34 275.43,24.34 277.34,26.24 277.34,34.5 v1(280.51,37.67)
  BOTTOM w0.097: C336.1 v1(280.51,37.67)
POST_I2S_IN: length 32.6
  TOP w0.097: v1(268.55,23.07) 266.67,23.07 265.58,24.16 R322.1
  TOP w0.203: v1(283.48,34.75) 283.67,34.75 283.81,34.61 284.66,34.61 U7.5
  IN10 w0.091: v1(268.55,23.07) 269.34,23.07 270.23,23.96 280,23.96 281.53,25.48 281.53,29.92 282.42,30.81 283.94,30.81 284.07,30.94 284.07,34.16 v1(283.48,34.75)
  BOTTOM w0.254: C333.1 283.49,34.75 v1(283.48,34.75)
POST_I2S_LRCLK: length 16.6
  TOP w0.097: R301.1 280.51,36.78 v1(280.51,36.78) ; v1(278.1,25.15) 277.3,25.95 U8.25
  IN03 w0.091: v1(280.51,36.78) 277.59,33.86 277.59,25.66 v1(278.1,25.15)
  BOTTOM w0.097: v1(280.51,36.78) C335.1
POST_I2S_MCLK: length 25.7
  TOP w0.097: v1(270.73,24.79) 270.73,25.73 269.51,26.95 U8.22 ; v1(280.51,38.56) 280.51,38.56 R296.1
  IN03 w0.091: v1(270.73,24.79) 275.51,24.79 276.96,26.24 276.96,35 v1(280.51,38.56)
  BOTTOM w0.097: C337.1 v1(280.51,38.56)
POST_I2S_OUT: length 26.6
  TOP w0.097: R302.1 280.51,35.89 v1(280.51,35.89) ; U8.24 268.99,25.95 269.21,25.73 v1(269.21,24.79)
  IN03 w0.091: v1(280.51,35.89) 280,35.39 280,31.96 280.51,31.45 280.51,29.42 279.12,28.02 279.12,26.69 279.62,26.18 279.62,24.72 278.86,23.96 270.05,23.96 v1(269.21,24.79)
  BOTTOM w0.097: C334.1 v1(280.51,35.89)
PROC_SELECT_N: length 5.4
  BOTTOM w0.097: R21.2 148.54,127.97 151.33,130.76 U1.BN1
PS1_NVVDD_EN: length 2.4
  BOTTOM w0.097: PR30.1 300.2,198.6 PU5.10
PSYS: length 309
  TOP w0.097: PU1101.29 130.12,190 130.8,189.31 v1(130.98,189.31) PR1192.1 ; v3(79.47,5.03) 79.09,5.41 79.09,6.05 79.55,6.51 PR226.1 PR216.1
  IN03 w0.089: 41.5,52.02 40.23,52.02 v2(39.72,51.51)
  IN03 w0.091: v1(72.23,57.23) 71.72,56.72 63.72,56.72 58.39,51.39 56.23,51.39 55.09,50.24 51.28,50.24 48.99,52.53 42.39,52.53 41.88,52.02 41.5,52.02
  IN08 w0.089: v2(39.72,51.51) 39.72,51.9 40.36,52.53 40.36,53.93 40.86,54.44 40.86,58.63
  IN08 w0.091: v3(79.47,5.03) 80.11,5.67 80.11,7.06 80.87,7.83 80.87,16.08 78.91,18.04 78.91,30.13 79.61,30.82 79.61,33.6 76.17,37.04 76.17,45.29 74.14,47.32 74.14,53.17 72.74,54.56 72.74,56.72 v1(72.23,57.23) ; v1(63.85,72.47) 63.85,73.74 59.15,78.44 44.55,78.44 44.29,78.18 43.78,78.18 41.12,75.52 41.12,69.55 41.37,69.29 41.37,68.41 39.72,66.75 39.72,62.56 40.86,61.42 40.86,58.63
  IN10 w0.091: v1(63.85,72.47) 65.76,72.47 66.39,73.1 70.07,73.1 75.66,78.69 76.55,78.69 80.36,82.5 80.36,87.84 86.71,94.19 86.71,100.54 97,110.82 99.79,110.82 109.06,120.09 109.06,130.25 111.46,132.65 111.46,173.93 118.46,180.93 125.57,180.93 127.99,183.34 128.49,183.34 129.51,184.36 129.51,187.84 v1(130.98,189.31)
  BOTTOM w0.076: 38.58,52.16 38.04,52.16 37.78,52.41 U5.F12
  BOTTOM w0.097: 38.58,52.16 38.82,52.16 39.47,51.51 v2(39.72,51.51)
PWM1_VCC: length 43.9
  TOP w0.203: PU1101.34 130.44,192 130.45,192
  TOP w0.254: v1(132.89,192) 130.45,192
  IN05 w0.254: v1(132.89,192) 132.99,191.9 132.99,191.21 133.37,190.83 133.37,190.2 133.62,189.94 134.77,189.94 135.27,190.45 153.64,190.45 154.02,190.83 164.94,190.83 167.1,192.99 v1(167.1,193.12)
  BOTTOM w0.254: v1(167.1,193.12) 167.05,193.07 167.05,190.73 PR1599.2
PWM1A_ICCMAX: length 108.3
  TOP w0.203: 130.2,190.4 PU1101.30
  TOP w0.254: 130.65,190.07 130.53,190.07 130.2,190.4
  TOP w0.381: 130.65,190.07 130.78,189.94 133.32,189.94 v1(133.95,190.58)
  IN03 w0.254: v1(211.55,191.72) 212.06,191.72 212.57,192.23 212.57,198.2 211.68,199.09 210.7,199.09 209.17,197.56 200.25,197.56 199.36,196.68 197.84,196.68 195.3,194.14 192.25,194.14 191.61,194.77 189.96,194.77 189.33,194.14 185.77,194.14 185.52,193.88 171.04,193.88 169.26,195.66 166.51,195.66 164.56,193.71 164.56,192.87 162.66,190.96 154.27,190.96 153.82,191.42 141.37,191.42 141.19,191.6 134.97,191.6 v1(133.95,190.58)
  BOTTOM w0.254: PR1193.1 130.14,190.58 130.75,189.97 133.34,189.97 v1(133.95,190.58)
  BOTTOM w0.356: PR1632.2 210.69,187.15 211.07,187.53 211.93,187.53 212.47,188.07 212.47,189.67 211.55,190.58 v1(211.55,191.72)
PWM2_VCC: length 53
  TOP w0.203: 130.27,191.6 PU1101.33
  TOP w0.254: v1(134.26,191.98) 133.62,191.34 131.92,191.34 131.67,191.6 130.27,191.6
  IN05 w0.254: v1(177.26,190.33) 173.45,194.14 171.42,194.14 170.02,195.53 166.34,195.53 165.83,195.02 165.83,194.29 164.15,192.61 153.64,192.61 153.13,192.1 134.46,192.1 134.34,191.98 v1(134.26,191.98)
  BOTTOM w0.254: PR1622.2 177.13,190.2 v1(177.26,190.33)
PWM3_VCC: length 77.2
  TOP w0.203: 130.53,191.2 PU1101.32
  TOP w0.254: 130.53,191.2 131.31,191.2 131.92,190.58 v1(132.68,190.58)
  IN03 w0.254: v1(132.68,190.58) 133.32,189.94 134.54,189.94 135.5,190.91 153.69,190.91 154.02,190.58 163.94,190.58 165.96,192.6 185.25,192.6 186.41,193.75 189.07,193.75 190.22,192.61 194.53,192.61 195.42,191.72 195.42,190.96 198.98,187.4 v1(200.38,187.4)
  BOTTOM w0.356: PR1623.2 200.12,187.15 v1(200.38,187.4)
