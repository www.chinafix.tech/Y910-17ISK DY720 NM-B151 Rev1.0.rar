# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQS_DP5: length 71.8
  TOP w0.102: v1(184.94,83.9) 184.94,83.78 184.82,83.65 184.68,83.65 184.45,83.88 184.45,84.62 183.11,85.96 182.75,85.96 182.36,86.35 182.36,86.5 182.42,86.56 182.59,86.56 182.67,86.64 182.67,87.56 JDIMM2.200
  IN03 w0.076: 179.89,126.16 179.88,126.17 179.79,126.17 179.44,126.52 179.12,126.52 178.96,126.37 v1(178.62,126.37)
  IN03 w0.145: v1(184.94,83.9) 184.78,83.73 184.61,83.73 184.44,83.9 184.44,90.28 184.85,90.69 184.85,91.62 184.44,92.04 184.44,93.07 188.3,96.94 188.3,106.54 188.45,106.68 188.62,106.68 188.92,106.98 188.92,107.84 188.62,108.14 188.38,108.14 188.25,108.27 188.25,108.6 188.38,108.73 188.62,108.73 188.92,109.03 188.92,109.89 188.62,110.19 188.37,110.19 188.24,110.32 188.24,110.94 188.37,111.06 188.69,111.06 189,111.36 189,112.23 188.69,112.53 188.45,112.53 188.28,112.69 188.28,119.47 184.62,123.14 182.91,123.14 182.79,123.26 179.89,126.16
  BOTTOM w0.076: U1.V3 177.71,132.12 177.8,132.22 177.91,132.22 178,132.13 178,130.61 178.28,130.33 178.28,129.65 178.19,129.56 178.19,129.54
  BOTTOM w0.102: v1(184.94,83.9) 185.13,83.72 185.46,83.72 185.71,83.47 185.71,81.89 185.05,81.23 184.75,81.23 184.32,80.8 JDIMM1.200
  BOTTOM w0.147: 178.19,129.54 178.19,129.17 178.97,128.4 178.97,126.45 178.89,126.37 v1(178.62,126.37)
M_A_DQS_DP6: length 78.8
  TOP w0.102: JDIMM2.221 187.9,80.64 188.09,80.83 189.38,80.83 189.87,81.31 190.33,81.31 190.85,81.83 190.85,83.47 190.6,83.72 190.33,83.72 v1(190.15,83.9)
  IN03 w0.076: v1(182.03,126.71) 182.17,126.85 182.87,126.85 183.11,126.61 183.12,126.61 183.13,126.6
  IN03 w0.145: v1(190.15,83.9) 189.98,83.73 189.41,83.73 189.23,83.91 189.23,91.18 189.81,91.76 190.15,91.76 190.96,92.57 190.96,94.05 194.28,97.37 194.28,109.77 194.42,109.91 194.78,109.91 195.08,110.22 195.08,111.08 194.78,111.38 194.38,111.38 194.25,111.5 194.25,111.92 194.38,112.05 194.87,112.05 195.17,112.35 195.17,113.13 194.87,113.43 194.36,113.43 194.23,113.56 194.23,113.95 194.41,114.13 194.66,114.13 194.96,114.42 194.96,115.85 192.47,118.34 192.47,121.01 189.75,123.73 188.83,123.73 187.04,125.52 184.21,125.52 183.13,126.6
  BOTTOM w0.076: 180.69,130.06 180.68,130.07 180.68,130.15 180.63,130.2 180.49,130.35 180.49,131.73 180.59,131.83 180.59,132 180.61,132.02 180.61,132.16 180.54,132.24 180.34,132.24 U1.R3
  BOTTOM w0.102: JDIMM1.221 189.57,86.6 189.52,86.55 189.33,86.55 189.27,86.49 189.27,86.34 189.07,86.13 188.67,86.13 188.54,86.01 188.54,85.68 188.67,85.55 189.5,85.55 189.75,85.3 189.75,84.73 189.5,84.48 189.24,84.48 189.11,84.36 189.11,83.8 189.26,83.65 190.02,83.65 190.15,83.78 v1(190.15,83.9)
  BOTTOM w0.147: 180.69,130.06 180.76,129.98 182.37,128.38 182.37,126.83 182.25,126.71 v1(182.03,126.71)
M_A_DQS_DP7: length 81.8
  TOP w0.102: JDIMM2.242 193.15,86.78 193.95,85.98 193.95,85.69 194.11,85.53 195.65,85.53 196.16,85.02 196.16,83.44 195.9,83.19 195.54,83.19 v1(195.36,83.01)
  IN03 w0.076: 185.78,129.54 185.77,129.54 185.69,129.62 185.4,129.62 185.17,129.39 185.17,129.23 v1(185.27,129.14)
  IN03 w0.145: v1(195.36,83.01) 195.19,83.18 194.88,83.18 194.61,83.45 194.61,87.07 195.88,88.35 195.88,90.99 196.52,91.63 196.52,91.64 201.01,96.13 201.01,111.2 200.76,111.46 200.76,114.63 201.53,115.4 201.53,121.93 199.38,124.08 196.96,124.08 193.02,128.02 190.05,128.02 188.52,129.54 185.78,129.54
  BOTTOM w0.076: 183.66,129.57 183.61,129.62 183.61,129.82 183.28,130.15 183.28,130.38 183.03,130.63 183.03,131.57 182.94,131.67 182.94,131.92 U1.M3
  BOTTOM w0.102: JDIMM1.242 194.82,80.29 194.68,80.43 194.48,80.43 194.41,80.51 194.41,80.67 194.2,80.88 193.57,80.88 193.44,81 193.44,81.21 193.57,81.33 194.17,81.33 194.36,81.15 194.69,81.15 194.95,81.42 194.95,82 194.69,82.27 194.69,82.63 194.93,82.88 194.93,83.19 194.99,83.26 195.23,83.26 195.36,83.13 v1(195.36,83.01)
  BOTTOM w0.147: v1(185.27,129.14) 185.05,129.14 184.81,128.9 184.33,128.9 183.66,129.57
M_B_A0: length 88.3
  TOP w0.102: JDIMM4.144 166.85,73.61 167,73.46 168.42,73.46 169.04,72.84 169.04,70.46 v1(169.45,70.06)
  IN10 w0.076: 170.15,120.2 170.15,121.95 170.53,122.33 170.53,130.72 170.02,131.23 170.02,134.59 169.84,134.78 169.84,135.97 v1(169.46,136.35)
  IN10 w0.175: 170.15,120.2 169.97,120.02 169.97,107.37 169.26,106.66 169.26,106.27 169.44,106.09 169.84,106.09 170.01,105.92 170.01,105.57 169.84,105.39 168.83,105.39 168.65,105.22 168.65,104.87 168.83,104.69 169.84,104.69 170.01,104.52 170.01,104.17 169.84,103.99 169.44,103.99 169.26,103.82 169.26,95.71 169.08,95.54 168.78,95.54 168.66,95.41 168.66,94.97 168.78,94.84 169.08,94.84 169.26,94.66 169.26,94.31 169.08,94.14 168.71,94.14 168.58,94.01 168.58,93.56 168.71,93.44 169.08,93.44 169.26,93.26 169.26,92.18 167.53,90.45 167.53,88.29 167.2,87.96 167.2,85.98 167.53,85.65 167.53,81.39 167.25,81.11 167.25,78.46 167.53,78.18 167.53,74.53 168.63,73.43 168.63,70.03 168.86,69.8 169.2,69.8 v1(169.45,70.06)
  BOTTOM w0.076: v1(169.46,136.35) 169.13,136.03 U1.AJ9
  BOTTOM w0.102: JDIMM3.144 168.55,67.01 168.8,67.26 169.26,67.26 169.39,67.14 169.39,66.81 169.51,66.68 169.78,66.68 169.91,66.81 169.91,69.6 v1(169.45,70.06)
M_B_A1: length 86.7
  TOP w0.102: v1(164.5,72.29) 164.07,71.87 164.07,68.2 164.1,68.17 JDIMM4.133
  IN10 w0.076: v1(168.83,133.74) 168.5,133.41 168.5,132.24 168.19,131.93 168.19,131.17 168.02,130.99 168.02,121.69 166.14,119.82
  IN10 w0.175: 166.14,119.82 166.14,113.67 165.86,113.39 164.79,113.39 164.54,113.14 164.54,112.83 164.71,112.66 166,112.66 166.18,112.48 166.18,112.13 166,111.96 164.71,111.96 164.54,111.78 164.54,111.43 164.71,111.26 166,111.26 166.18,111.08 166.18,110.73 166,110.55 164.71,110.55 164.54,110.38 164.54,110.03 164.71,109.85 166,109.85 166.18,109.68 166.18,109.33 166,109.15 164.71,109.15 164.54,108.98 164.54,94.16 164.38,94.01 164.06,94.01 163.93,93.88 163.93,93.37 164.23,93.07 164.23,92.36 163.93,92.06 163.93,75.24 163.7,75.01 163.7,74.02 164.5,73.22 v1(164.5,72.29)
  BOTTOM w0.102: v1(164.5,72.29) 164.78,72.29 164.9,72.16 164.9,70.87 165.03,70.74 165.25,70.74 165.37,70.87 165.37,72.44 165.16,72.66 165.16,72.83 165.28,72.95 165.5,72.95 165.8,73.25 JDIMM3.133
  BOTTOM w0.198: v1(168.83,133.74) U1.AK6
M_B_A2: length 89.1
  TOP w0.102: v1(162.72,68.48) 163.24,68.48 163.35,68.6 163.35,70.32 163.24,70.44 162.59,70.44 162.29,70.74 162.29,72.01 163.85,73.56 JDIMM4.132
  IN10 w0.076: 166.69,120.02 168.18,121.5 168.18,130.88 168.37,131.07 168.37,131.85 168.87,132.35 v1(168.87,133.11)
  IN10 w0.175: 166.69,120.02 166.69,109.05 165.15,107.5 165.15,93.6 165.25,93.5 165.25,92.23 164.31,91.29 164.31,74.22 165.04,73.49 165.04,71.76 166.09,70.71 166.09,67.9 165.2,67.01 163.55,67.01 162.72,67.83 v1(162.72,68.48)
  BOTTOM w0.076: U1.AK5 168.56,133.42 v1(168.87,133.11)
  BOTTOM w0.102: JDIMM3.132 165.55,67 165.3,67.25 164.7,67.25 163.88,68.08 163.88,69.41 163.13,70.16 162.55,70.16 162.25,69.86 162.25,68.95 v1(162.72,68.48)
M_B_A3: length 86
  TOP w0.102: JDIMM4.131 163.6,67.94 163.7,68.03 163.7,70.68 v1(162.72,71.66)
  IN10 w0.076: 163.34,119.54 163.34,119.66 165.2,121.52 165.2,123.96 165.6,124.36 165.6,129.21 165.88,129.49 165.88,131.09 166.95,132.16 166.95,132.89 v1(167.16,133.11)
  IN10 w0.175: 163.34,119.54 163.34,115.78 161.61,114.05 161.61,106.07 161.44,105.89 160.94,105.89 160.76,105.72 160.76,105.37 160.94,105.19 161.44,105.19 161.61,105.02 161.61,104.67 161.44,104.49 160.94,104.49 160.76,104.31 160.76,103.96 160.94,103.79 161.44,103.79 161.61,103.61 161.61,103.26 161.44,103.09 160.94,103.09 160.76,102.91 160.76,102.56 160.94,102.39 161.44,102.39 161.61,102.21 161.61,101.86 161.44,101.69 160.94,101.69 160.76,101.51 160.76,101.16 160.94,100.98 161.44,100.98 161.61,100.81 161.61,100.46 161.44,100.28 160.94,100.28 160.76,100.11 160.76,99.76 160.94,99.58 161.44,99.58 161.61,99.41 161.61,99.06 161.44,98.88 160.94,98.88 160.76,98.71 160.76,98.36 160.94,98.18 161.44,98.18 161.61,98.01 161.61,97.66 161.44,97.48 161.08,97.48 160.9,97.31 160.9,96.96 161.08,96.78 161.44,96.78 161.61,96.61 161.61,95.61 161.34,95.33 161.34,94.52 161.48,94.37 161.48,72.45 162.27,71.66 v1(162.72,71.66)
  BOTTOM w0.076: U1.AL5 167.47,133.42 v1(167.16,133.11)
  BOTTOM w0.102: JDIMM3.131 165.3,73.53 165.08,73.3 164.53,73.3 164.04,72.81 164.04,71.15 163.92,71.02 163.55,71.02 163.42,71.15 163.42,71.53 163.29,71.66 v1(162.72,71.66)
M_B_A4: length 85.8
  TOP w0.102: JDIMM4.128 162.85,73.35 161.97,72.47 161.97,70.5 v1(162.72,69.75)
  IN10 w0.076: v1(167.16,133.74) 166.75,133.33 166.75,132.3 165.7,131.26 165.7,129.62 165.35,129.26 165.35,124.57 164.94,124.16 164.94,121.64 163.3,120.01
  IN10 w0.175: v1(162.72,69.75) 162.45,69.75 161.59,70.62 161.59,71.81 161.05,72.34 161.05,93.35 160.52,93.88 160.52,96.52 160.24,96.8 160.24,106.48 160.42,106.65 160.92,106.65 161.1,106.83 161.1,107.18 160.92,107.35 160.42,107.35 160.24,107.53 160.24,107.88 160.42,108.06 160.92,108.06 161.1,108.23 161.1,108.58 160.92,108.76 160.42,108.76 160.24,108.93 160.24,109.28 160.42,109.46 160.92,109.46 161.1,109.63 161.1,109.98 160.92,110.16 160.42,110.16 160.24,110.33 160.24,110.68 160.42,110.86 160.92,110.86 161.1,111.03 161.1,111.39 160.92,111.56 160.42,111.56 160.24,111.74 160.24,112.09 160.42,112.26 160.92,112.26 161.1,112.44 161.1,112.79 160.92,112.96 160.42,112.96 160.24,113.14 160.24,113.44 162.63,115.83 162.63,119.33 163.3,120.01
  BOTTOM w0.076: v1(167.16,133.74) 167.16,133.91 167.31,134.07 U1.AL6
  BOTTOM w0.102: JDIMM3.128 164.55,66.97 163.95,67.57 163.42,67.57 163.23,67.76 163.23,68.62 163.33,68.73 163.45,68.73 163.57,68.84 163.57,69.01 163.45,69.13 163.33,69.13 163.23,69.23 163.23,69.62 163.1,69.75 v1(162.72,69.75)
M_B_A5: length 85.4
  TOP w0.102: JDIMM4.126 162.35,73.33 161.61,72.6 161.61,72.11 161.18,71.68 160.78,71.68 160.47,71.38 160.47,70.41 160.88,70 v1(160.94,70)
  IN10 w0.076: v1(166.71,135.05) 165.32,133.66 165.32,129.82 164.89,129.39 164.89,124.9 164.43,124.44 164.43,121.8 163.32,120.68 162.94,120.68
  IN10 w0.175: v1(160.94,70) 160.94,70.01 160.5,70.01 160.37,69.88 160.37,69.42 160.24,69.29 159.86,69.29 159.74,69.42 159.74,78.84 159.61,78.97 159.3,78.97 159.05,79.23 159.05,79.91 159.25,80.12 159.53,80.12 159.74,80.32 159.74,86.31 159.13,86.92 159.13,87.71 159.74,88.32 159.74,90.32 159.18,90.88 159.18,91.75 159.74,92.31 159.74,93.41 159.4,93.74 159.4,95.99 159.21,96.19 159.21,113.95 161.36,116.11 161.36,119.61 162.43,120.68 162.94,120.68
  BOTTOM w0.102: JDIMM3.126 164.05,67 163.81,67.24 163.32,67.24 161.58,68.98 161.58,69.76 161.34,70 v1(160.94,70)
  BOTTOM w0.198: v1(166.71,135.05) 166.76,135.01 U1.AM6
M_B_A6: length 85.6
  TOP w0.102: v1(160.94,71.27) 160.96,71.27 161.64,70.59 161.64,70.39 162.25,69.78 162.25,67.65 162.6,67.3 JDIMM4.127
  IN10 w0.076: v1(166.37,133.74) 165.5,132.88 165.5,129.72 165.12,129.34 165.12,124.69 164.66,124.23 164.66,121.69 163.27,120.3 162.77,120.3 162.41,119.94
  IN10 w0.175: v1(160.94,71.27) 160.94,71.19 160.81,71.06 160.24,71.06 160.12,71.19 160.12,71.58 160.24,71.71 160.62,71.71 160.75,71.83 160.75,72.09 160.62,72.22 160.37,72.22 160.14,72.44 160.14,72.83 160.32,73.01 160.52,73.01 160.65,73.14 160.65,73.58 160.52,73.71 160.24,73.71 160.12,73.84 160.12,74.28 160.24,74.41 160.52,74.41 160.65,74.54 160.65,74.99 160.52,75.11 160.24,75.11 160.12,75.24 160.12,75.64 160.24,75.77 160.5,75.77 160.62,75.9 160.62,78.78 160.5,78.91 160.29,78.91 160.17,79.03 160.17,79.48 160.29,79.61 160.5,79.61 160.62,79.73 160.62,80.18 160.5,80.31 160.32,80.31 160.19,80.44 160.19,80.88 160.32,81.01 160.5,81.01 160.62,81.14 160.62,85.9 160.5,86.02 160.37,86.02 160.19,86.2 160.19,86.55 160.37,86.72 160.5,86.72 160.62,86.85 160.62,87.3 160.5,87.43 160.24,87.43 160.12,87.55 160.12,88 160.24,88.13 160.5,88.13 160.62,88.25 160.62,91.02 160.5,91.15 160.16,91.15 159.99,91.32 159.99,91.68 160.16,91.85 160.45,91.85 160.62,92.03 160.62,93.22 159.96,93.88 159.96,96.24 159.72,96.48 159.72,113.71 161.94,115.93 161.94,119.47 162.41,119.94
  BOTTOM w0.102: JDIMM3.127 164.3,73.55 163.71,72.96 163.27,72.96 162.58,72.27 162,72.27 161.7,71.98 161.7,71.84 161.88,71.66 161.88,71.49 161.76,71.37 161.59,71.37 161.42,71.55 161.28,71.55 161,71.27 v1(160.94,71.27)
  BOTTOM w0.198: v1(166.37,133.74) 166.25,133.85 U1.AN7
M_B_A7: length 89.9
  TOP w0.102: v1(158.66,71.52) 158.89,71.76 159.53,71.76 159.76,71.99 159.9,71.99 160.18,71.71 160.35,71.71 160.47,71.83 160.47,72 160.19,72.27 160.19,72.42 160.34,72.56 160.48,72.56 160.95,72.1 161.11,72.1 161.23,72.22 161.23,72.38 160.77,72.85 160.77,72.99 160.93,73.16 161.11,73.16 161.18,73.08 161.26,73.08 161.37,72.97 161.53,72.97 161.64,73.08 161.64,73.23 161.35,73.52 JDIMM4.122
  IN10 w0.076: 163.29,121.31 163.82,121.85 163.82,128.96 164.97,130.1 164.97,133.75 166.06,134.84 166.06,135.29 166.33,135.56 166.33,136.62 v1(166.71,137)
  IN10 w0.175: 163.29,121.31 161.69,121.31 160.18,119.8 160.18,116.42 158.17,114.42 158.17,110.22 157.93,109.98 157.93,109.52 158.17,109.28 158.17,108.82 157.93,108.58 157.93,108.12 158.17,107.88 158.17,107.42 157.93,107.18 157.93,106.72 158.17,106.48 158.17,106.01 157.93,105.78 157.93,105.31 158.17,105.08 158.17,104.61 157.93,104.38 157.93,103.91 158.17,103.68 158.17,103.21 157.93,102.97 157.93,102.51 158.17,102.27 158.17,101.81 157.93,101.57 157.93,101.11 158.17,100.87 158.17,100.41 157.93,100.17 157.93,99.71 158.17,99.47 158.17,99 157.93,98.77 157.93,98.3 158.17,98.07 158.17,97.6 157.93,97.37 157.93,96.9 158.17,96.67 158.17,95.5 158.34,95.33 158.34,93.55 158.88,93.01 158.88,92.6 158.11,91.82 158.11,90.74 158.82,90.03 158.82,88.67 158.21,88.07 158.21,86.69 158.83,86.08 158.83,81.06 158.21,80.45 158.21,78.87 158.85,78.24 158.85,71.71 v1(158.66,71.52)
  BOTTOM w0.102: JDIMM3.122 163.05,67 162.46,67.59 161.97,67.59 161.25,68.31 160.77,68.31 159.8,69.27 159.8,70.32 158.68,71.44 158.68,71.45 158.66,71.47 v1(158.66,71.52)
  BOTTOM w0.198: v1(166.71,137) U1.AN10
M_B_A8: length 90.8
  TOP w0.102: JDIMM4.125 162.1,67.24 161.94,67.4 161.94,67.53 161.81,67.65 160.95,67.65 160.83,67.77 160.83,67.94 160.95,68.06 161.81,68.06 161.94,68.19 161.94,68.42 161.84,68.52 161.57,68.52 161.45,68.64 161.45,68.81 161.57,68.92 161.84,68.92 161.94,69.03 161.94,69.65 161.81,69.78 161.55,69.78 161.43,69.65 161.43,69.22 v1(160.94,68.73)
  IN10 w0.076: v1(166.71,135.7) 166.71,135.66 166.27,135.23 166.27,134.84 165.15,133.71 165.15,129.95 164.64,129.44 164.64,125.07 164.13,124.57 164.13,121.82 163.29,120.98 162.07,120.98 161.97,120.88
  IN10 w0.175: 161.97,120.88 160.83,119.74 160.83,116.31 158.69,114.17 158.69,95.87 158.87,95.69 158.87,93.6 159.36,93.12 159.36,92.51 158.49,91.64 158.49,90.97 159.36,90.1 159.36,88.5 158.67,87.81 158.67,86.8 159.28,86.18 159.28,80.83 158.67,80.22 158.67,79 159.36,78.31 159.36,69.24 159.86,68.73 v1(160.94,68.73)
  BOTTOM w0.076: U1.AN8 v1(166.71,135.7)
  BOTTOM w0.102: JDIMM3.125 163.8,73.55 163.55,73.3 163.12,73.3 162.44,72.62 161.86,72.62 160.94,71.7 160.79,71.7 160.43,71.34 160.43,69.24 v1(160.94,68.73)
M_B_A9: length 90.5
  TOP w0.102: v1(158.66,69.59) 159.13,70.06 159.13,71.23 159.3,71.4 159.92,71.4 160.17,71.16 160.17,70.29 160.5,69.96 160.5,67.64 161.1,67.04 JDIMM4.121
  IN10 w0.076: 162.55,123.27 162.55,125.94 163.42,126.8 163.42,129.09 164.61,130.28 164.61,133.83 165.57,134.78 165.57,135.47 165.42,135.62 165.42,136.74 165.35,136.81 165.35,137.19 v1(164.88,137.65)
  IN10 w0.175: v1(158.66,69.59) 158.22,69.59 157.83,69.98 157.83,73.55 157.32,74.06 157.32,94.67 156.7,95.29 156.7,114.68 158.99,116.96 158.99,119.7 162.55,123.27
  BOTTOM w0.102: v1(158.66,69.59) 158.23,70.02 158.23,71.67 158.49,71.93 160.45,71.93 160.56,72.04 160.79,72.04 161.71,72.96 162.25,72.96 162.8,73.51 JDIMM3.121
  BOTTOM w0.198: v1(164.88,137.65) U1.AR11
M_B_A10_AP: length 87.8
  TOP w0.102: JDIMM4.146 169.35,75.44 169.07,75.72 168.45,75.72 168.22,75.49 168.22,74.1 169.36,72.95 169.36,72.05 v1(169.45,71.96)
  IN10 w0.076: 171.06,121.59 170.89,121.77 170.89,130.79 170.37,131.31 v1(170.37,135.05)
  IN10 w0.175: v1(169.45,71.96) 169.45,74.51 169.18,74.78 168.63,74.78 168.29,75.11 168.29,75.44 168.52,75.67 168.75,75.67 169,75.92 169,90.63 170.09,91.71 170.09,93.06 170.38,93.35 170.38,93.8 170.55,93.98 170.8,93.98 170.98,94.15 170.98,94.5 170.8,94.68 170.44,94.68 170.31,94.8 170.31,95.25 170.44,95.38 170.98,95.38 171.1,95.51 171.1,95.95 170.98,96.08 170.44,96.08 170.31,96.21 170.31,96.65 170.44,96.78 170.98,96.78 171.1,96.91 171.1,97.35 170.98,97.48 170.44,97.48 170.31,97.61 170.31,98.17 170.44,98.3 170.94,98.3 171.06,98.43 171.06,105.14 171.24,105.31 171.73,105.31 171.91,105.49 171.91,105.84 171.73,106.02 171.24,106.02 171.06,106.19 171.06,106.54 171.24,106.72 171.73,106.72 171.91,106.89 171.91,107.24 171.73,107.42 171.24,107.42 171.06,107.59 171.06,107.94 171.24,108.12 171.73,108.12 171.91,108.29 171.91,108.64 171.73,108.82 171.24,108.82 171.06,108.99 171.06,109.34 171.24,109.52 171.73,109.52 171.91,109.7 171.91,110.05 171.73,110.22 171.24,110.22 171.06,110.4 171.06,121.59
  BOTTOM w0.102: JDIMM3.146 171.05,66.93 170.25,67.74 170.25,71.16 v1(169.45,71.96)
  BOTTOM w0.198: U1.AH7 v1(170.37,135.05)
M_B_A11: length 91
  TOP w0.102: v1(158.66,70.23) 158.19,70.23 158.02,70.4 158.02,71.46 158.69,72.13 159.43,72.13 160.85,73.55 JDIMM4.120
  IN10 w0.076: 163.19,121.69 163.52,122.03 163.52,126.04 163.62,126.14 163.62,129.01 164.78,130.17 164.78,133.78 165.84,134.84 165.84,135.29 166.18,135.62 166.18,136.79 166.26,136.88 166.26,137.2 v1(166.71,137.65)
  IN10 w0.175: v1(158.66,70.23) 158.63,70.2 158.38,70.2 158.21,70.37 158.21,71.86 158.44,72.09 158.44,74.69 158.26,74.87 157.93,74.87 157.75,75.04 157.75,75.39 157.93,75.57 158.26,75.57 158.44,75.74 158.44,77.88 157.75,78.57 157.75,80.72 158.36,81.33 158.36,85.83 157.75,86.44 157.75,88.27 158.41,88.93 158.41,89.72 157.7,90.43 157.7,92.05 158.34,92.69 158.34,92.99 157.83,93.5 157.83,94.97 157.42,95.39 157.42,96.61 157.22,96.81 157.22,97.31 157.42,97.51 157.42,98.02 157.22,98.21 157.22,98.72 157.42,98.91 157.42,99.42 157.22,99.61 157.22,100.12 157.42,100.31 157.42,100.82 157.22,101.01 157.22,101.52 157.42,101.71 157.42,102.22 157.22,102.42 157.22,102.92 157.42,103.12 157.42,103.62 157.22,103.82 157.22,104.33 157.42,104.52 157.42,105.03 157.22,105.22 157.22,105.73 157.42,105.92 157.42,106.43 157.22,106.62 157.22,107.13 157.42,107.32 157.42,107.83 157.22,108.02 157.22,108.53 157.42,108.72 157.42,109.23 157.22,109.43 157.22,109.93 157.42,110.13 157.42,110.63 157.22,110.83 157.22,111.34 157.42,111.53 157.42,112.04 157.22,112.23 157.22,112.74 157.42,112.93 157.42,113.44 157.22,113.63 157.22,114.23 159.61,116.61 159.61,119.84 161.46,121.69 163.19,121.69
  BOTTOM w0.102: JDIMM3.120 162.55,67 162.3,67.25 161.83,67.25 161.11,67.96 160.62,67.96 159.42,69.17 159.42,69.59 158.81,70.2 158.68,70.2 v1(158.66,70.23)
  BOTTOM w0.198: v1(166.71,137.65) U1.AN11
M_B_A12: length 93.7
  TOP w0.102: v1(158.66,68.32) 158.84,68.32 159.31,68.8 159.69,68.8 159.81,68.92 159.81,69.09 159.69,69.2 159.26,69.2 159.15,69.31 159.15,69.53 159.46,69.84 159.46,70.37 159.57,70.49 159.74,70.49 159.86,70.37 159.86,70.08 160.19,69.75 160.19,68.31 160.09,68.21 159.55,68.21 159.43,68.09 159.43,67.92 159.55,67.81 159.88,67.81 160.6,67.08 JDIMM4.119
  IN10 w0.076: v1(164.88,137) 165.26,136.62 165.26,135.55 165.42,135.4 165.42,134.85 164.41,133.84 164.41,130.33 163.19,129.11 163.19,127.03 162.22,126.06 162.22,123.45
  IN10 w0.175: 162.22,123.45 158.34,119.56 158.34,117.22 156.19,115.07 156.19,94.97 156.92,94.23 156.92,73.7 157.46,73.16 157.46,69.52 v1(158.66,68.32)
  BOTTOM w0.102: JDIMM3.119 162.3,73.58 162.02,73.3 161.57,73.3 160.65,72.38 160.3,72.38 160.15,72.23 158.36,72.23 157.91,71.78 157.91,69.07 v1(158.66,68.32)
  BOTTOM w0.198: v1(164.88,137) U1.AR10
M_B_A13: length 88
  TOP w0.102: v1(173.23,70.69) 172.97,70.69 172.35,71.31 172.35,72.71 172.45,72.81 172.74,72.81 172.84,72.91 172.84,73.12 172.74,73.22 172.45,73.22 172.35,73.32 JDIMM4.158
  IN10 w0.076: 173.58,125.33 173.02,125.89 173.02,131.08 172.58,131.52 172.58,133.2 172.58,133.2 172.58,134.23 172.58,134.19 172.58,134.75 172.58,134.75 172.58,135.97 v1(172.2,136.35)
  IN10 w0.175: v1(173.23,70.69) 172.92,70.69 172.78,70.83 172.78,73.58 173.37,74.16 173.37,74.4 173.49,74.53 173.81,74.53 173.93,74.65 173.93,74.96 173.81,75.09 173.53,75.09 173.41,75.21 173.41,78.21 173.58,78.39 173.98,78.39 174.11,78.51 174.11,78.77 173.98,78.9 173.58,78.9 173.43,79.04 173.43,79.35 173.56,79.48 173.98,79.48 174.11,79.61 174.11,79.96 173.98,80.09 173.58,80.09 173.43,80.24 173.43,80.45 173.81,80.83 174.31,80.83 174.44,80.95 174.44,81.43 174.31,81.56 173.79,81.56 173.66,81.69 173.66,85.92 173.84,86.1 174.27,86.1 174.44,86.27 174.44,86.62 174.27,86.8 173.84,86.8 173.66,86.97 173.66,87.32 173.84,87.5 174.27,87.5 174.44,87.67 174.44,88.02 174.27,88.2 173.84,88.2 173.66,88.37 173.66,90.51 175.61,92.46 175.61,93.68 176.08,94.15 176.08,94.89 176.3,95.1 176.62,95.1 176.83,95.3 176.83,95.76 176.65,95.93 176.14,95.93 175.97,96.11 175.97,96.46 176.14,96.63 176.65,96.63 176.83,96.81 176.83,110.84 175.12,112.55 175.12,121.58 173.58,123.12 173.58,125.33
  BOTTOM w0.102: JDIMM3.158 174.05,67.12 174.14,67.21 174.14,69.78 v1(173.23,70.69)
  BOTTOM w0.198: U1.AF9 v1(172.2,136.35)
M_B_A14_WE_N: length 85.3
  TOP w0.102: v1(171.1,71.33) 171.32,71.33 171.53,71.12 171.53,67.9 170.6,66.97 JDIMM4.151
  IN10 w0.076: v1(170.37,137.65) 170.56,137.65 170.9,137.31 170.9,135.64 171.09,135.46 171.09,134.8 170.83,134.54 170.83,131.56 171.42,130.97 171.42,122.51 172.63,121.29
  IN10 w0.175: 172.63,121.29 172.63,111.52 173.46,110.69 173.46,99.25 173.29,99.07 172.89,99.07 172.71,98.89 172.71,98.54 172.89,98.37 173.29,98.37 173.46,98.19 173.46,97.84 173.29,97.67 172.89,97.67 172.71,97.49 172.71,97.14 172.89,96.97 173.29,96.97 173.46,96.79 173.46,96.44 173.29,96.27 172.89,96.27 172.71,96.09 172.71,95.74 172.89,95.56 173.29,95.56 173.46,95.39 173.46,94.95 172.97,94.46 172.97,92.61 171.06,90.71 171.06,81.61 170.15,80.7 170.15,75.96 170.66,75.45 170.66,71.64 170.97,71.33 v1(171.1,71.33)
  BOTTOM w0.102: v1(171.1,71.33) 171.53,71.33 171.67,71.18 171.67,70.49 171.8,70.36 172.03,70.36 172.16,70.49 172.16,72.83 172.3,72.96 JDIMM3.151
  BOTTOM w0.198: v1(170.37,137.65) U1.AH11
M_B_A15_CAS_N: length 89.9
  TOP w0.102: v1(173.23,68.79) 173.18,68.79 171.99,69.97 171.99,70.87 171.85,71.01 JDIMM4.156
  IN10 w0.076: v1(172.2,135.71) 171.82,135.33 171.82,134.91 172.12,134.6 172.12,131.32 172.61,130.83 172.61,125.56 172.87,125.3 172.87,122.63 174.12,121.39
  IN10 w0.175: 174.12,121.39 174.12,112.13 175.82,110.42 175.82,101.6 174.94,100.72 174.94,94.92 174.89,94.86 174.89,92.83 172.94,90.88 172.94,88.54 172.77,88.36 172.53,88.36 172.36,88.19 172.36,87.84 172.53,87.66 172.77,87.66 172.94,87.48 172.94,87.13 172.77,86.96 172.53,86.96 172.36,86.78 172.36,86.43 172.53,86.26 172.77,86.26 172.94,86.08 172.94,81.43 171.99,80.48 171.99,68.98 172.44,68.53 172.44,66.75 172.56,66.63 173.1,66.63 173.23,66.75 v1(173.23,68.79)
  BOTTOM w0.102: v1(173.23,68.79) 173.68,68.79 173.81,68.66 173.81,68.48 173.68,68.35 172.97,68.35 172.85,68.24 172.85,68.07 172.97,67.95 173.73,67.95 173.83,67.84 173.83,67.7 173.73,67.59 172.96,67.59 172.85,67.49 172.85,67.34 172.96,67.23 173.42,67.23 173.55,67.1 JDIMM3.156
  BOTTOM w0.198: U1.AF8 v1(172.2,135.71)
M_B_A16_RAS_N: length 85.7
  TOP w0.102: v1(171.1,70.06) 170.68,70.48 170.68,73.06 170.85,73.24 JDIMM4.152
  IN10 w0.076: 172.11,121.35 171.24,122.23 171.24,130.9 170.67,131.46 170.67,134.6 170.92,134.85 170.92,135.4 170.75,135.57 170.75,136.73 170.48,137 v1(170.37,137)
  IN10 w0.175: 172.11,121.35 172.11,111.3 172.94,110.48 172.94,99.88 172.82,99.75 172.27,99.75 172.14,99.62 172.14,94.93 172.05,94.85 172.05,94.34 172.18,94.21 172.41,94.21 172.54,94.08 172.54,93.35 172.41,93.22 172.18,93.22 172.05,93.1 172.05,92.43 169.8,90.18 169.8,88.33 169.95,88.18 170.46,88.18 170.63,88 170.63,87.65 170.46,87.48 169.95,87.48 169.77,87.3 169.77,86.95 169.95,86.78 170.46,86.78 170.63,86.6 170.63,86.25 170.46,86.07 169.95,86.07 169.77,85.9 169.77,85.23 169.95,85.05 169.98,85.05 170.15,84.88 170.15,84.53 169.98,84.35 169.95,84.35 169.77,84.18 169.77,83.83 169.95,83.65 169.98,83.65 170.15,83.48 170.15,83.13 169.98,82.95 169.95,82.95 169.77,82.78 169.77,82.42 169.95,82.25 169.98,82.25 170.15,82.07 170.15,81.72 169.98,81.55 169.95,81.55 169.77,81.37 169.77,75.49 170.28,74.98 170.28,71.35 170.63,71 170.63,70.54 170.28,70.19 170.28,69.85 170.48,69.65 170.7,69.65 v1(171.1,70.06)
  BOTTOM w0.102: v1(171.1,70.06) 171.22,70.06 172.55,68.72 JDIMM3.152
  BOTTOM w0.198: U1.AH10 v1(170.37,137)
M_B_ACT_N: length 88.8
  TOP w0.102: JDIMM4.114 159.35,73.28 158.94,72.88 157.8,72.88 157.67,72.75 157.39,72.75 157.31,72.83 157.13,72.83 156.94,72.64 156.94,72.46 157.08,72.32 157.08,72.11 156.98,72.01 156.86,72.01 156.77,71.92 156.77,71.73 156.89,71.61 156.98,71.61 157.08,71.5 157.08,71.3 156.98,71.2 156.89,71.2 156.79,71.1 156.79,70.89 156.89,70.79 156.98,70.79 157.08,70.69 157.08,70.49 156.98,70.39 156.89,70.39 156.79,70.29 156.79,69.88 156.66,69.75 v1(156.37,69.75)
  IN10 w0.076: v1(163.97,136.35) 164.35,135.97 164.35,134.91 164.04,134.6 163.6,134.6 162.85,133.85 162.85,131.64 161.87,130.66 161.87,129.77 161.11,129.01 161.11,124.49 160.93,124.31
  IN10 w0.175: v1(156.37,69.75) 156.37,69.76 155.48,70.65 155.48,72.34 154.76,73.06 154.76,93.36 154.11,94 154.11,116.2 156.05,118.14 156.05,119.43 160.93,124.31
  BOTTOM w0.102: v1(156.37,69.75) 155.96,69.35 155.96,68.31 156.66,67.61 160,67.61 160.34,67.28 160.74,67.28 161.05,66.97 JDIMM3.114
  BOTTOM w0.198: U1.AT9 v1(163.97,136.35)
M_B_BA0: length 87.6
  TOP w0.102: v1(171.1,69.42) 170.22,70.3 170.22,73.1 170.35,73.23 JDIMM4.150
  IN10 w0.076: v1(170.37,135.7) 170.74,135.33 170.74,134.88 170.52,134.67 170.52,131.39 171.06,130.85 171.06,121.97 171.6,121.44
  IN10 w0.175: v1(171.1,69.42) 170.95,69.27 170.56,69.27 170.43,69.14 170.43,68 170.3,67.87 170.03,67.87 169.9,68 169.9,74.75 169.39,75.26 169.39,90.38 171.62,92.61 171.62,100.21 171.8,100.39 172.25,100.39 172.42,100.56 172.42,100.92 172.25,101.09 171.8,101.09 171.62,101.27 171.62,101.62 171.8,101.79 172.25,101.79 172.42,101.97 172.42,102.32 172.25,102.49 171.8,102.49 171.62,102.67 171.62,103.02 171.8,103.19 172.25,103.19 172.42,103.37 172.42,103.72 172.25,103.89 171.8,103.89 171.62,104.07 171.62,104.37 172.42,105.17 172.42,110.26 171.6,111.09 171.6,121.44
  BOTTOM w0.102: JDIMM3.150 172.05,67.06 172.23,67.24 172.23,67.47 172.13,67.57 171.53,67.57 171.41,67.69 171.41,67.86 171.53,67.98 172.13,67.98 172.23,68.08 172.23,68.61 171.42,69.42 v1(171.1,69.42)
  BOTTOM w0.198: v1(170.37,135.7) U1.AH8
M_B_BA1: length 88
  TOP w0.102: v1(169.45,70.69) 169.58,70.82 169.75,70.82 169.88,70.69 169.88,68.52 169.1,67.74 169.1,67.47 169.23,67.34 169.23,67.19 169.1,67.06 JDIMM4.145
  IN10 w0.076: v1(170.37,136.35) 169.99,135.97 169.99,134.87 170.17,134.68 170.17,131.29 170.71,130.76 170.71,121.97 170.53,121.8
  IN10 w0.175: v1(169.45,70.69) 169.16,70.69 169.01,70.84 169.01,74.2 168.88,74.32 168.42,74.32 167.91,74.83 167.91,77.93 168.09,78.1 168.27,78.1 168.45,78.28 168.45,78.63 168.27,78.8 168.09,78.8 167.91,78.98 167.91,79.45 168.09,79.63 168.3,79.63 168.47,79.8 168.47,80.15 168.3,80.33 167.91,80.33 167.74,80.5 167.74,80.85 167.91,81.03 168.3,81.03 168.47,81.2 168.47,81.55 168.3,81.73 168.09,81.73 167.91,81.9 167.91,86.06 168.09,86.23 168.4,86.23 168.57,86.41 168.57,86.76 168.4,86.93 167.78,86.93 167.61,87.11 167.61,87.46 167.78,87.63 168.4,87.63 168.57,87.81 168.57,88.16 168.4,88.33 168.09,88.33 167.91,88.51 167.91,90.25 169.64,91.98 169.64,93.53 169.79,93.68 169.79,99.02 169.97,99.2 170.37,99.2 170.55,99.37 170.55,99.72 170.37,99.9 169.97,99.9 169.79,100.07 169.79,100.42 169.97,100.6 170.37,100.6 170.55,100.77 170.55,101.12 170.37,101.3 169.97,101.3 169.79,101.47 169.79,101.82 169.97,102 170.37,102 170.55,102.18 170.55,102.53 170.37,102.7 169.97,102.7 169.79,102.88 169.79,103.18 170.53,103.91 170.53,121.8
  BOTTOM w0.102: v1(169.45,70.69) 169.07,70.69 168.87,70.89 168.87,72.4 169.58,73.1 170.47,73.1 170.8,73.44 JDIMM3.145
  BOTTOM w0.198: v1(170.37,136.35) U1.AH9
M_B_BG0: length 87
  TOP w0.102: v1(156.37,71.02) 155.96,70.62 155.96,68.29 156.33,67.92 158.71,67.92 159.6,67.02 JDIMM4.115
  IN10 w0.076: v1(164.88,136.35) 164.5,135.97 164.5,134.74 164.11,134.34 163.6,134.34 163.09,133.84 163.09,131.42 162.2,130.53 162.2,129.72 161.28,128.81 161.28,124.11 161.25,124.07
  IN10 w0.175: v1(156.37,71.02) 155.91,71.48 155.91,72.6 155.16,73.34 155.16,93.63 154.63,94.16 154.63,115.96 156.63,117.96 156.63,119.46 161.25,124.07
  BOTTOM w0.102: JDIMM3.115 161.3,73.52 160.51,72.73 160.15,72.73 159.97,72.54 158.23,72.54 157.6,71.91 157.6,70.82 157.27,70.49 156.9,70.49 v1(156.37,71.02)
  BOTTOM w0.198: v1(164.88,136.35) U1.AR9
M_B_BG1: length 88.6
  TOP w0.102: v1(156.37,72.29) 155.66,71.58 155.66,68.11 156.15,67.61 158.49,67.61 159.1,67 JDIMM4.113
  IN10 w0.076: v1(164.88,135.05) 164.88,134.83 164.23,134.17 163.65,134.17 163.32,133.84 163.32,131.14 162.76,130.58 162.76,127.51 161.69,126.44 161.69,123.96
  IN10 w0.175: v1(156.37,72.29) 156.37,72.98 156.1,73.25 156.1,78.76 155.93,78.93 155.85,78.93 155.67,79.11 155.67,79.46 155.85,79.63 155.93,79.63 156.1,79.81 156.1,80.16 155.93,80.33 155.85,80.33 155.67,80.51 155.67,80.86 155.85,81.03 155.93,81.03 156.1,81.21 156.1,85.97 155.93,86.15 155.9,86.15 155.72,86.32 155.72,86.67 155.9,86.85 155.93,86.85 156.1,87.02 156.1,87.37 155.93,87.55 155.9,87.55 155.72,87.72 155.72,88.08 155.9,88.25 155.93,88.25 156.1,88.43 156.1,91.12 155.93,91.29 155.85,91.29 155.67,91.47 155.67,91.82 155.85,92 155.93,92 156.1,92.17 156.1,93.43 155.15,94.38 155.15,115.74 157.2,117.78 157.2,119.46 161.69,123.96
  BOTTOM w0.102: JDIMM3.113 160.8,73.5 160.61,73.31 160.23,73.31 159.85,72.93 158.13,72.93 157.88,72.67 157.73,72.67 157.66,72.74 157.49,72.74 157.37,72.62 157.37,72.45 157.45,72.38 157.45,72.24 157.28,72.08 157.28,71.05 157.16,70.93 156.94,70.93 156.81,71.05 156.81,72.53 156.69,72.66 156.56,72.66 156.37,72.47 v1(156.37,72.29)
  BOTTOM w0.198: U1.AR7 v1(164.88,135.05)
M_B_DIM0_CK_DDR0_DN: length 81.9
  IN10 w0.076: v1(166.71,136.35) 167.09,135.97 167.09,134.51 167.15,134.46 167.15,134.36 167.13,134.34 167.13,134.33 167.13,134.32
  IN10 w0.107: v1(165.65,69.24) 165.65,69.36 165.52,69.49 165.34,69.49 165.21,69.36 165.21,68.24 164.78,67.81 164.22,67.81 163.16,68.87 163.16,72.04 162.03,73.17 162.03,94.89 162.39,95.25 162.39,113.72 164.13,115.45 164.13,119.72 165.1,120.7 166.11,121.71 166.11,130.89 167.22,132 167.22,132.52 167.55,132.85 167.55,133.9 167.13,134.32
  BOTTOM w0.076: v1(166.71,136.35) U1.AN9
  BOTTOM w0.102: JDIMM3.139 167.3,70.13 166.82,69.65 166.06,69.65 165.65,69.24 v1(165.65,69.24)
M_B_DIM0_CK_DDR0_DP: length 81.9
  IN10 w0.076: 167.32,134.51 167.3,134.52 167.25,134.58 167.25,136.03 167.13,136.15 167.13,136.35 167.28,136.5 167.48,136.5 v1(167.63,136.35)
  IN10 w0.107: 167.32,134.51 167.81,134.01 167.81,132.74 167.48,132.41 167.48,131.89 166.37,130.78 166.37,121.6 164.39,119.61 164.39,115.35 162.65,113.61 162.65,95.15 162.29,94.78 162.29,73.28 163.42,72.15 163.42,68.98 164.33,68.07 164.67,68.07 164.95,68.35 164.95,69.47 165.23,69.75 165.52,69.75 v1(165.65,69.88)
  BOTTOM w0.076: U1.AM9 v1(167.63,136.35)
  BOTTOM w0.102: v1(165.65,69.88) 165.65,70 165.77,70.13 166.1,70.13 166.3,69.93 166.71,69.93 167.02,70.24 167.02,70.84 166.85,71.01 166.85,71.5 167.02,71.67 167.02,72.16 166.85,72.33 166.85,72.8 167.02,72.97 167.02,73.31 166.8,73.53 JDIMM3.137
M_B_DIM0_CK_DDR1_DN: length 83.8
  IN10 w0.076: v1(167.63,135.7) 167.65,135.7 168.24,135.11 168.24,134.34
  IN10 w0.107: 168.24,134.34 168.32,134.27 168.32,132.49 167.94,132.11 167.94,131.34 167.59,130.99 167.59,121.88 165.35,119.64 165.35,114.53 164.98,114.17 164.44,114.17 163.52,113.25 163.52,112.36 163.76,112.12 163.76,111.37 163.52,111.14 163.52,110.56 163.76,110.32 163.76,109.57 163.52,109.34 163.52,108.76 163.76,108.52 163.76,107.77 163.52,107.54 163.52,106.96 163.76,106.72 163.76,105.98 163.52,105.74 163.52,105.16 163.76,104.93 163.76,104.18 163.52,103.94 163.52,103.36 163.76,103.13 163.76,102.38 163.52,102.14 163.52,101.57 163.76,101.33 163.76,100.58 163.52,100.35 163.52,99.77 163.76,99.53 163.76,98.78 163.52,98.55 163.52,97.97 163.76,97.73 163.76,97.15 163.55,96.94 163.55,96.31 163.76,96.1 163.76,94.85 163.48,94.57 163.48,94.29 163.17,93.98 163.17,93.34 163.48,93.02 163.48,92.61 163.17,92.29 163.17,91.83 163.48,91.52 163.48,90.96 163.17,90.65 163.17,90.29 163.48,89.98 163.48,88.51 163.25,88.28 163.25,87.88 163.48,87.65 163.48,87.01 163.19,86.72 163.19,86.19 163.48,85.9 163.48,81.39 163.16,81.07 163.16,80.82 163.48,80.5 163.48,80.02 163.16,79.7 163.16,79.45 163.39,79.23 163.39,75.95 163.04,75.61 163.04,73.62 164.06,72.6 164.06,69.63 164.19,69.51 164.37,69.51 164.5,69.63 v1(164.5,69.75)
  BOTTOM w0.076: U1.AM8 v1(167.63,135.7)
  BOTTOM w0.102: JDIMM3.140 167.55,66.97 167.37,67.15 167.37,67.29 167.47,67.39 168.16,67.39 168.42,67.65 168.42,68.1 168.16,68.35 167.47,68.35 167.38,68.45 167.38,69.02 167.09,69.31 166.4,69.31 166.11,69.02 166.11,68.33 165.98,68.2 165.34,68.2 165.21,68.33 165.21,69.35 164.92,69.65 164.6,69.65 v1(164.5,69.75)
M_B_DIM0_CK_DDR1_DP: length 83.9
  IN10 w0.076: 168.06,134.16 168.05,134.17 168.05,134.18 168.08,134.2 168.08,134.41 168.09,134.43 168.09,135.04 167.88,135.26 167.75,135.26 167.63,135.13 v1(167.63,135.05)
  IN10 w0.107: v1(164.5,69.12) 164.37,69.25 164.08,69.25 163.8,69.53 163.8,72.49 162.78,73.51 162.78,75.71 163.13,76.06 163.13,79.12 162.9,79.34 162.9,79.81 163.22,80.13 163.22,80.4 162.9,80.72 162.9,81.18 163.22,81.5 163.22,85.8 162.94,86.08 162.94,86.83 163.22,87.11 163.22,87.54 162.99,87.78 162.99,88.38 163.22,88.62 163.22,89.87 162.91,90.18 162.91,90.76 163.22,91.07 163.22,91.41 162.91,91.72 162.91,92.4 163.22,92.71 163.22,92.92 162.91,93.23 162.91,94.09 163.22,94.4 163.22,94.68 163.5,94.96 163.5,95.99 163.29,96.2 163.29,97.05 163.5,97.26 163.5,97.63 163.26,97.86 163.26,98.65 163.5,98.89 163.5,99.42 163.26,99.66 163.26,100.45 163.5,100.69 163.5,101.22 163.26,101.46 163.26,102.25 163.5,102.49 163.5,103.02 163.26,103.26 163.26,104.05 163.5,104.29 163.5,104.82 163.26,105.06 163.26,105.85 163.5,106.08 163.5,106.62 163.26,106.85 163.26,107.65 163.5,107.88 163.5,108.42 163.26,108.65 163.26,109.44 163.5,109.68 163.5,110.21 163.26,110.45 163.26,111.24 163.5,111.48 163.5,112.01 163.26,112.25 163.26,113.36 164.33,114.42 164.87,114.42 165.09,114.64 165.09,119.75 165.57,120.23 167.33,121.99 167.33,131.09 167.69,131.45 167.69,132.22 168.06,132.6 168.06,134.16 168.06,134.16
  BOTTOM w0.076: v1(167.63,135.05) 167.46,135.05 167.17,134.76 U1.AM7
  BOTTOM w0.102: v1(164.5,69.12) 164.5,69.24 164.62,69.37 164.8,69.37 164.93,69.24 164.93,68.21 165.22,67.92 166.1,67.92 166.39,68.21 166.39,68.9 166.52,69.03 166.97,69.03 167.1,68.9 167.1,68.33 167.36,68.08 168.05,68.08 168.14,67.98 168.14,67.76 168.05,67.67 166.97,67.67 166.85,67.54 166.85,67.34 167.05,67.14 JDIMM3.138
M_B_DIM0_CKE0: length 83.6
  IN10 w0.076: 160.47,124.9 160.75,125.17 160.75,131.78 162.28,133.3 162.28,133.92 163.74,135.38 163.74,135.47 v1(163.97,135.7)
  IN10 w0.14: 160.47,124.9 155.06,119.48 155.06,119.28 153.13,117.35 153.13,93.99 153.49,93.64 153.49,92.77 153.63,92.63 153.73,92.63 153.85,92.51 153.85,92.2 153.73,92.08 153.63,92.08 153.49,91.94 153.49,91.66 153.63,91.52 153.73,91.52 153.85,91.39 153.85,91.09 153.73,90.96 153.63,90.96 153.49,90.82 153.49,90.54 153.63,90.4 153.73,90.4 153.85,90.27 153.85,89.97 153.73,89.84 153.63,89.84 153.49,89.7 153.49,89.42 153.63,89.28 153.73,89.28 153.85,89.16 153.85,88.85 153.73,88.72 153.63,88.72 153.54,88.63 153.54,76.48 153.79,76.23 153.79,72.29 153.89,72.19 154.17,72.19 154.27,72.09 154.27,71.83 154.17,71.73 153.89,71.73 153.79,71.63 153.79,71.38 153.89,71.28 154.17,71.28 154.27,71.17 154.27,70.89 154.17,70.79 153.89,70.79 153.79,70.69 153.79,70.51 154.24,70.06 154.6,70.06 154.72,70.17 v1(154.72,70.28)
  BOTTOM w0.076: U1.AT8 v1(163.97,135.7)
  BOTTOM w0.102: JDIMM3.109 159.8,73.49 159.61,73.3 155.86,73.3 155.35,72.79 155.35,70.5 155.06,70.2 154.79,70.2 v1(154.72,70.28)
M_B_DIM0_CKE1: length 82.5
  IN10 w0.076: 160.55,125.45 160.55,132.03 162.02,133.51 162.02,133.92 163.59,135.49 163.59,136.62 v1(163.97,137)
  IN10 w0.14: v1(154.72,69.64) 154.13,69.64 153.41,70.36 153.41,73.82 153.27,73.96 153.08,73.96 152.98,74.06 152.98,74.41 153.08,74.51 153.27,74.51 153.41,74.65 153.41,74.93 153.27,75.07 153.08,75.07 152.98,75.17 152.98,75.53 153.08,75.63 153.27,75.63 153.41,75.77 153.41,76.02 153.09,76.34 153.09,93.55 152.63,94.01 152.63,117.54 160.55,125.45
  BOTTOM w0.076: U1.AT10 v1(163.97,137)
  BOTTOM w0.102: v1(154.72,69.64) 154.72,69.58 155.16,69.14 155.16,68.68 156.62,67.23 159.79,67.23 160.05,66.97 JDIMM3.110
M_B_DIM0_CS0_N: length 79.1
  IN10 w0.076: 172.26,124.69 172.28,124.72 172.28,124.92 172.18,125.02 172.18,130.58 171.74,131.03 171.74,134.45 171.44,134.75 171.44,135.4 171.67,135.62 171.67,137.54 171.77,137.65 v1(172.2,137.65)
  IN10 w0.14: v1(171.1,72.6) 171.1,80.9 171.5,81.3 171.5,90.5 173.96,92.97 173.96,103.59 174.1,103.73 174.7,103.73 174.84,103.87 174.84,104.15 174.7,104.29 174.1,104.29 173.96,104.43 173.96,104.71 174.1,104.85 174.7,104.85 174.84,104.99 174.84,105.27 174.7,105.41 174.1,105.41 173.96,105.55 173.96,105.83 174.1,105.97 174.7,105.97 174.84,106.11 174.84,106.38 174.7,106.52 174.1,106.52 173.96,106.66 173.96,106.94 174.1,107.08 174.7,107.08 174.84,107.22 174.84,107.5 174.7,107.64 174.1,107.64 173.96,107.78 173.96,108.06 174.1,108.2 174.7,108.2 174.84,108.34 174.84,108.62 174.7,108.76 174.1,108.76 173.96,108.9 173.96,109.18 174.1,109.32 174.7,109.32 174.84,109.46 174.84,109.74 174.7,109.88 174.1,109.88 173.96,110.02 173.96,110.9 173.13,111.73 173.13,121.3 172.26,122.18 172.26,124.69
  BOTTOM w0.152: U1.AF11 v1(172.2,137.65) ; JDIMM3.149 171.8,73.54 171.1,72.84 v1(171.1,72.6)
M_B_DIM0_CS1_N: length 82.4
  IN10 w0.076: v1(173.11,135.07) 173.11,134.55 172.96,134.39 172.96,131.8 173.4,131.35 173.4,126.29 174.49,125.2 174.49,125.06
  IN10 w0.14: 174.49,125.06 174.49,123.32 176.1,121.71 176.1,117.77 176.83,117.04 176.83,112.23 177.81,111.25 177.81,94.73 176.86,93.79 176.86,92.44 175.31,90.88 175.31,79.92 174.91,79.53 174.91,74.41 173.68,73.18 173.68,68.16 173.82,68.02 174.24,68.02 174.34,67.92 174.34,67.64 174.24,67.54 173.78,67.54 173.68,67.44 173.68,67.14 173.78,67.03 174.57,67.03 175.13,67.6 v1(175.13,68.79)
  BOTTOM w0.102: JDIMM3.157 173.8,70.89 174.7,69.99 174.7,69.22 v1(175.13,68.79)
  BOTTOM w0.152: U1.AE7 v1(173.11,135.07)
M_B_DIM0_ODT0: length 82.2
  IN10 w0.076: v1(172.2,135.08) 172.2,134.85 172.31,134.74 172.31,131.45 172.82,130.94 172.82,125.71 173.12,125.4
  IN10 w0.14: v1(173.23,70.06) 172.9,70.06 172.8,69.96 172.8,69.47 172.7,69.37 172.46,69.37 172.36,69.47 172.36,74.14 172.5,74.28 172.68,74.28 172.82,74.42 172.82,74.7 172.68,74.84 172.5,74.84 172.36,74.98 172.36,75.24 172.49,75.37 172.88,75.37 173.01,75.5 173.01,78.27 172.87,78.41 172.7,78.41 172.56,78.55 172.56,78.83 172.7,78.97 172.87,78.97 173.01,79.11 173.01,79.39 172.87,79.53 172.7,79.53 172.56,79.67 172.56,79.95 172.7,80.09 172.82,80.09 172.94,80.22 172.94,80.62 173.3,80.98 173.3,90.73 175.25,92.68 175.25,94.21 175.44,94.4 175.44,97.17 175.58,97.31 176.19,97.31 176.33,97.45 176.33,97.73 176.19,97.87 175.58,97.87 175.44,98.01 175.44,98.29 175.58,98.43 176.19,98.43 176.33,98.57 176.33,98.85 176.19,98.99 175.58,98.99 175.44,99.13 175.44,99.41 175.58,99.55 176.19,99.55 176.33,99.69 176.33,99.97 176.19,100.11 175.58,100.11 175.44,100.25 175.44,100.51 175.65,100.71 176.07,100.71 176.33,100.97 176.33,110.63 174.62,112.34 174.62,121.49 173.12,122.99 173.12,125.4
  BOTTOM w0.102: v1(173.23,70.06) 172.75,70.53 172.75,72.22 173.3,72.76 JDIMM3.155
  BOTTOM w0.152: U1.AF7 v1(172.2,135.08)
M_B_DIM0_ODT1: length 82.7
  IN10 w0.076: 174.92,125.16 173.58,126.5 173.58,131.51 173.11,131.97 173.11,134.33 173.32,134.54 173.32,134.74 173.49,134.91 173.49,135.32 v1(173.11,135.7)
  IN10 w0.14: 174.92,125.16 174.92,123.45 176.58,121.79 176.58,117.97 177.31,117.24 177.31,112.43 178.29,111.45 178.29,94.16 178.19,94.06 177.92,94.06 177.82,93.96 177.82,93.73 177.92,93.63 178.07,93.63 178.18,93.53 178.18,93.32 178.07,93.22 177.62,93.22 177.52,93.11 177.52,92.59 175.75,90.82 175.75,88.54 175.89,88.4 176.52,88.4 176.63,88.3 176.63,87.95 176.52,87.84 175.89,87.84 175.75,87.7 175.75,87.42 175.89,87.29 176.52,87.29 176.63,87.18 176.63,86.83 176.52,86.73 175.89,86.73 175.75,86.59 175.75,79.88 175.32,79.45 175.32,74.27 174.02,72.97 174.02,68.66 174.12,68.56 174.61,68.56 174.71,68.66 174.71,69.96 174.81,70.06 v1(175.13,70.06)
  BOTTOM w0.102: JDIMM3.161 174.8,72.48 174.7,72.39 174.7,70.49 v1(175.13,70.06)
  BOTTOM w0.152: U1.AE8 v1(173.11,135.7)
M_B_DIM1_CK_DDR2_DN: length 84.9
  TOP w0.102: JDIMM4.139 165.6,67.14 165.5,67.24 165.44,67.24 165.38,67.3 165.38,67.66 165.59,67.87 166.14,67.87 166.44,68.18 166.44,71.4 166.57,71.53 166.87,71.53 167,71.4 167,68.61 167.13,68.48 167.66,68.48 167.79,68.61 v1(167.79,68.79)
  IN10 w0.076: v1(167.63,137) 167.88,137 168.01,136.88 168.01,135.58 168.48,135.11 168.48,134.69 169.24,133.94 169.24,131.49 168.82,131.07
  IN10 w0.107: 168.82,131.07 168.62,130.87 168.62,121.29 167.48,120.15 167.48,108.56 166.05,107.14 166.05,106.36 165.92,106.23 165.92,105.23 166.05,105.1 166.05,104.56 165.92,104.43 165.92,103.34 166.07,103.19 166.07,102.44 165.92,102.29 165.92,93.67 165.86,93.61 165.86,92.04 165.25,91.44 165.25,90.58 164.99,90.32 164.99,89.64 165.25,89.38 165.25,88.61 164.94,88.3 164.94,87.8 165.25,87.49 165.25,87.13 164.97,86.85 164.97,86.19 165.25,85.91 165.25,82.08 164.97,81.8 164.97,81 165.25,80.72 165.25,79.89 164.99,79.62 164.99,78.36 165.25,78.1 165.25,75.88 165.02,75.64 165.02,74.3 165.83,73.49 165.83,71.57 166.61,70.79 166.61,69.62 167.12,69.11 167.69,69.11 167.79,69.02 v1(167.79,68.79)
  BOTTOM w0.102: U1.AM10 v1(167.63,137)
M_B_DIM1_CK_DDR2_DP: length 84.9
  TOP w0.102: v1(167.8,69.62) 167.8,69.3 167.67,69.18 167.41,69.18 167.28,69.3 167.28,71.52 166.99,71.81 166.45,71.81 166.16,71.52 166.16,68.29 166.02,68.15 165.48,68.15 165.1,67.78 JDIMM4.137
  IN10 w0.076: v1(167.63,137.65) 168.16,137.12 168.16,135.64 168.63,135.17 168.63,134.76 169.39,134 169.39,131.4 169.01,131.02 169.01,130.89
  IN10 w0.107: v1(167.8,69.62) 167.8,69.5 167.67,69.37 167.23,69.37 166.87,69.73 166.87,70.89 166.09,71.68 166.09,73.6 165.28,74.41 165.28,75.54 165.51,75.77 165.51,78.21 165.25,78.47 165.25,79.52 165.51,79.78 165.51,80.82 165.23,81.11 165.23,81.69 165.51,81.98 165.51,86.01 165.23,86.3 165.23,86.74 165.51,87.03 165.51,87.6 165.2,87.91 165.2,88.19 165.51,88.5 165.51,89.49 165.25,89.75 165.25,90.21 165.51,90.47 165.51,91.33 166.12,91.93 166.12,93.5 166.18,93.56 166.18,102.18 166.33,102.33 166.33,103.3 166.18,103.44 166.18,104.32 166.31,104.46 166.31,105.21 166.25,105.27 166.18,105.34 166.18,106.12 166.31,106.26 166.31,107.03 167.74,108.45 167.74,120.04 168.88,121.18 168.88,130.76 169.01,130.89
  BOTTOM w0.102: U1.AM11 v1(167.63,137.65)
M_B_DIM1_CK_DDR3_DN: length 86.2
  TOP w0.102: JDIMM4.140 165.85,72.96 165.18,72.29 165.18,71.45 165.28,71.35 165.43,71.35 165.53,71.45 165.53,72.01 166.44,72.93 168.23,72.93 168.52,72.64 168.52,71.29 168.23,71 167.91,71 v1(167.8,70.89)
  IN10 w0.076: 169.75,130.25 169.75,130.26 169.79,130.3 169.79,130.75 169.56,130.98 169.56,134.12 168.92,134.76 168.92,137.32 169.06,137.46 169.26,137.46 v1(169.46,137.65)
  IN10 w0.107: 169.75,130.25 169.75,123.1 169.23,122.58 169.23,120.88 168.37,120.02 168.37,107.99 166.94,106.56 166.94,102.93 167.2,102.67 167.56,102.67 167.69,102.54 167.69,102.18 167.56,102.06 167.07,102.06 166.79,101.78 166.79,101.2 167.07,100.92 167.56,100.92 167.69,100.8 167.69,100.44 167.56,100.31 167.07,100.31 166.79,100.03 166.79,99.46 167.07,99.18 167.56,99.18 167.69,99.05 167.69,98.69 167.56,98.56 167.2,98.56 166.94,98.3 166.94,97.69 167.2,97.43 167.56,97.43 167.69,97.3 167.69,96.94 167.56,96.81 167.2,96.81 166.93,96.54 166.93,93.26 167.07,93.11 167.07,92.06 165.95,90.94 165.95,74.38 167.25,73.08 167.25,72.86 167.12,72.72 166.84,72.72 166.55,72.44 166.55,71.73 167.16,71.13 167.32,70.97 167.73,70.97 v1(167.8,70.89)
  BOTTOM w0.076: U1.AJ11 169.23,137.33 169.46,137.56 v1(169.46,137.65)
M_B_DIM1_CK_DDR3_DP: length 86.2
  TOP w0.102: JDIMM4.138 165.35,73.48 165.4,73.43 165.51,73.43 165.57,73.37 165.57,73.07 164.9,72.41 164.9,71.34 165.17,71.07 165.54,71.07 165.81,71.34 165.81,71.9 166.56,72.65 166.8,72.65 166.97,72.47 167.38,72.47 167.56,72.65 168.12,72.65 168.24,72.52 168.24,71.41 168.12,71.28 167.93,71.28 167.8,71.41 v1(167.8,71.53)
  IN10 w0.076: 170.01,130.25 170.01,130.26 169.94,130.32 169.94,130.82 169.72,131.04 169.72,134.18 169.07,134.82 169.07,135.56 169.14,135.63 169.27,135.63 169.34,135.69 169.34,135.79 169.27,135.86 169.14,135.86 169.07,135.92 169.07,137.26 169.13,137.31 169.33,137.31 169.46,137.18 v1(169.46,137)
  IN10 w0.107: v1(167.8,71.53) 167.8,71.47 167.56,71.23 167.42,71.23 167.25,71.4 167.25,71.58 167.13,71.71 166.94,71.71 166.81,71.84 166.81,72.33 166.94,72.46 167.22,72.46 167.51,72.75 167.51,73.19 166.21,74.49 166.21,90.84 167.33,91.95 167.33,93.22 167.19,93.36 167.19,96.43 167.31,96.56 167.67,96.56 167.95,96.83 167.95,97.41 167.67,97.69 167.31,97.69 167.2,97.8 167.2,98.2 167.31,98.3 167.67,98.3 167.95,98.58 167.95,99.16 167.67,99.44 167.18,99.44 167.05,99.56 167.05,99.92 167.18,100.05 167.67,100.05 167.95,100.33 167.95,100.9 167.67,101.18 167.18,101.18 167.05,101.31 167.05,101.67 167.18,101.8 167.67,101.8 167.95,102.08 167.95,102.65 167.67,102.93 167.31,102.93 167.2,103.04 167.2,106.45 168.63,107.88 168.63,119.91 169.49,120.77 169.49,122.47 170.01,122.99 170.01,130.25
  BOTTOM w0.076: U1.AJ10 169,136.68 169.32,137 v1(169.46,137)
M_B_DIM1_CKE2: length 84.3
  TOP w0.102: JDIMM4.109 158.1,67.06 157.93,67.23 154.82,67.23 154.17,67.87 154.05,67.87 153.94,67.97 153.94,68.18 154.05,68.28 154.17,68.28 154.27,68.38 154.27,68.58 154.17,68.69 154.05,68.69 153.94,68.79 153.94,68.99 154.05,69.09 154.17,69.09 154.27,69.19 154.27,69.4 154.17,69.5 154.05,69.5 153.94,69.6 153.94,69.8 154.05,69.9 154.17,69.9 154.27,70.01 154.27,70.21 154.17,70.31 154.05,70.31 153.94,70.41 153.94,70.62 154.05,70.72 154.17,70.72 154.27,70.82 154.27,71.47 154.38,71.57 v1(154.72,71.57)
  IN10 w0.076: 160.73,124.64 160.93,124.84 160.93,130.2 162.58,131.85 162.58,133.87 163.76,135.05 v1(163.97,135.05)
  IN10 w0.14: 160.73,124.64 155.55,119.46 155.55,119.08 153.61,117.15 153.61,93.99 154.34,93.27 154.34,88.27 154.2,88.13 154.11,88.13 153.97,87.99 153.97,87.71 154.11,87.57 154.2,87.57 154.34,87.43 154.34,87.15 154.2,87.01 154.11,87.01 153.97,86.87 153.97,86.59 154.11,86.45 154.2,86.45 154.34,86.31 154.34,86.03 154.2,85.89 154.11,85.89 153.97,85.75 153.97,85.47 154.11,85.33 154.2,85.33 154.34,85.19 154.34,84.91 154.2,84.78 154.11,84.78 153.97,84.64 153.97,84.36 154.11,84.22 154.2,84.22 154.34,84.08 154.34,83.8 154.2,83.66 154.11,83.66 153.97,83.52 153.97,83.24 154.11,83.1 154.2,83.1 154.34,82.96 154.34,82.68 154.2,82.54 154.11,82.54 153.97,82.4 153.97,82.12 154.11,81.98 154.2,81.98 154.34,81.84 154.34,81.56 154.2,81.42 154.11,81.42 153.97,81.28 153.97,81 154.11,80.86 154.2,80.86 154.34,80.72 154.34,80.44 154.2,80.3 154.11,80.3 153.97,80.17 153.97,79.89 154.11,79.75 154.2,79.75 154.34,79.61 154.34,79.33 154.2,79.19 154.11,79.19 153.97,79.05 153.97,78.77 154.11,78.63 154.2,78.63 154.34,78.49 154.34,78.21 154.2,78.07 154.11,78.07 153.97,77.93 153.97,77.65 154.11,77.51 154.2,77.51 154.34,77.37 154.34,77.09 154.22,76.97 154.2,76.95 154.11,76.95 153.97,76.81 153.97,76.53 154.11,76.39 154.2,76.39 154.34,76.25 154.34,72.76 154.72,72.38 v1(154.72,71.57)
  BOTTOM w0.076: U1.AT7 v1(163.97,135.05)
M_B_DIM1_CKE3: length 83
  TOP w0.102: v1(154.72,68.37) 155.12,68.78 155.12,71.62 156.81,73.31 158.08,73.31 158.35,73.58 JDIMM4.110
  IN10 w0.076: 160.34,125.93 160.34,132.26 161.77,133.68 161.77,133.94 162.69,134.86 162.69,136.66 v1(163.07,137.04)
  IN10 w0.14: 160.34,125.93 152.14,117.73 152.14,94.01 152.6,93.55 152.6,73.43 152.71,73.32 152.81,73.23 152.81,70.29 v1(154.72,68.37)
  BOTTOM w0.152: U1.AT11 v1(163.07,137.04)
M_B_DIM1_CS2_N: length 84.7
  TOP w0.102: v1(171.1,68.15) 170.17,68.15 170.05,68.03 170.05,67.86 170.17,67.75 170.44,67.75 170.56,67.63 170.56,67.46 170.44,67.34 170.2,67.34 170.1,67.24 JDIMM4.149
  IN10 w0.076: 172.38,125.45 172.38,130.73 171.93,131.19 171.93,134.47 171.59,134.81 171.59,135.33 171.82,135.56 171.82,135.69 171.82,136.62 v1(172.2,137)
  IN10 w0.14: v1(171.1,68.15) 170.89,67.94 170.89,66.15 170.99,66.04 171.8,66.04 171.9,66.15 171.9,66.4 171.8,66.5 171.6,66.5 171.5,66.6 171.5,66.83 171.6,66.93 171.8,66.93 171.9,67.03 171.9,67.29 171.8,67.39 171.6,67.39 171.5,67.49 171.5,67.75 171.6,67.85 171.83,67.85 171.93,67.95 171.93,68.18 171.83,68.28 171.71,68.28 171.61,68.38 171.61,80.72 171.93,81.04 171.93,90.38 174.44,92.89 174.44,101.38 174.67,101.6 175.12,101.6 175.32,101.81 175.32,102.26 175.18,102.4 174.58,102.4 174.44,102.54 174.44,102.82 174.58,102.96 175.18,102.96 175.32,103.1 175.32,110.22 173.62,111.93 173.62,121.43 172.65,122.39 172.65,125.19 172.38,125.45
  BOTTOM w0.152: U1.AF10 v1(172.2,137)
M_B_DIM1_CS3_N: length 87
  TOP w0.102: JDIMM4.157 172.1,67.12 172.88,67.9 173.9,67.9 174.36,68.36 174.36,72.3 174.46,72.4 174.62,72.4 174.73,72.3 174.73,70.79 174.83,70.69 v1(175.13,70.69)
  IN10 w0.076: 175.36,125.12 173.76,126.72 173.76,131.61 173.26,132.1 173.26,134.27 173.48,134.48 173.48,134.68 173.65,134.85 173.65,135.43 173.49,135.58 173.49,136.62 v1(173.11,137)
  IN10 w0.14: 175.36,125.12 175.36,123.55 177.07,121.84 177.07,118.17 177.79,117.44 177.79,117.08 177.93,116.94 177.96,116.94 178.1,116.8 178.1,116.52 177.96,116.38 177.93,116.38 177.79,116.24 177.79,115.96 177.93,115.82 177.96,115.82 178.1,115.68 178.1,115.4 177.96,115.26 177.93,115.26 177.79,115.12 177.79,114.84 177.93,114.7 177.96,114.7 178.1,114.56 178.1,114.28 177.96,114.14 177.93,114.14 177.79,114 177.79,113.73 177.93,113.59 177.96,113.59 178.1,113.45 178.1,113.17 177.96,113.03 177.93,113.03 177.79,112.89 177.79,112.63 178.77,111.65 178.77,92.87 177.95,92.05 177.59,92.05 176.99,91.46 176.99,91.01 176.85,90.87 176.56,90.87 176.42,90.73 176.42,90.45 176.56,90.31 176.85,90.31 177.02,90.15 177.02,81.61 177.12,81.51 177.41,81.51 177.51,81.41 177.51,81.08 177.41,80.98 176.3,80.98 176.19,80.88 176.19,80.57 176.3,80.47 176.65,80.47 176.75,80.37 176.75,79.99 176.65,79.89 176.22,79.89 176.12,79.78 176.12,79.35 175.67,78.9 175.67,74.03 174.37,72.72 174.37,71.8 174.47,71.7 174.67,71.7 174.77,71.59 174.77,71.3 174.67,71.2 174.47,71.2 174.37,71.1 174.37,70.82 174.49,70.69 v1(175.13,70.69)
  BOTTOM w0.152: v1(173.11,137) U1.AE10
