# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_VCCIO_VSS_SENSE: length 90.2
  IN08 w0.203: v1(137.18,156.77) 137.23,156.77 137.51,157.05 144.88,157.05 145.32,156.61 145.32,149.62 148.76,146.18 152.34,146.18 153,146.84 160.17,146.84 163.55,143.46 163.55,141.05 163.75,140.85 163.75,138.66 163.57,138.48 162.2,138.48 161.64,137.93 161.64,135.44 162.86,134.22 164.79,134.22 165.07,133.94 165.07,131.75 165.93,130.89 174.14,130.89 175.08,131.83 175.08,133.68 175.64,134.24 184.03,134.24 184.42,133.85 184.42,132.6 184.79,132.24 185.97,132.24 186.43,132.69 186.43,134.17 185.01,135.59 185.01,136.6 185.77,137.37 185.77,139.87 185.38,140.26 184.82,140.26 184.67,140.11 v1(184.21,140.11)
  BOTTOM w0.203: U1.J14 184.46,139.86 v1(184.21,140.11) ; v1(137.18,156.77) 136.9,156.49 PR1229.1
CPU_VCCSA_VCC_SENSE: length 74.6
  TOP w0.254: v1(123.92,181.56) 123.06,182.43 PR1175.1
  IN03 w0.203: v1(181.45,160.73) 180.97,161.22 173.22,161.22 169.9,164.54 146.15,164.54 141.83,168.86 141.83,170.13 130.73,181.23 125.69,181.23 124.55,182.38 123.76,182.38 123.54,182.16 123.54,181.94 v1(123.92,181.56)
  BOTTOM w0.102: U1.M38 182.62,158.04 182.34,158.32
  BOTTOM w0.254: 182.34,158.32 181.45,159.21 v1(181.45,160.73) 181.68,160.96 PR1172.2
CPU_VCCSA_VSS_SENSE: length 78.2
  TOP w0.254: v1(123.16,181.56) 123.03,181.44 v2(122.14,181.44) 121.86,181.72 PR1169.1
  IN03 w0.203: v1(123.16,181.56) 123.21,181.61 123.21,182.3 123.62,182.71 124.68,182.71 125.72,181.66 130.8,181.66 142.21,170.26 142.21,168.99 146.27,164.93 170.15,164.93 173.48,161.6 180.84,161.6 v1(181.45,162.21)
  BOTTOM w0.102: 182.24,157.78 182.32,157.71 182.32,157.08 182.6,156.79 U1.M37
  BOTTOM w0.254: 182.24,157.78 180.94,159.08 180.94,161.7 v1(181.45,162.21) 181.76,162.51 PR1173.2
CPU_VCORE_VCC_SENSE: length 90.5
  TOP w0.203: v1(114.02,197.31) 114.12,197.41 PR1121.1
  IN03 w0.254: v1(114.02,197.31) 115.06,197.31 116.3,196.07 116.3,193.83 115.7,193.23 115.7,190.93 116.3,190.33 116.3,177.37 119.3,174.37 129.72,174.37 140.18,163.91 169.01,163.91 170.53,162.39 v1(170.53,160.96)
  BOTTOM w0.102: 171.19,158.19 171.19,157.2 170.81,156.82 U1.AG37
  BOTTOM w0.254: 171.19,158.19 171.19,158.55 170.53,159.21 170.53,159.9 R59.1 170.73,160.68 170.53,160.89 v1(170.53,160.96) 170.28,161.22 PR1164.2
CPU_VCORE_VSS_SENSE: length 89.1
  TOP w0.254: v1(114.02,196.62) 114.98,196.62 PR1165.1
  IN03 w0.254: v1(169.67,160.89) 169.84,160.89 170.02,161.06 170.02,162.26 168.75,163.53 139.8,163.53 129.51,173.82 119.22,173.82 115.92,177.12 115.92,190.07 115.32,190.67 115.32,193.49 115.79,193.96 115.79,195.79 114.95,196.62 v1(114.02,196.62)
  BOTTOM w0.254: PR1163.2 169.26,161.29 v1(169.67,160.89) 169.82,160.73 R59.2 170.02,159.9 170.02,159.08 170.86,158.25 170.86,157.49 U1.AG38
CPU_VR_HOT_N: length 228.9
  TOP w0.097: v1(116.94,184.23) v2(116.94,185.5) 116.94,185.8 116.73,186.01 PR1233.1
  IN03 w0.091: v1(116.94,184.23) 116.94,182.58 118.21,181.31 v1(118.21,177.37)
  IN05 w0.091: v1(47.21,44.4) 47.21,44.28 47.72,43.77 48.48,43.77 52.08,40.17 52.08,35.92 57.33,30.67 57.9,30.67 58.73,29.84 63.68,29.84 65.25,28.27 71.12,28.27 73.92,31.07 83.28,31.07 83.46,31.25 86.89,31.25 v1(87.98,32.34)
  IN10 w0.091: v1(118.21,177.37) 114.36,173.53 114.36,131.74 111.35,128.73 111.35,113.36 106.14,108.16 98.14,108.16 89.63,99.65 89.63,94.06 85.03,89.46 85.03,74.98 84.68,74.63 84.68,67.52 84.42,67.26 84.42,63.71 83.54,62.82 83.54,51.39 82.77,50.63 82.77,37.54 v1(87.98,32.34)
  BOTTOM w0.097: v1(47.21,44.4) 47.09,44.28 R556.2
CPU_VR_PWRGD: length 252
  TOP w0.097: v1(117.36,191.21) 118,191.85 PR1241.1
  IN03 w0.091: v1(117.36,191.21) 117.36,190.66 118.28,189.74 118.28,182.25 v1(121.89,178.64)
  IN05 w0.091: v1(38.07,43.39) 38.58,43.89 47.21,43.89 47.59,43.51 48.34,43.51 51.86,39.99 51.86,35.69 57.1,30.45 57.61,30.45 58.47,29.59 63.55,29.59 65.12,28.02 71.18,28.02 73.97,30.81 83.46,30.81 83.68,31.03 87.69,31.03 v1(87.98,31.32)
  IN10 w0.091: v1(87.98,31.32) 88.49,31.83 88.49,32.46 83.13,37.82 83.13,50.6 83.79,51.26 83.79,62.69 84.81,63.71 84.81,67.14 87.6,69.93 87.6,79.87 85.31,82.15 85.31,87.84 90.14,92.66 90.14,99.77 98.05,107.68 106.3,107.68 112.4,113.79 112.4,129.27 114.61,131.48 114.61,173.15 120.11,178.64 v1(121.89,178.64)
  BOTTOM w0.097: R260.2 v1(38.07,43.39)
CSCOMP_1PH_A: length 111.4
  TOP w0.203: PR1199.1 125.83,186.81 v1(125.93,186.92) PU1101.19
  IN03 w0.203: v1(209.29,178.51) 209.01,178.24 208.48,178.24 207.06,176.81 201.37,176.81 200.63,176.08 200.63,168.05 199.9,167.32 186.68,167.32 186.02,167.97 172.56,167.97 170.4,165.81 150.97,165.81 148.23,168.56 148.23,170.97 147.92,171.28 142.59,171.28 131.18,182.68 127.5,182.68 125.93,184.25 v1(125.93,186.92)
  BOTTOM w0.254: PC1155.1 PC1154.1 PR1211.2 125.8,186.79 v1(125.93,186.92) ; PH1106.1 209.24,178.46 v1(209.29,178.51)
CSCOMP_3PH_A: length 51.4
  TOP w0.203: PU1101.47 125.93,196.57 125.19,197.31 123.54,197.31 122.96,197.89 v1(122.96,198.83) 123.46,199.34 PR1208.2 123.67,199.32 PC1140.1 124.51,199.29 PC1130.1
  IN05 w0.127: v1(122.96,198.83) 123.34,199.22 124.32,199.22 128.01,195.53 130.42,195.53 130.65,195.3 130.65,194.37 130.27,193.99 130.27,188.19 139.69,178.77 148.43,178.77 148.75,178.45 149.13,178.45 149.32,178.26 v1(149.32,177.88)
  BOTTOM w0.254: v1(149.32,177.88) 149.32,177.8 149.83,177.3 PH1103.1 ; PR1148.1 123.26,199.14 v1(122.96,198.83)
CSN1_3PH_A: length 43.3
  TOP w0.203: PU1101.38 130.24,193.6 130.91,194.26 130.91,194.59
  TOP w0.254: 130.91,194.59 131.34,195.02 132.38,195.02 PC1148.1 132.48,194.29 v1(132.53,194.24)
  IN05 w0.203: v1(151.35,177.37) 151.1,177.63 150.59,177.63 150.21,178.01 150.21,179.86 149.83,180.24 140.86,180.24 131.8,189.31 131.8,192.18 132,192.38 132,193.7 v1(132.53,194.24)
  BOTTOM w0.254: PR1155.2 127.1,196.42 127.6,195.91 130.86,195.91 v1(132.53,194.24) ; PR1505.2 151.43,177.45 v1(151.35,177.37)
CSN2_3PH_A: length 59.3
  TOP w0.203: PC1147.1 129.48,195.3 128.94,195.3 128.73,195.09 PU1101.40
  TOP w0.254: v1(130.91,196.93) 130.4,196.42 130.4,196.22 PC1147.1
  IN03 w0.254: v1(164.41,177.12) 163.9,177.63 153.26,177.63 151.61,175.97 145.69,175.97 134.87,186.8 131.06,186.8 129.61,188.24 129.61,193.86 130.91,195.15 v1(130.91,196.93)
  BOTTOM w0.254: v1(164.41,177.12) 164.74,177.45 PR1511.2 ; PR1158.2 126.97,197.31 127.99,196.29 130.27,196.29 v1(130.91,196.93)
CSN3_3PH_A: length 91.3
  TOP w0.203: PU1101.42 127.93,195.53 PC1145.1
  TOP w0.254: v1(129.13,197.82) 129.13,196.93 128.57,196.37 PC1145.1
  IN03 w0.254: v1(129.13,197.82) 128.72,197.41 128.72,185.3 129.94,184.08 131.39,184.08 131.67,184.36 132.94,184.36 143.61,173.69 148.31,173.69 151.38,170.62 184.22,170.62 185.26,171.66 185.26,175.85 186.89,177.47 188.21,177.47 v1(188.44,177.24)
  BOTTOM w0.254: PR1161.2 128.75,198.2 v1(129.13,197.82) ; PR1605.2 188.64,177.45 v1(188.44,177.24)
CSN4_3PH_A: length 76.6
  TOP w0.203: PC1166.1 129.71,186.31 129.34,186.68 129.04,186.68 127.93,187.79 PU1101.24
  TOP w0.254: PC1166.1 129.74,186.01 130.02,185.73 v1(130.7,185.73)
  IN03 w0.254: v1(176.37,177.24) 176.72,177.6 177.16,177.6 177.64,177.12 177.64,174.15 176.29,172.8 151.99,172.8 149.58,175.21 144.75,175.21 134.21,185.75 131.21,185.75 131.19,185.73 v1(130.7,185.73)
  IN05 w0.254: v1(129.89,195.02) 129.53,194.67 129.53,186.39 130.19,185.73 v1(130.7,185.73)
  BOTTOM w0.254: PR1206.2 129.38,195.53 v1(129.89,195.02) ; v1(176.37,177.24) 176.58,177.45 PR1613.2
CSN_1PH: length 94.6
  TOP w0.203: PU1101.26 128.73,188.1 129.28,187.56 129.99,187.56 130.14,187.4
  TOP w0.254: PR1176.2 130.8,183.14 131.98,183.14 v1(132.49,183.65) 132.38,183.75 132.38,186.26 PC1167.1 131.74,186.9 130.65,186.9 130.14,187.4
  IN03 w0.254: v1(199.36,177.24) 199.66,176.94 199.66,168.63 199.38,168.35 187.55,168.35 186.66,169.24 151.86,169.24 148.18,172.93 142.59,172.93 132.3,183.21 132.3,183.46 v1(132.49,183.65)
  BOTTOM w0.203: v1(199.36,177.24) 199.56,177.45 PR1619.2
CSP1_3PH_A: length 5
  TOP w0.203: PU1101.39 130,194 130.3,194.29 130.3,194.67
  TOP w0.254: 130.3,194.67 v2(131.46,195.84) PC1148.2 133.37,195.84 PR1185.2
CSP2_3PH_A: length 5.5
  TOP w0.203: PU1101.41 128.33,195.38 128.61,195.66 128.95,195.66 129.43,196.14 PC1147.2
  TOP w0.254: v1(130.02,196.93) 129.43,196.35 PC1147.2
  BOTTOM w0.254: PR1184.2 v2(131.13,197.74) 130.83,197.74 v1(130.02,196.93)
CSP3_3PH_A: length 4.6
  TOP w0.203: PC1145.2 127.53,196.05 PU1101.43
  TOP w0.254: PC1145.2 127.65,196.35 128.11,196.8 v1(128.11,196.93)
  BOTTOM w0.254: v1(128.11,196.93) 129.08,196.93 PR1183.2
CSP4_3PH_A: length 4.9
  TOP w0.203: PU1101.23 127.53,187.7 127.99,187.25 v1(127.99,187.05)
  TOP w0.254: PR1205.2 PC1166.2 128.8,186.23 v1(127.99,187.05)
  BOTTOM w0.254: v1(127.99,187.05) 127.99,187.05 128.39,186.64 PR1186.2
CSP_1PH: length 5.4
  TOP w0.203: 129.64,187.02 129.26,187.02 128.33,187.94 PU1101.25
  TOP w0.254: PR1212.2 131.54,186.19 PC1167.2 130.4,186.26 v2(129.71,186.95) 129.64,187.02
CSREF_3PH_A: length 11
  TOP w0.203: v1(128.11,198.96) 128.37,198.71 128.37,197.95 127.13,196.71 PU1101.44
  BOTTOM w0.254: PR1206.1 PR1155.1 PR1158.1 PR1161.1 125.62,198.76 126.13,199.27 PC1161.2 127.86,199.27 128.11,199.01 v1(128.11,198.96)
CSSUM_1PH: length 8.6
  TOP w0.203: v1(127.4,184.13) 127.22,184.31 127.22,185.75 126.94,186.03 PR1198.2 127.07,186.39 127.07,187.13 126.73,187.46 PU1101.21
  BOTTOM w0.254: PR1154.1 128.81,184.04 128.49,183.72 127.73,183.72 127.4,184.05 v1(127.4,184.13) 127.35,184.18 126.84,184.18 PC1155.2 PC1154.2
CSSUM_3PH_A: length 17.7
  TOP w0.203: PU1101.45 126.73,197.51 125.86,198.38 PC1130.2 125.42,199.29 PC1140.2 ; PR1147.1 PR1145.1
  TOP w0.254: PR1145.1 125.25,200.55 v1(125.7,200.1) 125.7,199.62 PC1140.2
  BOTTOM w0.254: PR1149.1 131.47,201.31 131.29,201.49 130.65,201.49 130.47,201.31 PR1151.1 v2(128.16,201.31) 126.78,201.31 125.7,200.23 v1(125.7,200.1) 125.7,199.87 124.97,199.14 PR1146.2
DDI1_AUX_DN: length 23
  TOP w0.097: C2154.1 59.21,87.6 60.82,87.6 61.07,87.86 62.69,87.86 63.36,87.19 63.36,86.3 v1(65.49,84.17) 65.74,83.92 68.15,83.92 68.57,83.51 68.57,82.24 69.32,81.49 70.58,81.49 71.22,80.85 71.22,78.82 71.72,78.31 72.61,78.31 72.96,78.65 72.96,79.49 72.78,79.67 72.57,79.67 v1(72.49,79.58)
  BOTTOM w0.097: R585.2 v1(72.49,79.58)
DDI1_AUX_DP: length 23
  TOP w0.097: v1(73.38,79.58) 73.23,79.44 73.23,78.54 72.73,78.04 71.61,78.04 70.94,78.71 70.94,80.74 70.47,81.21 69.2,81.21 68.3,82.12 68.3,83.39 68.04,83.65 65.63,83.65 v1(63.34,85.93) 63.09,86.19 63.09,87.07 62.58,87.58 61.18,87.58 60.93,87.33 59.1,87.33 C2153.1
  BOTTOM w0.097: R584.2 v1(73.38,79.58)
DDI1_AUX_OUT_DN: length 3.8
  BOTTOM w0.097: R510.1 R585.1 72.79,77.67 72.79,77.3 73.64,76.45 73.64,76.05 73.54,75.95 73.54,75.57 U2013.27
DDI1_AUX_OUT_DP: length 3.8
  BOTTOM w0.097: U2013.28 74.04,75.57 74.04,75.95 73.92,76.07 73.92,76.56 73.07,77.41 73.07,77.67 R584.1 R489.1
DDI1_DN0: length 1.6
  BOTTOM w0.097: C2044.2 70.52,73.97 71,73.97 71.14,73.84 U2013.22
DDI1_DN1: length 1.5
  BOTTOM w0.097: U2013.19 71.14,72.34 71.03,72.44 70.52,72.44 C2047.2
DDI1_DN2: length 1.5
  BOTTOM w0.097: C2050.2 70.52,70.92 71.26,70.92 71.34,70.84 U2013.16
DDI1_DN3: length 1.5
  BOTTOM w0.097: C2052.2 70.52,69.45 71.03,69.45 71.14,69.34 U2013.13
DDI1_DP0: length 1.5
  BOTTOM w0.097: C2043.2 70.49,74.25 71.04,74.25 71.14,74.34 U2013.23
DDI1_DP1: length 1.5
  BOTTOM w0.097: C2045.2 70.5,72.72 71.02,72.72 71.14,72.84 U2013.20
DDI1_DP2: length 1.6
  BOTTOM w0.097: C2049.2 70.5,71.19 71.32,71.19 71.46,71.34 U2013.17
DDI1_DP3: length 1.5
  BOTTOM w0.097: U2013.14 71.14,69.84 71.02,69.72 70.5,69.72 C2051.2
DDI1_HPD: length 38.4
  IN08 w0.091: v1(65.5,70.56) 64.61,71.45 64.61,74.37 59.91,79.07 59.91,85.04 59.02,85.93 59.02,91.39 58.39,92.03 v2(57.88,92.03)
  BOTTOM w0.076: U2005.AA2 55.26,90.89 55.26,91.19 55.27,91.19 55.27,91.21 55.7,91.65 56.46,91.65
  BOTTOM w0.097: 58.06,92.21 58.14,92.28 R2057.1 ; v1(65.5,70.56) 66.01,70.06 67.53,70.06 69.44,68.15 69.57,68.15 v2(70.71,67.01) 71.93,65.79 R420.2
  BOTTOM w0.102: 58.06,92.21 v2(57.88,92.03) 57.5,91.65 56.46,91.65
DDI2_AUX_DN: length 19.4
  TOP w0.097: C2134.1 60.24,85.27 60.6,85.62 61.24,85.62 v1(61.48,85.38) 63.08,83.79 63.08,69.38 62.91,69.21 62.79,69.21 v1(62.71,69.29)
  BOTTOM w0.097: v1(62.71,69.29) R632.2
DDI2_AUX_DP: length 19.4
  TOP w0.097: C2133.1 60.41,85.89 61.36,85.89 v1(63.09,84.16) 63.35,83.9 63.35,69.54 v1(63.6,69.29)
  BOTTOM w0.097: R773.2 v1(63.6,69.29)
DDI2_AUX_OUT_DN: length 3.8
  BOTTOM w0.097: U2014.27 63.88,65.91 63.99,66.02 63.99,66.15 63.01,67.12 63.01,67.39 R632.1 R439.1
DDI2_AUX_OUT_DP: length 3.8
  BOTTOM w0.097: U2014.28 64.38,65.91 64.27,66.02 64.27,66.26 63.29,67.24 63.29,67.39 R773.1 R438.1
DDI2_DN0: length 2.2
  BOTTOM w0.097: U2014.22 61.77,63.68 61.65,63.8 61.33,63.8 61.18,63.65 61.18,63.5 60.86,63.17 60.56,63.17 C2057.2
DDI2_DN1: length 2
  BOTTOM w0.097: U2014.19 61.74,62.18 61.63,62.28 61.23,62.28 60.88,61.94 60.57,61.94 C2059.2
DDI2_DN2: length 1.9
  BOTTOM w0.097: U2014.16 61.69,60.68 61.62,60.76 60.58,60.76 C2061.2
DDI2_DN3: length 1.9
  BOTTOM w0.097: C2063.2 60.55,59.4 61.01,59.4 61.11,59.31 61.63,59.31 61.76,59.18 U2014.13
DDI2_DP0: length 2.2
  BOTTOM w0.097: C2056.2 60.54,63.45 60.74,63.45 60.91,63.61 60.91,63.76 61.22,64.08 61.68,64.08 61.78,64.18 U2014.23
DDI2_DP1: length 2
  BOTTOM w0.097: C2058.2 60.53,62.21 60.77,62.21 61.12,62.56 61.66,62.56 61.78,62.68 U2014.20
DDI2_DP2: length 1.9
  BOTTOM w0.097: U2014.17 61.72,61.18 61.57,61.03 60.52,61.03 C2060.2
DDI2_DP3: length 1.9
  BOTTOM w0.097: U2014.14 61.73,59.68 61.64,59.58 61.22,59.58 61.13,59.67 60.58,59.67 C2062.2
DDI2_HPD: length 39.3
  TOP w0.089: R2083.1 55.1,89.61 v2(54.47,88.98)
  IN10 w0.091: v1(60.32,56.67) 60.32,64.29 59.66,64.95 59.66,68.02 57.25,70.44 57.25,75.14 58.64,76.53 58.64,78.06 57.06,79.65 57.06,86.76 55.21,88.6 54.86,88.6 v2(54.47,88.98)
  BOTTOM w0.097: R423.2 61.11,56.09 60.9,56.09 v1(60.32,56.67)
  BOTTOM w0.178: U2005.Y6 54.8,88.66 v2(54.47,88.98)
DDR0_A_ALERT_N: length 68.7
  TOP w0.102: JDIMM2.116 159.65,86.64 158.92,85.91 158.92,83.49 158.54,83.11 158.2,83.11 157.89,83.42 v1(157.89,83.59)
  IN03 w0.175: v1(161.67,128.43) 160.6,127.35 160.6,123.68 153.39,116.46 153.39,114.17 152.15,112.93 152.15,97.53 153.17,96.51 153.17,95.14 154.35,93.96 154.35,88.62 156.53,86.44 156.53,84.28 157.22,83.59 v1(157.89,83.59)
  BOTTOM w0.076: v1(161.67,128.43) 161.74,128.5 161.74,130.38 162.02,130.66 162.02,132.82 U1.AU5
  BOTTOM w0.102: JDIMM1.116 161.32,80.39 160.47,81.24 160.06,81.24 158.91,82.39 158.91,82.58 v1(157.89,83.59)
DDR0_A_PARITY: length 77.9
  TOP w0.102: v1(170.59,83.26) 170.19,82.86 170.19,82.02 168.92,80.75 168.4,80.75 167.99,80.34 166.67,80.34 166.4,80.08 JDIMM2.143
  IN03 w0.175: v1(169.27,125.82) 169.27,125.85 169.03,126.09 168.83,126.09 168.68,125.94 168.68,122.58 169.13,122.13 169.13,116.84 168.55,116.26 168.55,116.01 168.65,115.9 169.59,115.9 169.72,115.78 169.72,115.45 169.59,115.32 168.29,115.32 168.17,115.19 168.17,114.74 168.29,114.61 169.62,114.61 169.74,114.48 169.74,114.07 169.62,113.95 168.32,113.95 168.19,113.82 168.19,113.39 168.32,113.26 169.49,113.26 169.71,113.04 169.71,112.31 169.47,112.08 169.47,111.6 169.71,111.37 169.71,111.04 169.58,110.91 169.57,110.91 169.45,110.79 169.45,110.22 169.57,110.1 169.58,110.1 169.71,109.97 169.71,109.5 169.47,109.27 169.47,108.79 169.71,108.56 169.71,107.9 169.58,107.78 169.04,107.78 168.91,107.65 168.91,107.17 169.04,107.05 169.58,107.05 169.71,106.92 169.71,106.47 169.58,106.35 168.94,106.35 168.77,106.17 168.77,100.07 167.62,98.92 167.62,88.31 169.38,86.54 169.38,82.76 169.51,82.63 169.87,82.63 170,82.76 170,83.35 170.12,83.48 170.47,83.48 170.59,83.35 v1(170.59,83.26)
  BOTTOM w0.076: U1.AG3 170.69,132.12 170.61,132.03 170.61,130.51 170.54,130.44 170.54,128.57 170.23,128.25 170.23,126 170.06,125.82 v1(169.27,125.82)
  BOTTOM w0.102: v1(170.59,83.26) 171.01,83.68 171.01,85.33 170.71,85.62 169,85.62 168.07,86.55 JDIMM1.143
DDR1_B_ALERT_N: length 91.2
  TOP w0.102: JDIMM4.116 159.85,73.33 158.99,72.48 157.9,72.48 157.39,71.96 157.39,69.5 v1(156.37,68.48)
  IN10 w0.076: v1(164.88,135.7) 165.26,135.32 165.26,134.91 164.21,133.85 164.21,130.37 162.99,129.16 162.99,127.31 161.94,126.27 161.94,123.7
  IN10 w0.175: v1(156.37,68.48) 156.37,67.8 156.55,67.62 157.2,67.62 157.53,67.95 157.53,68.48 156.88,69.13 156.88,73.05 156.52,73.41 156.52,93.85 155.67,94.7 155.67,115.34 157.77,117.44 157.77,119.52 161.94,123.7
  BOTTOM w0.076: U1.AR8 v1(164.88,135.7)
  BOTTOM w0.102: v1(156.37,68.48) 156.37,68.42 156.84,67.95 157.13,67.95 157.23,68.05 157.23,68.61 157.33,68.71 157.54,68.71 157.64,68.61 157.64,68.05 157.77,67.92 160.18,67.92 160.48,67.62 160.97,67.62 161.55,67.04 JDIMM3.116
DDR1_B_PARITY: length 90.6
  TOP w0.102: v1(169.45,68.79) 169.45,68.71 168.99,68.25 167.99,68.25 167.74,68 167.74,67.08 167.61,66.96 167.3,66.96 167.18,67.08 167.18,67.49 167.05,67.62 166.73,67.62 166.6,67.49 JDIMM4.143
  IN10 w0.076: 169.86,120.41 169.86,122.04 170.35,122.53 170.35,130.67 169.87,131.15 169.87,134.41 169.46,134.82 v1(169.46,135.05)
  IN10 w0.175: v1(169.45,68.79) 169.45,67.76 169.72,67.49 169.72,66.4 169.59,66.27 168.38,66.27 168.25,66.4 168.25,66.89 168.43,67.07 168.75,67.07 168.93,67.24 168.93,67.6 168.75,67.77 168.43,67.77 168.25,67.95 168.25,68.3 168.43,68.47 168.75,68.47 168.93,68.65 168.93,69 168.75,69.17 168.43,69.17 168.25,69.35 168.25,73.25 167.15,74.35 167.15,77.8 166.87,78.08 166.87,81.28 167.15,81.56 167.15,85.37 166.77,85.75 166.77,88.22 167.15,88.6 167.15,90.66 168.07,91.57 168.07,95.56 168.73,96.22 168.73,103.71 168.04,104.4 168.04,106.18 169.41,107.55 169.41,119.97 169.86,120.41
  BOTTOM w0.076: U1.AJ7 v1(169.46,135.05)
  BOTTOM w0.102: JDIMM3.143 168.3,73.37 168.47,73.2 168.47,69.77 v1(169.45,68.79)
DDR4_DRAMRST_N: length 43.9
  TOP w0.254: JDIMM2.108 157.65,88.87 v1(157.77,88.98) ; JDIMM4.108 157.85,75.41 158.47,76.03 158.47,76.51 158.11,76.86 v1(157.89,76.86)
  IN08 w0.091: v1(157.83,59.13) 158.72,60.02 158.72,60.91 160.24,62.44 160.24,64.34 v1(159.99,64.6) 159.48,65.1 159.48,71.96 158.97,72.47 158.97,76.15 158.26,76.86 v1(157.89,76.86) 157.63,76.86 157.07,77.42 157.07,88.28 v1(157.77,88.98)
  BOTTOM w0.254: v1(157.89,76.86) 158.67,76.86 159.32,77.51 JDIMM1.108 ; JDIMM3.108 159.55,65.04 v1(159.99,64.6)
  BOTTOM w0.457: R86.2 157.96,59.01 v1(157.83,59.13)
DDR_RCOMP0: length 5.8
  BOTTOM w0.305: U1.G1 186.59,130.82 188.04,129.37 189.58,129.37 190.98,127.97 R4.2
DDR_RCOMP1: length 3.7
  BOTTOM w0.305: R5.2 187.42,128.46 185.5,130.38 U1.H1
DDR_RCOMP2: length 4.2
  BOTTOM w0.305: U1.J2 184.93,131.19 184.93,130.22 186.28,128.83 R6.2
DDR_VREF_EN: length 165.2
  TOP w0.097: PU401.8 108.05,89.49 v1(107.92,89.36) ; PR451.2 208.2,112.93 v1(208.12,112.86)
  IN03 w0.091: v1(209.77,76.28) 209.01,75.52 202.15,75.52 201.9,75.27 114.77,75.27 113.25,76.79 108.17,76.79 106.27,78.69 106.27,82.63 106.78,83.14 107.16,83.14 107.67,83.65 107.67,86.69 107.41,86.95 107.41,88.47 107.92,88.98 v1(107.92,89.36)
  BOTTOM w0.097: PC433.1 107.03,91.06 v2(107.03,90.25) v1(107.92,89.36) ; v1(208.12,112.86) 207.61,112.35 207.61,111.2 207.97,110.85 208.5,110.85 208.83,110.52 PD401.2 209.07,110.13 209.39,109.81 209.39,108.41 207.87,106.89 207.87,102.57 207.49,102.19 206.22,102.19 205.84,101.81 205.84,96.35 204.82,95.33 204.82,87.2 207.64,84.38 209.17,84.38 209.77,83.77 v1(209.77,76.28)
DDR_VTT_PG_CTRL: length 197
  TOP w0.097: v1(107.03,97.23) 107.28,97.49 R57.1
  IN03 w0.091: v1(107.03,97.23) 107.03,97.36 135.86,126.19 135.86,134.19 136.75,135.08 145.38,135.08 146.4,136.1 146.4,136.6 147.6,137.81 v1(147.6,137.85)
  IN05 w0.091: v1(93.57,32.59) 93.27,32.89 87.9,32.89 86.48,31.47 83.3,31.47 83.15,31.32 73.81,31.32 71.02,28.53 65.37,28.53 63.84,30.06 58.82,30.06 57.99,30.89 57.55,30.89 52.3,36.14 52.3,40.33 48.23,44.4 v1(48.1,44.4)
  IN08 w0.091: v1(107.03,97.23) 106.27,96.47 106.27,92.92 102.97,89.61 102.97,69.55 97.25,63.83 97.25,62.94 96.79,62.48 94.37,62.48 91.91,60.01 91.91,38.19 93.06,37.04 93.06,34.5 93.57,33.99 v1(93.57,32.59)
  BOTTOM w0.097: v1(147.6,137.85) 147.6,138.41 148.11,138.92 149.12,138.92 149.2,138.84 U1.BT13 ; R838.2 48.48,44.02 v1(48.1,44.4)
DGPU_AON_EN: length 3.2
  TOP w0.097: R2266.1 PR2187.2 208.72,124.37 PC3566.1 210.24,124.37 210.28,124.41 PU8.B2
DGPU_AON_EN_N: length 4.4
  TOP w0.097: Q100.5 204.31,125.43 204.19,125.3 203.75,125.3 R2265.2 203.55,124.03 v2(204.06,123.52) 204.45,123.91 Q100.6
DGPU_CORE_EN: length 7.5
  TOP w0.097: v1(295.68,184.43) 295.57,184.43 295.57,184.43 PU1605.36
  BOTTOM w0.097: PC801.1 295.7,184.46 v1(295.68,184.43) PR804.1 298.19,184.43 PD801.1 299.97,186.21 PR3590.2
DGPU_HOLD_RST_N: length 110.5
  TOP w0.097: U63.2 v1(303.25,71.07)
  IN05 w0.091: v1(288.01,68.02) 287.24,68.79 280.94,68.79 279.54,70.18 276.4,70.18 274.25,68.02 264.3,68.02 262.01,70.31 256.64,70.31 v1(256.13,69.8)
  IN08 w0.091: v3(222.96,64.6) 224.1,63.45 227.43,63.45 228.06,62.82 231.24,62.82 232.25,61.81 240,61.81 240.13,61.93 241.38,61.93 242.14,62.69 246.1,62.69 249.27,65.87 252.12,65.87 253.21,66.95 253.21,68.15 254.43,69.37 255.92,69.37 256.13,69.57 v1(256.13,69.8) ; v1(288.01,68.02) 287.37,68.02 285.72,66.37 285.72,62.44 286.86,61.29 291.94,61.29 293.85,63.2 293.85,66.25 v1(298.42,70.82)
  BOTTOM w0.097: U2.Y44 226.73,63.85 226.54,63.65 226.16,63.65 226.16,63.65 226.15,63.65 226.08,63.58 225.77,63.58 225.14,64.22 v2(224.38,64.21) 224,64.6 v3(222.96,64.6) 222.96,63.94 R110.1 ; v1(298.42,70.82) 299.31,71.71 302.61,71.71 v1(303.25,71.07)
DGPU_PEX_RST_N: length 259.2
  TOP w0.097: R2261.1 295.63,77.04 v1(297.02,75.64) ; R808.2 299.4,60.4 299.18,60.62 299.18,61.67 301.09,63.58 v2(301.85,63.58) 305.15,66.88 305.15,71.71 304.26,72.6 301.52,72.6 R2172.2 301.09,72.72 300.96,72.85 R1001.2 ; U62.4 301.98,74.23 301.66,74.55 R1001.2 ; R1001.2 300.27,74.55 v1(300.2,74.63)
  IN08 w0.091: v3(206.39,129.14) 206.09,128.83 206.09,124.62 205.58,124.11 205.58,121.11 207.87,118.82 209.01,118.82 209.27,118.57 212.19,118.57 213.33,117.43 213.33,114.38 214.35,113.36 214.91,113.36 216.34,111.93 216.34,106.92 215.29,105.87 213.33,105.87 210.19,102.74 210.19,98.8 209.39,98 209.39,95.16 206.98,92.74 206.98,79.33 208,78.31 209.39,78.31 211.42,76.28 218.41,76.28 220.95,73.74 220.95,70.69 222.47,69.17 224.65,69.17 227.83,65.99 235.25,65.99 235.81,66.55 237.79,66.55 238.24,67 238.61,67 239.24,66.37 240.89,66.37 241.27,65.99 241.65,65.99 241.75,65.89 246.48,65.89 246.9,66.31 247.66,66.31 252.42,71.07 257.53,71.07 257.91,70.69 270.86,70.69 274.16,67.39 274.16,61.42 278.1,57.48 295.63,57.48 296.39,58.25 296.39,63.45 297.53,64.6 297.53,69.04 298.93,70.44 298.93,71.2 298.67,71.45 298.04,71.45 297.78,71.71 297.78,74.88 v1(297.02,75.64)
  BOTTOM w0.097: v3(206.39,129.14) 206.62,129.14 206.85,129.37 208.38,129.37 208.93,129.92 208.93,133.3 209.27,133.63 220.44,133.63 224.08,130 236.08,130 236.37,130.28 236.9,130.28 G2.BK26 ; v1(300.2,74.63) 300.2,75.77 299.69,76.28 298.29,76.28 297.66,75.64 v1(297.02,75.64)
DGPU_PWR_EN: length 226.8
  TOP w0.097: R108.2 225.65,67.77 225.78,67.64 225.78,64.75 v3(225.93,64.6) ; D2007.1 299.94,84.63 R2259.1 299.41,83.72 v1(299.23,83.9) ; v3(204.69,127.97) 204.77,128.04 207.41,128.04 208.5,126.95 PR2187.1 ; D2010.1 v2(295.37,66.63) 293.97,66.63 293.59,67.01 289.91,67.01 v1(288.77,68.15)
  IN05 w0.091: v1(255.24,69.8) 256,70.56 262.12,70.56 264.4,68.28 274.14,68.28 276.3,70.44 279.64,70.44 281.04,69.04 287.88,69.04 v1(288.77,68.15)
  IN08 w0.091: v1(255.24,69.8) 254.73,70.31 254.22,70.31 252.7,68.79 252.7,67.14 252.01,66.45 249.09,66.45 246.35,63.71 231.32,63.71 230.81,64.21 228.21,64.21 228.09,64.09 226.43,64.09 v3(225.93,64.6) 224.89,64.6 223.97,65.51 221.23,65.51 218.66,62.94 213.33,62.94 207.61,68.66 207.61,73.36 206.22,74.76 206.22,93.11 208.66,95.55 208.66,99.65 209.52,100.51 209.52,103.2 212.95,106.63 215.11,106.63 215.62,107.14 215.62,111.59 214.85,112.35 214.42,112.35 210.2,116.56 204.54,116.56 204.08,117.03 204.08,126.47 204.69,127.08 v3(204.69,127.97) ; v1(288.77,68.15) 288.77,67.14 288.39,66.75 287.24,66.75 286.74,66.25 286.74,62.56 287.24,62.06 291.43,62.06 293.21,63.83 293.21,66.63 295.75,69.17 295.75,73.36 294.48,74.63 294.48,79.71 298.67,83.9 v1(299.23,83.9)
  BOTTOM w0.097: U2.V44 226.18,64.84 v3(225.93,64.6)
DGPU_PWROK: length 323.1
  TOP w0.097: PU1605.38 295.24,185.23 295.64,185.63 v1(296.51,185.63) 296.72,185.83 300.3,185.83 PR3525.2 ; v1(299.56,69.55) 299.07,69.55 297.81,68.3 D2009.1 296.26,67.77 295.12,68.91 288.26,68.91 286.1,71.07 v1(286.1,71.33) 284.58,72.85 v2(284.58,73.61) 284.8,73.84 D2013.1 D69.1 R2263.1
  IN05 w0.091: v1(296.51,185.63) 296.9,185.25 296.9,179.53 303.63,172.8 303.63,164.16 305.66,162.13 305.66,122.51 305.02,121.87 305.02,110.82 304.13,109.93 304.13,109.17 303.63,108.66 302.78,108.66 301.68,107.56 301.68,104.72 303.63,102.77 303.63,101.73 306.12,99.24 306.12,94.14 304.26,92.28 304.26,91.59 303.75,91.08 303.75,83.26 303.25,82.76 303.25,82.63 302.86,82.25 302.86,80.47 v1(301.85,79.45)
  IN08 w0.091: v1(299.56,69.55) 300.71,70.69 300.71,78.31 v1(301.85,79.45) ; v1(257.53,68.91) 257.53,67.14 257.14,66.75 256.38,66.75 255.24,65.61 249.47,65.61 246.17,62.31 242.03,62.31 241.4,61.67 240.25,61.67 240.19,61.61 232.06,61.61 231.11,62.56 227.55,62.56 227.3,62.82 223.59,62.82 v1(221.81,64.6) 220.95,64.6 219.04,62.69 213.2,62.69 207.36,68.53 207.36,73.23 205.96,74.63 205.96,93.16 208.43,95.63 208.43,99.73 209.3,100.61 209.3,103.29 211.19,105.18 211.19,114.11 208.95,116.35 204.38,116.35 203.82,116.9 203.82,126.59 204.19,126.95 204.19,129.75 204.57,130.13 204.57,130.89 v1(204.06,131.4)
  IN10 w0.091: v1(286.1,71.33) 285.85,71.07 285.21,71.07 283.94,69.8 279.24,69.8 278.99,70.06 275.69,70.06 274.54,71.2 265.91,71.2 264,69.29 257.91,69.29 v1(257.53,68.91)
  BOTTOM w0.097: R270.2 222.14,64.93 v1(221.81,64.6) ; v1(204.06,131.4) 203.55,130.89 203.55,130.38 204.19,129.75 R1003.1
DGPU_PWROK_N: length 5.2
  BOTTOM w0.097: U2.R42 227.8,66.2 227.4,65.79 224.73,65.79 v2(224.47,65.52) 224.17,65.23 R270.1
DIFFOUT_1PH_A: length 3.6
  TOP w0.203: PU1101.16 124.73,187.84
  TOP w0.254: PR1195.2 123.9,185.25 PR1159.2 123.9,187 v2(123.91,187.01) 124.73,187.84
DIFFOUT_3PH_A: length 7.5
  TOP w0.203: v2(120.42,199.29) 121.25,199.29 PR1243.2 121.3,199.19 PR1157.2 121.3,197.88 123.15,196.04 124.18,196.04 124.73,195.48 PU1101.50
DIMM0_CHA_EVENT_N: length 2.5
  BOTTOM w0.097: JDIMM1.134 165.82,76.93 v2(165.83,76.91)
DIMM0_CHB_EVENT_N: length 2.9
  BOTTOM w0.097: JDIMM3.134 166.05,65.2 165.32,64.47 165.32,64.21 TP102.1
DIMM1_CHA_EVENT_N: length 2.2
  TOP w0.097: TP127.1 164.15,89.21 JDIMM2.134
DIMM1_CHB_EVENT_N: length 2.7
  TOP w0.097: JDIMM4.134 164.35,75.54 164.24,75.64 164.24,76.72 TP128.1
DIMM_SMB_CLK: length 43.8
  TOP w0.097: JDIMM2.253 195.9,78 v1(196.98,76.91)
  TOP w0.102: JDIMM4.253 196.1,65.02 v1(195.68,64.6)
  IN08 w0.091: v1(193.14,59.77) 193.77,60.4 193.77,61.29 195.73,63.25 195.73,64.54 v1(195.68,64.6) 195.68,66.88 195.8,67.01 195.8,75.73 v1(196.98,76.91) 195.8,78.1 195.8,88.69 v1(196.98,89.87)
  BOTTOM w0.097: v1(196.98,89.87) 197.07,89.87 197.57,89.37 JDIMM1.253 ; v1(196.98,76.91) 197.8,76.1 JDIMM3.253 ; R81.2 v1(193.14,59.77)
DIMM_SMB_DAT: length 50.9
  TOP w0.097: JDIMM2.254 196.15,88.5 196.03,88.62 196.03,88.94 v1(195.36,89.61) ; JDIMM4.254 196.35,75.37 196.76,75.77 197.14,75.77 197.52,76.15 197.52,76.66 198.03,77.17 v1(198.28,77.17)
  IN08 w0.091: v1(194.41,59.77) 194.84,60.2 194.84,61.09 195.8,62.06 195.8,62.82 196.11,63.12 196.11,64.85 196.49,65.23 197.33,65.23 197.96,64.6 v1(198.22,64.6) 198.22,65.23 196.06,67.39 196.06,74.5 197.71,76.15 197.71,76.6 v1(198.28,77.17) 197.43,78.02 197.37,78.02 196.06,79.33 196.06,87.23 197.43,88.6 197.43,90.1 197.2,90.33 196.07,90.33 v1(195.36,89.61)
  BOTTOM w0.097: R82.2 v1(194.41,59.77) ; JDIMM3.254 198.05,64.76 v1(198.22,64.6) ; v1(198.28,77.17) 197.82,77.63 JDIMM1.254
DMI_IT_MR_0_DN: length 105.9
  IN03 w0.114: v1(187.67,135.53) 188.37,136.22 198.21,136.22 202.8,131.64 202.8,129.98 203.8,128.98 204.64,128.98 205.45,128.17 205.45,127.87 209.84,123.49 209.84,116.86 208.88,115.9 208.88,114.51 209.02,114.37 209.02,107.79 208.12,106.89 208.12,100.16 207.81,99.85 207.81,92.48 206.85,91.52 206.85,87.2 208,86.06 210.54,86.06 213.82,82.77 226.21,82.77 231.04,77.93 233.42,77.93 233.65,77.7 234.82,77.7 235,77.88 v1(235,77.97)
  BOTTOM w0.076: U2.C27 235.71,72.4 235.71,73.17 235.83,73.3 235.83,73.67 235.89,73.72 235.89,73.74
  BOTTOM w0.104: 235.89,73.74 235.89,77.37 235.48,77.78 235.36,77.78 235.32,77.82 235.14,77.82 v1(235,77.97) ; v1(187.67,135.53) 187.35,135.2 U1.E8
DMI_IT_MR_0_DP: length 105.9
  IN03 w0.114: v1(235,77.15) 235,76.84 234.87,76.71 234.54,76.71 234.39,76.86 234.39,77.27 234.22,77.44 233.54,77.44 233.31,77.66 230.93,77.66 226.09,82.5 213.71,82.5 210.42,85.79 207.88,85.79 206.59,87.09 206.59,91.63 207.54,92.59 207.54,99.96 207.86,100.27 207.86,107 208.76,107.9 208.76,114.26 208.62,114.4 208.62,116.01 209.57,116.97 209.57,123.38 205.19,127.76 205.19,128.06 204.53,128.72 203.69,128.72 202.53,129.87 202.53,131.52 198.1,135.96 188.75,135.96 v1(188.32,135.53)
  BOTTOM w0.076: 235.63,73.74 235.63,73.72 235.68,73.67 235.68,73.36 235.55,73.23 235.55,72.85 U2.B27
  BOTTOM w0.104: U1.D8 188,135.2 v1(188.32,135.53) ; v1(235,77.15) 234.71,77.15 234.61,77.24 234.61,77.42 234.74,77.55 235.22,77.55 235.25,77.52 235.37,77.52 235.63,77.26 235.63,73.74
DMI_IT_MR_1_DN: length 104.3
  IN03 w0.076: 188.26,135.14 187.42,135.14 v1(187.02,134.74)
  IN03 w0.114: 188.26,135.14 188.39,135.02 189.7,135.02 189.85,135.17 197.89,135.17 201.54,131.52 201.54,129.35 203.79,127.09 204.93,127.09 208.12,123.9 208.12,121.24 207.63,120.74 207.63,119.06 208.01,118.68 208.01,116.6 207.23,115.83 207.23,102.63 206.67,102.06 206.67,92.99 205.96,92.28 205.96,86.44 207.36,85.04 210.03,85.04 213.19,81.88 225.76,81.88 231.03,76.61 233.49,76.61 v1(233.58,76.7)
  BOTTOM w0.076: U2.B28 234.84,72.51 235.38,73.05 235.38,73.46
  BOTTOM w0.104: v1(233.58,76.7) 234.96,76.7 235.25,76.41 235.25,73.59 235.38,73.46 ; v1(187.02,134.74) 186.67,134.39 U1.F6
DMI_IT_MR_1_DP: length 104.3
  IN03 w0.076: v1(187.67,134.74) 187.9,134.97 188.06,134.97 188.07,134.96
  IN03 w0.114: v1(233.58,75.8) 233.58,76.11 233.34,76.34 230.92,76.34 225.65,81.61 213.08,81.61 209.92,84.78 207.25,84.78 205.7,86.33 205.7,92.39 206.4,93.1 206.4,102.17 206.97,102.74 206.97,115.94 207.74,116.71 207.74,118.57 207.36,118.95 207.36,120.85 207.86,121.35 207.86,123.79 204.82,126.83 203.68,126.83 201.27,129.23 201.27,131.41 197.78,134.9 197.33,134.9 197.15,134.73 196.69,134.73 196.51,134.9 196.06,134.9 195.88,134.73 195.42,134.73 195.24,134.9 189.96,134.9 189.81,134.75 188.28,134.75 188.07,134.96
  BOTTOM w0.076: U2.A28 235.1,73 235.22,73.12 235.22,73.25 235.19,73.28
  BOTTOM w0.104: v1(187.67,134.74) 187.35,134.42 U1.E6 ; v1(233.58,75.8) 233.42,75.8 233.26,75.96 233.26,76.12 233.38,76.24 233.71,76.24 233.91,76.44 234.85,76.44 234.99,76.3 234.99,73.48 235.19,73.28
DMI_IT_MR_2_DN: length 99.4
  IN03 w0.114: v1(233.61,74.34) 233.32,74.63 232.76,74.63 232.38,75.01 230.98,75.01 230.36,75.63 225.92,75.63 220.84,80.71 212.58,80.71 209.52,83.77 206.6,83.77 204.68,85.69 204.68,93.21 205.51,94.04 205.51,116.31 206.28,117.08 206.28,122.07 205.46,122.89 205.46,123.78 196.01,133.23 188.28,133.23 188.06,133.46 188.06,133.57 v1(187.67,133.95)
  BOTTOM w0.076: U2.B29 234.27,72.58 234.21,72.64 234.21,72.77 234.51,73.08 234.51,74.04 234.46,74.1
  BOTTOM w0.104: v1(187.67,133.95) 187.35,133.63 U1.E5 ; 234.46,74.1 234.46,74.66 234.24,74.88 234.02,74.88 233.93,74.78 233.93,74.65 234.08,74.5 234.08,74.35 233.93,74.2 233.67,74.2 233.61,74.26 v1(233.61,74.34)
DMI_IT_MR_2_DP: length 99.4
  IN03 w0.114: v1(233.61,75.13) 233.37,74.9 232.87,74.9 232.49,75.28 231.09,75.28 230.47,75.9 226.03,75.9 220.95,80.98 212.69,80.98 209.63,84.04 206.71,84.04 204.95,85.8 204.95,93.1 205.78,93.93 205.78,116.2 206.55,116.97 206.55,122.18 205.72,123 205.72,123.89 196.12,133.49 188.92,133.49 188.77,133.65 188.77,134.24 188.67,134.34 188.41,134.34 188.32,134.25 v1(188.32,133.95)
  BOTTOM w0.076: U2.C29 234.59,72.34 234.59,72.56 234.67,72.64 234.67,74.09 234.72,74.14 234.72,74.15
  BOTTOM w0.104: v1(188.32,133.95) 188,133.63 U1.D5 ; v1(233.61,75.13) 234.35,75.13 234.72,74.76 234.72,74.15
DMI_IT_MR_3_DN: length 102.5
  IN03 w0.114: v3(234.13,73.23) 234.06,73.31 233.8,73.31 233.61,73.12 231.1,73.12 229.59,74.63 223.37,74.63 220.17,77.82 220.17,78.58 218.93,79.82 211.95,79.82 208.9,82.87 205.98,82.87 203.79,85.06 203.79,93.66 204.55,94.42 204.55,119.42 204.31,119.66 204.31,122.89 202.46,124.74 198.73,128.48 197.33,128.48 193.99,131.82 190.18,131.82 189.49,132.5 188.37,132.5 188.17,132.3 187.51,132.3 186.9,132.91 186.9,133.19 184.74,135.35 184.74,136 185.01,136.27 185.66,136.27 v1(185.71,136.32)
  BOTTOM w0.104: U2.B30 233.9,72.49 233.98,72.57 233.98,73.08 v3(234.13,73.23) ; v1(185.71,136.32) 185.42,136.03 U1.J9
DMI_IT_MR_3_DP: length 102.5
  IN03 w0.114: v1(185.61,135.68) 185.61,135.86 185.46,136.01 185.12,136.01 185.01,135.89 185.01,135.46 185.26,135.21 185.47,135.21 185.79,134.88 185.79,134.68 186.11,134.36 186.32,134.36 186.64,134.03 186.64,133.83 187.17,133.3 187.17,133.02 187.62,132.57 188.06,132.57 188.26,132.77 189.6,132.77 190.29,132.08 194.1,132.08 194.48,131.71 194.57,131.71 194.65,131.71 194.98,131.38 194.98,131.3 194.98,131.21 195.3,130.88 195.39,130.88 195.48,130.88 195.8,130.56 195.8,130.47 195.8,130.38 197.44,128.74 198.84,128.74 202.65,124.93 204.58,123 204.58,119.77 204.82,119.53 204.82,94.31 204.06,93.55 204.06,85.17 206.09,83.14 209.01,83.14 212.06,80.09 219.04,80.09 220.44,78.69 220.44,77.93 223.48,74.9 229.7,74.9 231.21,73.38 233.5,73.38 233.62,73.51 233.62,73.79 233.8,73.97 234.03,73.97 v3(234.13,73.87)
  BOTTOM w0.104: U2.A30 233.71,73.44 v3(234.13,73.87) ; U1.J8 185.39,135.36 185.61,135.58 v1(185.61,135.68)
DMI_MT_IR_0_DN: length 112.1
  IN10 w0.076: 236.67,71.53 236.67,71.51 ; 236.43,69.98 236.43,69.97 236.43,69.89 236.35,69.82 235.87,69.82 235.48,69.42 235.48,68.28 235.26,68.06 235.01,68.06 v3(234.79,68.28)
  IN10 w0.114: 236.67,71.53 236.67,78.07 235.79,78.95 230.73,78.95 229.95,78.17 222.1,78.17 221.84,78.44 220.95,78.44 220.37,77.87 215.43,77.87 213.82,79.47 213.82,83.79 212.81,84.81 212.81,85.92 213.57,86.68 213.57,91.16 211.51,93.21 211.51,94.23 210.34,95.4 210.34,106.32 209.52,107.14 209.52,117.81 209.25,118.08 209.25,124.93 208.49,125.7 208.49,128.11 206.74,129.86 203.82,129.86 202.03,131.65 197.58,131.65 196.5,132.74 196.5,133.24 195.97,133.77 193.93,133.77 v1(193.34,134.36) ; 236.67,71.51 236.67,70.21 236.43,69.98
  BOTTOM w0.076: U1.A8 189.83,135.02 189.68,135.02 189.58,135.12 189.58,135.28 189.75,135.45 191.66,135.45 192.18,134.93 192.31,134.93 192.36,134.88 192.37,134.88
  BOTTOM w0.104: 192.37,134.88 193.55,134.88 193.7,134.73 193.7,134.43 193.64,134.36 v1(193.34,134.36) ; v3(234.79,68.28) 235.31,68.28 235.43,68.15 U2.L27
DMI_MT_IR_0_DP: length 112.1
  IN10 w0.076: 236.93,71.53 236.93,71.51 ; 236.62,69.79 236.61,69.78 236.6,69.78 236.57,69.82 236.42,69.66 235.93,69.66 235.63,69.36 235.63,68.22 235.33,67.91 234.98,67.91 234.79,67.72 v3(234.79,67.64)
  IN10 w0.114: 236.93,71.53 236.93,78.18 235.9,79.21 230.62,79.21 229.84,78.44 222.22,78.44 221.95,78.71 220.83,78.71 220.26,78.13 215.54,78.13 214.09,79.58 214.09,83.9 213.08,84.92 213.08,85.8 213.84,86.57 213.84,91.27 211.78,93.32 211.78,94.34 210.6,95.51 210.6,106.43 209.79,107.25 209.79,117.92 209.52,118.19 209.52,125.04 208.76,125.81 208.76,128.22 206.85,130.13 203.93,130.13 202.14,131.92 197.69,131.92 196.77,132.85 196.77,133.35 196.08,134.04 194.43,134.04 v1(194.1,134.36) ; 236.62,69.79 236.93,70.1 236.93,71.51
  BOTTOM w0.076: U1.B8 189.43,135.27 189.43,135.35 189.69,135.6 191.72,135.6 192.25,135.08 192.31,135.08 192.36,135.13 192.37,135.13
  BOTTOM w0.104: v3(234.79,67.64) 235.1,67.64 U2.N27 ; 192.37,135.13 193.66,135.13 193.96,134.83 193.96,134.5 v1(194.1,134.36)
DMI_MT_IR_1_DN: length 107.9
  IN10 w0.114: v3(236.04,70.95) 236.04,71.03 235.96,71.11 235.95,71.11 234.91,72.16 234.91,76.11 233.21,77.81 231.87,77.81 231.04,76.98 214.54,76.98 212.69,78.82 212.69,83.38 211.79,84.28 211.79,86.42 212.55,87.19 212.55,90.41 210.42,92.54 210.15,92.54 209.52,93.17 209.52,94.06 208.74,94.83 208.74,101.16 209.27,101.68 209.27,105.87 208.63,106.51 208.63,116.29 207.86,117.06 207.86,118.33 207.23,118.96 207.23,119.97 208.36,121.1 208.36,124.3 207.36,125.3 207.36,127.46 206.73,128.1 205.84,128.1 205.34,128.59 203.55,128.59 202.1,130.04 196.66,130.04 195.31,131.39 195.31,132.79 195,133.09 192.24,133.09 191.55,133.79 191.03,133.79 190.9,133.92 190.9,134.34 190.98,134.42 191.12,134.42 v1(191.18,134.36)
  BOTTOM w0.076: v1(191.18,134.36) 191.45,134.36 191.55,134.46 191.55,134.68 191.4,134.83 190.36,134.83 190.2,134.67 189.06,134.67 188.98,134.59 188.98,134.36 189.07,134.27 189.22,134.27 U1.B6
  BOTTOM w0.104: v3(236.04,70.95) 236.36,70.95 U2.E24
DMI_MT_IR_1_DP: length 107.9
  IN10 w0.114: v1(191.94,134.36) 191.94,133.77 192.35,133.36 195.11,133.36 195.57,132.9 195.57,131.5 196.77,130.31 202.21,130.31 203.66,128.86 205.45,128.86 205.95,128.36 206.84,128.36 207.63,127.58 207.63,125.41 208.63,124.41 208.63,120.99 207.5,119.86 207.5,119.07 208.12,118.44 208.12,117.17 208.9,116.4 208.9,106.62 209.53,105.98 209.53,101.57 209.01,101.05 209.01,94.94 209.79,94.17 209.79,93.28 210.26,92.8 210.54,92.8 212.82,90.52 212.82,87.07 212.06,86.31 212.06,84.39 212.96,83.49 212.96,78.93 214.65,77.24 230.93,77.24 231.76,78.08 233.32,78.08 235.17,76.22 235.17,72.27 236.06,71.38 236.21,71.38 236.44,71.15 236.44,70.72 v3(236.04,70.31)
  BOTTOM w0.076: U1.C6 188.82,134.52 188.82,134.65 189,134.82 190.14,134.82 190.3,134.98 191.46,134.98 191.7,134.74 191.7,134.6 v1(191.94,134.36)
  BOTTOM w0.104: U2.G24 236.43,70.25 236.1,70.25 v3(236.04,70.31)
DMI_MT_IR_2_DN: length 101.8
  IN10 w0.114: v1(193.29,132.54) 193.43,132.4 193.43,131.87 196.84,128.46 201.92,128.46 203.57,126.81 205.22,126.81 205.57,126.46 205.57,125.7 207.47,123.79 207.47,121.48 206.34,120.34 206.34,117.05 207.36,116.03 207.36,106.69 207.6,106.45 207.6,93.19 209.15,91.63 209.92,91.63 211.54,90.01 211.54,87.44 210.52,86.42 210.52,84.04 211.67,82.9 211.67,78.07 213.65,76.09 220,76.09 220.57,75.52 229.84,75.52 232.76,72.6 233.14,72.6 234.18,71.56 234.18,70.52 234.43,70.27 234.84,70.27 v3(234.92,70.18)
  BOTTOM w0.076: 191.36,133.69 191.36,133.69 191.3,133.75 190.11,133.75 U1.A5
  BOTTOM w0.104: v1(193.29,132.54) 193.29,132.19 193.41,132.07 193.57,132.07 193.69,132.19 193.69,133 193.37,133.33 192.27,133.33 191.91,133.69 191.36,133.69 ; v3(234.92,70.18) 234.94,70.16 235.35,70.16 235.43,70.25 U2.G27
DMI_MT_IR_2_DP: length 101.8
  IN10 w0.114: v3(234.92,70.82) 234.92,70.7 234.75,70.53 234.54,70.53 234.45,70.63 234.45,71.67 233.25,72.86 232.87,72.86 229.95,75.78 220.68,75.78 220.11,76.36 213.76,76.36 211.93,78.18 211.93,83.01 210.79,84.15 210.79,86.31 211.81,87.33 211.81,90.12 210.03,91.9 209.27,91.9 207.87,93.3 207.87,106.56 207.63,106.8 207.63,116.14 206.61,117.16 206.61,120.23 207.74,121.36 207.74,123.9 205.84,125.81 205.84,126.57 205.33,127.08 203.68,127.08 202.03,128.73 196.95,128.73 193.7,131.98 193.7,132.44 193.8,132.54 v1(194.1,132.54)
  BOTTOM w0.076: 191.36,133.94 191.31,133.9 189.79,133.9 189.46,133.56 U1.B5
  BOTTOM w0.104: 191.36,133.94 192.01,133.94 192.37,133.58 193.47,133.58 193.95,133.11 193.95,132.69 v1(194.1,132.54) ; U2.E26 235.23,70.82 v3(234.92,70.82)
DMI_MT_IR_3_DN: length 101.1
  IN10 w0.114: v3(233.65,68.28) 233.45,68.48 233.22,68.48 232.98,68.72 232.98,69.63 233.09,69.74 233.09,71.28 232.71,71.66 230.26,71.66 227.44,74.49 220.08,74.49 219.37,75.2 212.89,75.2 210.52,77.57 210.52,82.77 207.22,86.07 207.22,91.92 206.33,92.81 206.33,102.11 206.71,102.49 206.71,105.89 206.46,106.14 206.46,115.15 205.07,116.53 205.07,120.48 205.57,120.97 205.57,122.38 205.33,122.62 205.33,123.53 201.41,127.45 196.33,127.45 193.03,130.75 191.88,130.75 191.27,131.36 191.27,132.45 v1(191.18,132.54)
  BOTTOM w0.076: U1.B4 188.76,132.85 188.67,132.76 188.67,132.63 188.76,132.54 189.12,132.54 189.7,133.12 190.14,133.12 190.2,133.06 190.22,133.06
  BOTTOM w0.104: v1(191.18,132.54) 191.5,132.54 191.55,132.59 191.55,132.88 191.36,133.06 190.22,133.06 ; U2.L29 234.05,68.28 v3(233.65,68.28)
DMI_MT_IR_3_DP: length 101.1
  IN10 w0.114: v1(191.94,132.54) 192.12,132.36 192.12,132.08 191.99,131.96 191.7,131.96 191.53,131.79 191.53,131.47 191.99,131.02 193.14,131.02 196.44,127.71 201.52,127.71 205.6,123.64 205.6,122.73 205.84,122.49 205.84,120.86 205.34,120.37 205.34,116.64 206.73,115.26 206.73,106.25 206.98,106 206.98,102.38 206.6,102 206.6,92.92 207.49,92.03 207.49,86.18 210.79,82.88 210.79,77.68 213,75.47 219.48,75.47 220.19,74.76 227.55,74.76 230.37,71.93 232.82,71.93 233.35,71.4 233.35,69.62 233.25,69.52 233.25,68.83 233.33,68.74 233.48,68.74 v3(233.65,68.91)
  BOTTOM w0.076: 190.22,133.32 190.21,133.32 190.15,133.27 188.85,133.27 U1.D4
  BOTTOM w0.104: 190.22,133.32 191.47,133.32 191.81,132.98 191.81,132.68 v1(191.94,132.54) ; v3(233.65,68.91) 233.73,68.99 234.09,68.99 U2.K29
DMIC_CLK: length 317
  TOP w0.097: R293.1 284.53,40.72 v2(283.81,40.72) 283.18,40.72 282.67,40.21 v1(282.67,40.08) ; v1(181.71,50.88) 180.94,50.12 v1(180.94,40.72)
  IN08 w0.091: v1(282.67,40.08) 282.04,39.45 279.62,39.45 279.12,38.94 267.3,38.94 263.49,42.75 260.45,42.75 256.74,39.04 214.86,39.04 211.45,42.45 203.85,42.45 201.13,39.73 181.93,39.73 v1(180.94,40.72) ; v1(181.71,50.88) 182.85,52.02 182.85,55.96 178.4,60.4 178.4,64.85 177.52,65.74 177.52,109.74 195.93,128.15 195.93,131.27 196.7,132.04 196.7,148 198.47,149.77 198.47,154.64 199.49,155.65 199.49,162.13 197.62,164 197.62,183.09 198.93,184.4 198.93,189.81 195.93,192.81 179.34,192.81 177.22,194.94 170.7,194.94 168.5,197.13 163.24,197.13 162.91,196.8 v1(162.91,195.79)
  BOTTOM w0.097: JCAM1.6 163.11,196.88 162.91,196.68 v1(162.91,195.79) ; C338.2 283.61,39.14 v1(282.67,40.08)
DMIC_CLK_R: length 3.4
  TOP w0.097: R293.2 284.96,38.72 285.37,38.31 285.95,38.31 286.73,37.52 U7.53
DMIC_DATA: length 310.8
  TOP w0.097: R295.1 283.1,39.58 v1(283.56,40.03) ; v1(180.18,40.72) 180.44,40.97 v1(180.44,50.88)
  IN08 w0.091: v1(180.44,50.88) 180.44,55.56 177.39,58.6 177.39,63.58 177.08,63.88 177.08,65.28 177.01,65.36 177.01,109.64 195.68,128.31 195.68,131.27 196.31,131.91 196.31,148.16 198.09,149.94 198.09,154.89 199.11,155.91 199.11,161.88 197.33,163.66 197.33,183.21 198.64,184.52 198.64,189.69 195.81,192.51 179.14,192.51 177.01,194.64 170.57,194.64 169.24,195.98 164.24,195.98 v1(163.55,196.68) ; v1(180.18,40.72) 181.48,39.42 201.26,39.42 203.98,42.14 211.33,42.14 214.73,38.74 256.94,38.74 260.57,42.37 263.37,42.37 267.18,38.56 279.24,38.56 279.75,39.07 282.59,39.07 v1(283.56,40.03)
  BOTTOM w0.097: v1(163.55,196.68) 163.71,196.84 JCAM1.7
DMIC_DATA_R: length 3.6
  TOP w0.097: R295.2 284.45,38.89 284.45,38.69 v2(284.87,38.27) 285.13,38 285.82,38 286.33,37.49 U7.54
DP_AUX_C_DN_SDA: length 3.7
  TOP w0.097: JDP1.17 14.46,160.8 14.82,160.44 14.99,160.44 15.17,160.62 15.36,160.62 D24.2 15.73,160.99 R406.2
DP_AUX_C_DP_SCL: length 3.6
  TOP w0.097: R405.2 15.73,160.1 D23.2 15.48,160.35 15.29,160.35 15.1,160.16 14.82,160.16 14.46,159.8 JDP1.15
DP_AUX_OUT_DN_SDA: length 114.9
  TOP w0.097: R406.1 17.88,160.99 17.9,160.96 R410.1 v1(19.15,160.96)
  IN03 w0.102: v1(19.15,160.96) 19.15,160.68 19,160.53 18.23,160.53 17.75,160.05 17.75,150.7 18.52,149.93 18.52,124.55 42.92,100.16 53.69,100.16 57.37,96.47 70.48,96.47 71.36,95.58 71.85,95.58 74.39,93.04 75.66,93.04 76.42,92.28 76.42,91.27 76.04,90.88 75.13,90.88 75,91.01 75,91.43 75.25,91.67 v1(75.28,91.67)
  BOTTOM w0.102: U2016.2 75.23,91.62 v1(75.28,91.67)
DP_AUX_OUT_DP_SCL: length 115
  TOP w0.097: v1(19.15,160.13) R411.1 17.9,160.13 17.88,160.1 R405.1
  IN03 w0.102: v1(74.65,91.67) 74.75,91.57 74.75,91.53 74.75,90.91 75.02,90.63 76.15,90.63 76.68,91.16 76.68,92.39 75.77,93.3 74.5,93.3 71.96,95.84 71.47,95.84 70.58,96.73 57.48,96.73 53.8,100.41 43.02,100.41 18.77,124.66 18.77,150.04 18,150.81 18,159.95 18.33,160.28 18.99,160.28 v1(19.15,160.13)
  BOTTOM w0.102: U2016.1 74.83,91.49 v1(74.65,91.67)
DP_HPD_CON: length 135.7
  TOP w0.097: R997.1 66.26,75.9 v1(67.15,75.01) ; JDP1.18 11.84,161.3 v1(11.78,161.24)
  IN05 w0.091: v1(11.78,161.24) 8.99,158.45 8.99,144.1 10.63,142.46 10.63,128.11 11.27,127.46 11.27,121.36 10,120.09 10,118.82 10.76,118.06 16.99,118.06 17.38,117.67 21.34,117.67 38.07,100.95 38.07,95.96 39.97,94.06 49.63,94.06 50.77,92.92 53.69,92.92 54.33,92.28 54.33,92.03 54.71,91.65 55.09,91.65 56.36,90.38 56.36,89.23 64.23,81.36 67.15,81.36 68.93,79.58 68.93,75.77 68.17,75.01 v1(67.15,75.01)
  BOTTOM w0.097: v1(11.78,161.24) 11.97,161.05 D22.2 13.16,161.12 R409.1
DP_TX0_C_DN: length 4.9
  TOP w0.097: C467.2 17.45,152.78 17.33,152.78 17.06,153.05 16.93,153.05 16.7,153.28 D2018.7 D2018.4 15.65,153.28 15.58,153.21 15.24,153.21 15.08,153.37 14.89,153.37 14.46,153.8 JDP1.3
DP_TX0_C_DP: length 4.9
  TOP w0.097: JDP1.1 14.46,152.8 14.76,153.09 14.97,153.09 15.12,152.94 15.65,152.94 D2018.5 D2018.6 16.95,152.78 17.22,152.5 17.33,152.5 17.67,152.16 C466.2
DP_TX0_OUT_DN: length 93.7
  TOP w0.097: C467.1 18.59,152.92 18.87,152.63 19.17,152.63 v3(19.27,152.73)
  IN05 w0.102: v3(19.27,152.73) 19.19,152.65 17.9,152.65 17.62,152.38 17.62,145.62 18.38,144.86 18.38,126.44 19.4,125.43 19.4,124.69 41.65,102.44 47.59,102.44 49.12,100.92 52.55,100.92 56.99,96.47 59.28,96.47 59.53,96.22 61.84,96.22 62.45,95.6 62.45,92.96 63.48,91.94 64.77,91.94 v1(64.99,91.71)
  BOTTOM w0.097: U2015.34 66.35,91.87 66.24,91.98 65.26,91.98 v1(64.99,91.71)
DP_TX0_OUT_DP: length 93.7
  TOP w0.097: C466.1 18.84,152.36 19.09,152.36 19.26,152.18 v3(19.26,152.11)
  IN05 w0.102: v3(19.26,152.11) 19.26,151.95 19.16,151.85 18.93,151.85 18.84,151.94 18.84,152.23 18.67,152.4 18,152.4 17.88,152.27 17.88,145.73 18.64,144.97 18.64,126.55 19.65,125.53 19.65,124.79 41.75,102.7 47.7,102.7 49.22,101.17 52.65,101.17 57.1,96.73 59.38,96.73 59.64,96.47 61.94,96.47 62.71,95.71 62.71,93.06 63.58,92.19 64.99,92.19 65.06,92.26 65.06,92.46 v1(64.99,92.53)
  BOTTOM w0.097: U2015.35 66.35,92.37 66.24,92.26 65.27,92.26 v1(64.99,92.53)
DP_TX1_C_DN: length 4.8
  TOP w0.097: JDP1.6 14.47,155.3 14.83,154.94 15.07,154.94 15.37,154.64 15.68,154.64 D2018.1 D2018.10 16.82,154.78 17.05,154.55 17.44,154.55 17.56,154.66 C469.2
DP_TX1_C_DP: length 4.8
  TOP w0.097: JDP1.4 14.49,154.3 14.85,154.66 14.96,154.66 15.25,154.36 15.73,154.36 D2018.2 D2018.9 17.36,154.28 17.67,153.96 C468.2
DP_TX1_OUT_DN: length 99.8
  TOP w0.097: v3(19.26,154.73) 19.26,154.68 19.1,154.52 18.85,154.52 C469.1
  IN05 w0.102: v1(64.99,90.21) 64.76,90.44 63.28,90.44 62.45,91.27 61.33,91.27 60.55,92.05 60.55,94.46 59.93,95.08 59.3,95.08 58.92,95.46 56.37,95.46 55.1,96.73 54.83,96.73 54.33,97.23 54.33,97.87 53.82,98.38 51.4,98.38 51.02,98.76 51.02,99.65 50.64,100.03 48.48,100.03 46.96,101.55 41.23,101.55 18.26,124.53 18.26,124.81 16.1,126.97 16.1,133.68 15.84,133.94 15.84,136.86 16.1,137.11 16.1,153.73 17.07,154.7 19.23,154.7 v3(19.26,154.73)
  BOTTOM w0.097: v1(64.99,90.21) 65.26,90.48 66.24,90.48 66.35,90.37 U2015.31
DP_TX1_OUT_DP: length 99.8
  TOP w0.097: v3(19.27,154.13) 19.16,154.25 18.92,154.25 18.59,153.91 C468.1
  IN05 w0.102: v3(19.27,154.13) 19.27,154.01 19.2,153.94 18.94,153.94 18.85,154.03 18.85,154.28 18.69,154.44 17.17,154.44 16.35,153.62 16.35,137.01 16.1,136.75 16.1,134.04 16.35,133.79 16.35,127.08 18.51,124.92 18.51,124.63 41.34,101.81 47.06,101.81 48.59,100.28 50.75,100.28 51.28,99.75 51.28,98.86 51.51,98.63 53.92,98.63 54.58,97.98 54.58,97.34 54.94,96.98 55.2,96.98 56.47,95.71 59.02,95.71 59.41,95.33 60.04,95.33 60.8,94.57 60.8,92.15 61.44,91.52 62.56,91.52 63.38,90.69 64.97,90.69 65.11,90.83 65.11,90.95 65.03,91.03 v1(64.99,91.03)
  BOTTOM w0.097: v1(64.99,91.03) 65.27,90.76 66.24,90.76 66.35,90.87 U2015.32
DP_TX2_C_DN: length 4.8
  TOP w0.097: JDP1.9 14.53,156.8 14.89,156.44 15.14,156.44 15.22,156.52 15.63,156.52 D2019.4 D2019.7 16.75,156.68 16.9,156.53 17.09,156.53 17.33,156.28 17.4,156.28 C471.2
DP_TX2_C_DP: length 4.8
  TOP w0.097: JDP1.7 14.53,155.8 14.89,156.16 15.25,156.16 15.34,156.25 15.72,156.25 D2019.5 D2019.6 16.73,156.18 16.81,156.25 16.97,156.25 17.22,156.01 17.33,156.01 C470.2
DP_TX2_OUT_DN: length 106.8
  TOP w0.097: v3(19.26,156.56) 19.26,156.46 19.1,156.29 18.85,156.29 C471.1
  IN05 w0.102: v3(19.26,156.56) 19.23,156.53 16.48,156.53 14.32,154.36 14.32,142.07 14.57,141.81 14.57,133.45 14.96,133.07 14.96,125.81 18.51,122.25 19.17,122.25 40.76,100.66 46.32,100.66 49.5,97.49 52.04,97.49 53.94,95.58 54.96,95.58 55.21,95.33 55.21,94.06 55.6,93.68 58.14,93.68 59.53,92.28 59.53,88.73 60.55,87.71 63.34,87.71 63.85,88.22 63.85,88.55 64.23,88.93 64.77,88.93 v1(64.99,88.71)
  BOTTOM w0.097: U2015.28 66.35,88.87 66.24,88.98 65.26,88.98 v1(64.99,88.71)
DP_TX2_OUT_DP: length 106.8
  TOP w0.097: C470.1 18.59,155.78 18.83,156.02 19.16,156.02 v3(19.27,155.91)
  IN05 w0.102: v3(19.27,155.91) 19.27,155.83 19.16,155.72 18.94,155.72 18.85,155.8 18.85,156.14 18.72,156.27 16.59,156.27 14.57,154.26 14.57,142.17 14.83,141.92 14.83,133.56 15.21,133.18 15.21,125.92 18.62,122.51 19.28,122.51 40.87,100.92 46.43,100.92 49.6,97.74 52.14,97.74 54.05,95.84 55.07,95.84 55.47,95.44 55.47,94.17 55.7,93.93 58.24,93.93 59.79,92.39 59.79,88.83 60.65,87.96 63.24,87.96 63.6,88.32 63.6,88.65 64.12,89.18 64.97,89.18 65.05,89.26 65.05,89.47 v1(64.99,89.53)
  BOTTOM w0.097: v1(64.99,89.53) 65.27,89.26 66.24,89.26 66.35,89.37 U2015.29
DP_TX3_C_DN: length 4.7
  TOP w0.097: C473.2 17.39,158.05 16.9,158.05 16.77,158.18 D2019.10 D2019.1 15.62,158.01 14.76,158.01 14.47,158.3 JDP1.12
DP_TX3_C_DP: length 4.7
  TOP w0.097: JDP1.10 14.55,157.3 14.98,157.74 15.73,157.74 D2019.2 D2019.9 16.72,157.68 16.82,157.77 17.34,157.77 C472.2
DP_TX3_OUT_DN: length 111.7
  TOP w0.097: v3(19.26,158.33) 19.26,158.28 19.06,158.09 18.83,158.09 C473.1
  IN05 w0.102: v1(65.12,87.21) 64.94,87.39 64.29,87.39 63.09,86.19 60.68,86.19 58.52,88.34 58.52,92.05 58.15,92.41 56.76,92.41 56.38,92.79 55.24,92.79 54.22,93.81 51.81,93.81 45.84,99.77 40.41,99.77 20.21,119.97 19.02,119.97 12.49,126.49 12.49,155.71 15.12,158.33 v3(19.26,158.33)
  BOTTOM w0.097: U2015.25 66.35,87.37 66.24,87.48 65.39,87.48 v1(65.12,87.21)
