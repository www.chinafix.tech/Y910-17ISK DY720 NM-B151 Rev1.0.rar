# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
TP147  -  [TPC40]  48.36 49.86 180 bottom
TP152  -  [TPC40]  50.52 49.86 180 bottom
TP153  -  [TPC40]  63.22 3.38 180 bottom
TP154  -  [TPC40]  61.06 6.43 180 bottom
TP155  -  [TPC12]  70.2 20.27 0 top
TP160  -  [TPC12]  223.11 61.17 180 bottom
TP161  -  [TPC12]  70.33 19.26 0 top
TP168  -  [TPC12]  231.11 61.67 0 top
TP169  -  [TPC12]  229.33 61.55 0 top
TP170  -  [TPC12]  223.87 63.33 180 bottom
TP171  -  [TPC12]  223.49 62.31 180 bottom
TP181  -  [TPC12]  56.87 46.82 90 bottom
TP182  -  [TPC12]  55.72 45.93 90 bottom
TP184  -  [TPC12]  238.98 55.07 0 top
TP185  -  [TPC12]  61.06 66.75 90 bottom
TP186  -  [TPC12]  74.52 67.39 90 bottom
TP187  -  [TPC12]  64.23 57.1 90 bottom
U1  -  [BGA1445_SKL_HALO_28X42MM_MPI]  169.63 144.13 270 bottom
U2  -  [SPT_H_BOP_23X23MM]  237.21 62.18 0 bottom
U3  -  [W25Q64FVSSIG_SO8]  217.65 49.79 180 bottom
U4  -  [SOT353-0_65-1_35X2_25X1_1MM]  247.46 46.15 270 bottom
U5  -  [IT8586VG-AX_VFBGA_128P]  32.27 49.91 0 bottom
U6  -  [QFN41P-0_4-5X5X0_9MM]  46.96 62.69 180 top
U7  -  [ALC286-CG_QFN56_7X7]  284.66 36.21 0 top
U8  -  [TSOP49P-0_5-12_5X6_1-1_2MM]  272.38 31.7 270 top
U9  -  [SSOP29P-0_65-9_7X4_4X1_2MM]  282.93 49.99 270 top
U14  -  [QFN21P-0_5-4X4-0_75MM]  282.29 64.72 270 top
U16  -  [W25Q64FVSSIG_SO8]  41.56 6.18 270 top
U18  v*  [TPS2553DRV_SON6_2X2]  18.32 69.1 90 top
U19  -  [IT8586VG-AX_VFBGA_128P]  68.6 7.37 90 top
U21  -  [TPS2546RTER_QFN16_4X4]  23.36 39.21 90 top
U22  -  [QFN20P-0_4-3X2-0_6MM]  53.31 43.77 180 bottom
U23  -  [BGA8-TMP006]  82.65 97.24 0 top
U24  -  [BGA8-TMP006]  273.02 10.75 0 top
U25  -  [TSSOP10P-0_5-3X3-1_1MM]  206.09 111.84 0 bottom
U26  -  [SOT353-0_65-1_35X2_25X1_1MM]  43.94 44.43 90 bottom
U48  -  [BGA170-HYNIX-H5GC2H24BFR]  256.51 171.15 270 bottom
U50  v*  [TPS2553DRV_SON6_2X2]  59.98 11.45 180 bottom
U51  -  [SOT-2_8-1_9-3P]  4.41 144.73 90 top
U55  -  [BGA170-HYNIX-H5GC2H24BFR]  273.53 171.15 90 bottom
U56  -  [SOT353-0_65-1_35X2_25X1_1MM]  108.86 95.79 180 top
U58  -  [SOT353-0_65-1_35X2_25X1_1MM]  45.69 35.51 90 bottom
U59  -  [SOT353-0_65-1_35X2_25X1_1MM]  137.91 148.55 180 bottom
U60  -  [BGA170-HYNIX-H5GC2H24BFR]  267.43 91.52 270 bottom
U61  -  [SOT353-0_65-1_35X2_25X1_1MM]  44.42 41.1 270 bottom
U62  -  [SOT353-0_65-1_35X2_25X1_1MM]  303.12 75.01 180 top
U63  -  [SOT353-0_65-1_35X2_25X1_1MM]  303.25 71.07 180 top
U2005  -  [BGA337-INTEL-H38212]  50.9 86.06 0 bottom
U2007  -  [BGA96-TEXAS-TPS65982]  33.75 74.88 180 bottom
U2011  -  [74AUP1G04GF_SOT891-6_1X1]  27.37 79.42 180 top
U2012  -  [W25Q64FVSSIG_SO8]  53.06 93.23 180 bottom
U2013  -  [QFN48P-0_5-7X7X0_85MM]  78.03 68.61 180 bottom
U2014  -  [QFN48P-0_5-7X7X0_85MM]  68.38 58.45 180 bottom
U2015  -  [TQFN42P-0_5-9X3_5X0_84MM]  68.17 89.87 180 bottom
U2016  -  [TQFN10P-0_4-1_6X1_3X0_75MM]  75.03 90.38 270 bottom
U2019  -  [TQFN42P-0_5-9X3_5X0_8MM]  81.76 85.3 180 bottom
U2021  -  [SOP8-1_27-5X4X1_75MM]  286.1 85.8 0 bottom
U2022  -  [BGA170-HYNIX-H5GC2H24BFR]  238.48 171.15 90 bottom
U2023  -  [BGA170-HYNIX-H5GC2H24BFR]  294.1 151.34 180 bottom
U2024  -  [BGA170-HYNIX-H5GC2H24BFR]  294.23 134.32 0 bottom
U2025  -  [BGA170-HYNIX-H5GC2H24BFR]  294.23 116.28 180 bottom
U2026  -  [BGA170-HYNIX-H5GC2H24BFR]  249.27 91.52 90 bottom
U2027  -  [SOT353-0_65-1_35X2_25X1_1MM]  204.06 199.09 90 top
U2028  -  [SOT353-0_65-1_35X2_25X1_1MM]  208.99 200.1 180 top
U2029  -  [SOT353-0_65-1_35X2_25X1_1MM]  208.12 164.54 0 top
U2030  v*  [TPS2553DRV_SON6_2X2]  15.08 146.76 0 top
U2031  v*  [TPS2553DRV_SON6_2X2]  86.14 75.45 0 top
Y1  -  [Y_CM8V-T1A_2P]  244.06 44.66 180 bottom
Y2  -  [Y_EXS00A-CS07257_4P]  247.37 78.44 0 bottom
Y4  -  [Y_EXS00A-CS07257_4P]  46.32 69.93 0 top
Y6  27MHZ_10PF_7V27000050  [Y_7V27000011_4P]  219.03 113.91 90 bottom
Y2001  -  [Y_EXS00A-CS07257_4P]  44.8 76.66 180 bottom

## Library data of the parts
C1-C6 C10-C15 C17 C19-C24 C31-C33 C35-C38 C54-C64 C67-C70 C85 C86 C88-C97 C102 C119-C130 C133-C136 C151 C152 C154-C163 C166 C170-C209 C212 C215 C219-C239 C241-C249 C252-C254 C256-C290 C293 C295 C297 C299 C302-C310 C313-C318 C320-C339 C345 C346 C358 C359 C361-C365 C373-C382 C416 C418 C419 C421 C422 C424-C428 C434-C439 C448 C450-C457 C465 C472 C473 C541 C543 C544 C549-C552 C554-C557 C560-C572 C574-C581 C599 C602 C605 C606 C625 C627-C631 C641 C642 C644 C650 C653 C662-C664 C670-C674 C699 C871-C873 C919-C928 C930-C937 C949 C974-C988 C1007-C1021 C1330 C1332 C1333 C1339 C1340 C1342 C1359 C1361-C1365 C1367-C1370 C1372 C1376-C1378 C1385 C1391 PC103-PC105 PC107 PC108 PC203 PC207 PC212 PC213 PC216-PC219 PC221-PC223 PC317 PC402 PC412 PC416 PC419 PC421 PC428 PC433 PC435 PC501 PC511 PC515 PC676 PC677 PC704 PC717 PC720 PC721 PC801 PC820 PC927 PC1027 PC1130 PC1140 PC1145 PC1147 PC1148 PC1152 PC1154 PC1155 PC1157 PC1159 PC1162 PC1163 PC1166 PC1167 PC1251 PC1254-PC1260 PC1269 PC1280 PC1302 PC1306 PC1307 PC1310-PC1314 PC1319 PC1323 PC1325 PC1327 PC1512 PC1520 PC1532 PC1541 PC1545-PC1548 PC1610 PC1619 PC1629 PC1638 PC1646 PC1648 PC1651 PC1659 PC1664-PC1667 = C_0402NEW: signal model: C_0402NEW-2
C7-C9 C16 C18 = C_0402NEW: signal model: C_0402NEW-2; room: THERMAL
C25-C30 = C_0402NEW: signal model: C_0402NEW-2; room: CRT
C34 C39 C72 C87 C138 C941 C942 C952-C954 C1178-C1180 C1335 C1371 C2120 C2175 C2440 C2441 PC312 PC318-PC322 PC408 PC409 PC724 PC725 PC730 PC731 PC938-PC940 = C_B2
C40 C41 C43 C49 = C_0603NEW: room: LVDS
C42 C48 C50 C65 C66 C73-C84 C98 C99 C111 C113 C131 C132 C137 C139-C150 C164 C165 C210 C211 C213 C214 C216 C217 C250 C251 C255 C292 C294 C296 C298 C319 C433 C449 C529 C542 C553 C558 C559 C573 C592-C595 C603 C604 C607-C616 C632 C659-C661 C694 C915-C918 C955-C962 C1379 C1386 C1392 C1393 C2103-C2105 C2113-C2116 C2119 C2136 C2172 C2176-C2188 C2320 C2322 C2323 C2333 C2342 C2352 C2354 C2371 C2375 C2380 C2383 C2388 C2390 C2394-C2397 C2408 C2409 C2448-C2458 C2477-C2487 C2514-C2524 C2535-C2545 C2572-C2582 C2593-C2603 C2630-C2640 C2651-C2661 C2684 C2689 C2690 PC10 PC11 PC205 PC206 PC214 PC215 PC220 PC224 PC309 PC310 PC313-PC316 PC424 PC434 PC437 PC504 PC718 PC719 PC1156 PC1253 PC1264 PC1265 PC1301 PC1305 PC1315 PC1802-PC1809 PC1811 PC3532 PC3533 PC3539 PC3580 = C_0603NEW
C44 C45 = C_0603NEW: room: TPM
C46 C47 C347 = C_0603NEW: room: HDMI
C51 = C_0603NEW: room: USH
C52 C53 = C_0402NEW: signal model: C_0402NEW-2; room: USH
C71 C398-C401 C405-C407 C475-C497 C500 C504-C509 C512 C514 C525-C528 C530 C531 C537-C540 C582 C583 C621 C648 C695 C868-C870 C874-C890 C907-C910 C1326 C1329 C1338 C1341 C1353-C1355 C1373-C1375 C1399-C1402 C2046 C2048 C2085-C2088 C2100 C2109 C2110 C2122-C2126 C2133 C2134 C2139 C2153 C2154 C2166-C2171 C2221 C2222 C2425 C2439 C2459-C2476 C2488-C2513 C2525-C2534 C2546-C2571 C2583-C2592 C2604-C2629 C2641-C2650 C2662-C2680 C2682 C2683 C2685-C2688 C2692-C2696 C2701 C2715-C2724 PC9 PC12 PC13 PC15 PC190-PC192 PC231 PC301 PC601 PC626 PC803 PC809 PC901 PC911 PC917 PC972 PC973 PC1001 PC1011 PC1017 PC1022 PC1036 PC1074 PC1081 PC1225 PC1328 PC1422-PC1426 PC1812-PC1815 PC3416 PC3433 PC3434 PC3438 PC3439 PC3505 PC3507 PC3508 PC3513 PC3514 PC3528 PC3535 PC3538 PC3551 PC3552 PC3556 PC3561 PC3567 PC3571 PC3577-PC3579 = C_0402NEW
C100 C101 C103 C104 C118 = C_0402NEW: signal model: C_0402NEW-2; room: EDP
C105 = C_B2: room: EDP
C106-C110 C112 C114-C117 = C_0603NEW: room: EDP
C153 C167 C240 C311 C312 C341-C343 C369-C372 C545-C547 C624 C929 C1181-C1184 C1327 C2174 PC128 PC208-PC211 PC225-PC229 PC308 PC405 PC417 PC418 PC420 PC422 PC423 PC425 PC426 PC436 PC438 PC502 PC503 PC505-PC508 PC701 PC702 PC711 PC715 PC716 PC722 PC723 PC726-PC729 PC902-PC905 PC908 PC912-PC916 PC918-PC922 PC925 PC926 PC928 PC929 PC932 PC934 PC936 PC1002-PC1005 PC1012-PC1016 PC1018-PC1021 PC1023 PC1025 PC1026 PC1028 PC1030 PC1032-PC1035 PC1304 PC1308 PC1326 PC3501-PC3504 PC3520-PC3527 PC3529-PC3531 PC3534 PC3536 PC3537 PC3540 PC3544 PC3546 PC3548 PC3550 PC3553-PC3555 PC3557 PC3559 PC3560 PC3563 PC3568 PC3569 = C_0805NEW
C168 C169 C938-C940 C944-C948 C950 C951 C1040-C1062 C1086-C1108 C1132-C1154 C2027-C2045 C2047 C2049-C2052 C2055-C2063 C2066-C2074 C2076-C2084 C2089-C2099 C2101 C2102 C2107 C2108 C2111 C2112 C2117 C2118 C2121 C2127-C2131 C2151 C2163-C2165 C2410-C2414 = C_0201NEW: signal model: C_0201NEW-1
C291 PC930 PC931 PC1029 PC1031 PC3562 = C_1206
C300 C301 = C_0402NEW: signal model: C_0402NEW-2; room: CAM
C340 C348-C355 = C_0402NEW: signal model: C_0402NEW-2; room: HDMI
C344 = C_0805NEW: room: HDMI
C356 C357 C360 C366-C368 = C_0402NEW: signal model: C_0402NEW-2; room: AUX MUX
C383 C384 = C_0402NEW: signal model: C_0402NEW-2; room: HDD
C408 C414 C415 C417 C420 C429-C432 C548 C586-C591 C596-C598 C619 C620 C657 C658 C666 C669 C1394-C1398 C1405-C1407 C2189 C2193 C2198 C2204 C2207-C2220 C2319 C2321 C2324-C2326 C2328-C2332 C2334 C2336-C2341 C2343 C2344 C2346-C2351 C2353 C2355-C2362 C2364-C2370 C2372-C2374 C2376-C2379 C2381 C2382 C2384 C2385 C2389 C2391-C2393 C2398-C2407 C2415 C2416 C2442-C2447 = C_0402-NV
C423 = C_0402NEW: signal model: C_0402NEW-2; room: +5VMOD SOURCE
C460 C461 C464 C466-C471 = C_0402NEW: signal model: C_0402NEW-2; room: LAN
C463 = C_0603NEW: room: LAN
C510 C511 PC623 PC624 PC665 PC667-PC670 PC679-PC681 PC1221 PC1278 PC1417-PC1420 PC1501-PC1506 PC1516-PC1519 PC1523-PC1527 PC1529 PC1602-PC1607 PC1620-PC1626 PC1639-PC1645 PC1660 PC1661 PC2264 = C_0805
C600 = C_1206: signal model: C_0402NEW-2
C601 C622 C623 = C_0402NEW: signal model: C_0201NEW-1
C626 = C_0402NEW: signal model: C_0402NEW-2; room: DMC
C633-C635 C638 C640 C643 = C_0402NEW: signal model: C_0402NEW-2; room: EXPRESS
C636 = C_0402NEW: signal model: C_0402NEW-2; room: SIM
C637 = C_0603NEW: room: EXPRESS
C639 = C_0603NEW: room: SIM
C654 C675 = C_0402NEW: signal model: C_0402NEW-2; room: USB
C655 C656 C1343 = C_0402-NV: signal model: C_0402NEW-2
C665 PC1810 = C_0603NEW: signal model: C_0402NEW-2
C667 C668 = C_0402-NV: room: ESATA
C676 = C_0603NEW: room: USB; signal model: C_0402NEW-2
C677 C678 = C_0603NEW: room: MDC
C679-C682 C696 = C_0402NEW: signal model: C_0402NEW-2; room: DOCK
C683 C684 C704 = C_0603NEW: room: DOCK; signal model: C_0402NEW-2
C685 C697 = C_0402-NV: room: DOCK
C686 C688-C692 C698 C701-C703 = C_0402-NV: room: DOCK; signal model: C_0402NEW-2
C687 C693 = C_0603NEW: room: DOCK
C705 = C_0603NEW: room: SIO; signal model: C_0402NEW-2
C2327 C2335 C2345 C2363 = C_0603NEW_S
C2386 C2387 = C_0402-NV_S
CM3-CM6 CM10-CM15 = MURAT_DLW21HN900HQ2L_4P
D1-D5 D8-D10 D19 D20 D38 D39 D51 D52 D69-D71 D2007 D2009-D2017 D2020 PD401 = SDM10U45LP-7_DFN1006-2-2
D6 D7 = AZC099-04SPR7G_SOT23-6
D22-D24 D27-D29 D37 D40 D41 D48 D55-D59 = AIES12U020R2_0402-2
D26 D30 D53 D54 D2018 D2019 = TPD4EUSB30DQAR_SON10
D33 D49 D2005 D2006 = AZ5315_0402-3
D60-D67 = ESD101_0201-2
D2004 = AZ5123-01F_0402-2
DL1 = D-4_315X3_62-2_3H
G2 = BGA_2152_P070_375X375
H2 H4-H10 H12 H23 H24 H26-H28 = HOLE217_98
H13 = HOLE197_118
H14 = HOLE394_118
H15 H16 = HOLE335_118
H17-H22 = HOLET275B197_166
H29 = HOLE276_98
H30 = HOLEOB297X197_197X118
J1-J3 PJ1201 = JUMPER1_0
JBAT1 = DOCK-12502HB012M200ZL-12P-L
JCAM1 = 50376-00801-V01-8P-L
JDBUG1 = KRYO_046809605020846_5P-T
JDCIN1 = 50458-00901-001-9P
JDIMM1 = DDR-5_2-80886-100-260P: room: MEMORY
JDIMM2 = DDR-80888-100-260P: room: MEMORY
JDIMM3 = DDR-5_2-80888-100-260P
JDIMM4 = DDR-80886-100-260P
JDP1 = DP-DRA45-00-00-20P-R
JEC1 = KRYO_046299626120846_26P-T
JEDP1 = 50398-04071-001-40P
JFAN1 JFAN2 = WS33041-S0351-HF-4P
JHDD1 = ACES_50208-01001-001_10P
JHDMI1 = HDMI-2HE3Y36-000111F-19P: room: HDMI
JIO1 = CONN76-0_4-33_35X4_9X1_3MM
JKB1 = 006800650012846-50P-L: room: KB
JRJ1 = RJ45-JM3611-RS800003-7H-8P
JRTC1 JSWF1 = ACES_50271-0020N-001_2P
JSPBL1 = 50208-00601-001-6P
JSPKR1 = 50281-00401-001-4P
JSSD1 JSSD2 = NGFF-NFSM0-S6710-TP50-75P-KM
JTP1 = FC1AF061-1201H-6P: room: TOUCH.PAD
JTPBL1 = FC1AF061-1201H-6P
JTYPC1 = USB-UT11111-13401-7H-24P
JUSB1 = USB-UAA111C-441R1-7H-9P: room: USB
JUSB2 = UB3-UEA1111-R36AM1-7H-9P
JWLAN1 = MINIPCI-80152-001-75P
L1 = MURAT_BLM15BD221SN1D_2P: room: HDMI
L2 L3 L21 L2003 L2008 L2013 = MURAT_BLM15BD221SN1D_2P
L4 = L4X4-1_2H
L5 L6 = L1_6X0_8
L7 L8 L11 L12 L38 L39 PL1202 PL1203 PL1301 = MURAT_BLM15PX121SN1D_2P
L18 L20 L2002 L2004-L2007 L2009 L2010 L2012 L2014 L2015 = L1_6X0_8-T0_8MM
L2001 = MURAT_LQM18PN1R0M_2P
LD1 = LED-FSL-2408035WA-3P
NUT1-NUT3 = HOLE240_126
PC14 PC3566 = 1005_BGA
PC23 PC204 PC230 PC401 PC906 PC1006 PC1007 PC1270 PC1274 PC1276 PC1279 PC1281 PC1282 PC1510 PC1530 PC1533-PC1540 PC1608 PC1611-PC1618 PC1627 PC1630-PC1637 PC1649 PC1650 PC1652-PC1655 PC1658 PC1662 PC1663 PC3409 PC3425 PC3515 PC3519 PC3547 = C_0603
PC101 PC102 = C_0402NEW: signal model: C_0402NEW-2; room: 3V5V
PC106 = C_0402NEW: signal model: C_0402NEW-2; room: ETY-ROOM
PC193-PC195 PC1508 PC1549 = C_EEEFK1E680P
PC196 PC410 PC411 PC413-PC415 PC439 PC622 PC625 PC666 PC671 PC675 PC678 PC907 PC1072 PC1082 PC1120 PC1133 PC1137 PC1139 PC1141-PC1143 PC1149-PC1151 PC1153 PC1158 PC1160 PC1161 PC1222 PC1226 PC1227 PC1271-PC1273 PC1275 PC1277 PC1316 PC1317 PC1329 PC1427 PC1429-PC1432 PC1511 PC1531 PC1542 PC1609 PC1628 PC1647 PC3401 PC3407 PC3424 PC3426 PC3435 PC3436 PC3506 PC3509-PC3512 PC3516 PC3518 PC3541-PC3543 PC3558 PC3570 PC3572 PC3575 PC3576 PC3590 = C_0402
PC201 = C_0402NEW: signal model: C_0402NEW-2; room: VGA_CORE
PC202 = C_0402NEW: signal model: C_0402NEW-2; room: 1.5V/0.75V
PC303 PC307 = C_0603NEW: room: 1.05V
PC304-PC306 = C_0805NEW: room: 1.05V
PC403 = C_0603: room: ETY-ROOM
PC404 PC406 PC407 = C_0805NEW: room: ETY-ROOM
PC510 = C_0805NEW: room: DDR_VTT
PC512 PC513 = C_0603NEW: room: CPU_CORE
PC514 = C_0402NEW: signal model: C_0402NEW-2; room: CPU_CORE
PC706 PC707 = C_B2: room: CHARGER
PC709 = C_0402NEW: signal model: C_0402NEW-2; room: CHARGER
PC710 PC713 PC714 = C_0805NEW: room: CHARGER
PC712 = C_0603NEW: room: CHARGER
PC909 PC923 = C_0402NEW: signal model: C_0402NEW-2; room: CPU
PC910 PC924 PC933 PC935 PC937 PC1008-PC1010 PC1024 PC1513-PC1515 PC1521 PC1522 PC1543 PC1544 PC1656 PC1657 PC1799-PC1801 PC1939 PC2268 PC3564 PC3565 PC3588 PC3589 = C_D2
PD101 = AZ5425-01F_DFN1006P2E2
PD201 PD202 PD801 = RB751V-40_SOD323-2
PD601 = B140HW-7_SOD123-2
PF101 PF102 = F3_2X1_6-2_95
PH201 PH1108 PR22-PR32 PR34-PR36 PR38 PR106-PR108 PR203 PR206 PR213 PR215-PR217 PR219-PR229 PR231 PR235 PR236 PR307 PR313 PR314 PR355 PR413 PR414 PR416 PR423 PR425-PR427 PR429-PR431 PR451 PR501 PR605 PR610 PR611 PR623 PR647-PR649 PR712 PR715 PR717 PR718 PR720-PR724 PR801 PR803 PR804 PR818 PR820 PR907-PR909 PR914 PR920 PR992 PR1005 PR1006 PR1009 PR1013 PR1014 PR1025 PR1146 PR1148 PR1155 PR1158 PR1161 PR1176 PR1179 PR1181 PR1183-PR1185 PR1189 PR1192 PR1195 PR1196 PR1198 PR1199 PR1205 PR1206 PR1208 PR1211 PR1212 PR1231-PR1235 PR1237 PR1238 PR1240-PR1243 PR1251 PR1253 PR1258 PR1302 PR1305 PR1306 PR1310-PR1315 PR1317 PR1401 PR1403-PR1412 PR1414 PR1415 PR1461 PR1595 PR1597 PR1599 PR1622-PR1624 PR1629 PR1631-PR1633 PR2187 PR2261 PR3417 PR3423 PR3424 PR3426 PR3428 PR3439 PR3441 PR3449 PR3454 PR3456 PR3459 PR3461 PR3463-PR3465 PR3532 PR3535 PR3536 PR3550 PR3551 PR3553-PR3556 PR3558 PR3560 PR3561 PR3567-PR3573 PR3575 PR3578 PR3580 PR3583 PR3584 PR3587 PR3589 PR3590 R1 R2 R4-R6 R10-R18 R21-R29 R31 R32 R46 R48 R49 R51 R56 R57 R59-R64 R81 R82 R84 R89-R97 R99 R102 R103 R109-R114 R116-R126 R129-R132 R134-R139 R142-R153 R155 R158-R171 R173-R192 R200-R205 R207 R209 R212 R216-R220 R222 R224-R226 R228 R232 R233 R235-R265 R267-R270 R272 R274-R282 R287-R289 R292-R304 R306-R328 R330-R348 R368-R370 R372-R374 R377 R379-R381 R386 R387 R389-R399 R402 R403 R405 R406 R408-R411 R420 R422 R423 R425 R428-R432 R434-R439 R443-R489 R492 R495-R501 R503-R508 R510-R513 R517-R526 R528-R533 R537 R538 R540 R541 R546-R555 R557 R558 R563-R576 R578 R579 R584 R585 R588 R590 R591 R593-R596 R600 R601 R606-R614 R620 R632 R660 R773 R774 R777 R780 R781 R783-R785 R787 R788 R791 R793 R796-R798 R807-R810 R813 R814 R825-R827 R830-R850 R854-R859 R862 R865-R869 R871-R880 R894-R901 R903-R906 R908-R914 R916-R931 R934 R936-R938 R940 R942 R944 R962 R963 R973-R977 R979-R983 R985-R1004 R1006 R1007 R1009 R1010 R1013-R1026 R2010-R2015 R2017-R2020 R2023-R2054 R2057-R2060 R2062-R2072 R2075-R2080 R2082-R2094 R2096-R2099 R2101 R2103-R2110 R2112 R2113 R2115 R2118-R2123 R2125 R2126 R2130 R2131 R2138-R2146 R2150-R2172 R2183-R2189 R2193-R2209 R2211-R2213 R2215-R2224 R2226-R2234 R2236-R2244 R2251-R2257 R2259-R2269 R2271-R2284 R2286-R2290 R2294-R2300 R2302 R2304-R2307 R2312-R2315 R2327 R2328 R2334 R2339-R2342 = R_0402NEW
PH1103 PH1105-PH1107 PR208 PR230 PR234 PR402 PR404 PR407-PR412 PR415 PR433 PR438-PR441 PR511 PR609 PR612 PR624 PR719 PR906 PR910 PR915 PR922 PR1007 PR1020 PR1023 PR1024 PR1121 PR1152 PR1157 PR1159 PR1162-PR1166 PR1169 PR1172 PR1173 PR1175 PR1177 PR1180 PR1182 PR1186-PR1188 PR1190 PR1191 PR1193 PR1194 PR1197 PR1201 PR1202 PR1209 PR1210 PR1220 PR1221 PR1224 PR1226 PR1227 PR1229 PR1239 PR1416-PR1420 PR1433 PR1436 PR1439 PR1442 PR1445-PR1447 PR1449-PR1453 PR1457-PR1460 PR1462 PR1463 PR1467 PR1469 PR1470 PR1472 PR1473 PR1504-PR1506 PR1511-PR1513 PR1596 PR1598 PR1604-PR1606 PR1611-PR1613 PR1618-PR1620 PR1625 PR1628 PR1630 PR3408 PR3411-PR3416 PR3418-PR3422 PR3431-PR3433 PR3435-PR3438 PR3440 PR3444 PR3446 PR3448 PR3457 PR3458 PR3466-PR3468 PR3470-PR3472 PR3525 PR3526 PR3528-PR3530 PR3533 PR3534 PR3540-PR3542 PR3547 PR3562-PR3566 PR3574 PR3576 PR3577 PR3579 PR3581 PR3582 PR3585 PR3586 PR3588 R266 R534-R536 R556 R580 R2291 R2292 R2311 R2333 = R_0402
PJ4 PJ7-PJ12 PJ17 PJ18 PJ502 PJ1206 PJ1252 PJ1253 PJ1255 PJ1506-PJ1508 = JUMP_43X79_7
PJ15 PJ16 PJ301-PJ303 PJ402 PJ403 PJ701 PJ702 PJ1501-PJ1504 = JUMP_43X118
PJ401 PJ404 PJ703 PJ704 = JUMP_43X79
PJ405 PJ501 PJ602 PJ610 PJ611 PJ1207 PJ1505 = JUMP_43X39
PL101 = TAI-T_C8BBPH403025-1TAPING_2P: room: ETY-ROOM
PL102-PL104 = TAI-T_C8BBPH403025-1TAPING_2P
PL201 = L11_15X10-3_8H: room: 1.5V/0.75V
PL301 = CYNTE_PCMC065T-2R2MN_2P: room: 1.05V
PL302 PL401 PL711 PL1808 PL1809 = CYNTE_PCMC065T-2R2MN_2P
PL410 PL501 PL602 PL702 PL1201 PL1807 = CYNTE_PCMB053T-1R0MS_2P
PL701 = CYNTE_PCMC065T-2R2MN_2P: room: ETY-ROOM
PL901 PL902 PL1001 PL1810 PL1811 = L11_15X10-3_8H
PL1501 PL1502 PL1601-PL1603 = TOKO_FDUE0640J-H_4P
PL2001 = MAGLA_SPS-04AEN2R2M-M1_2P
PQ101 = 2N7002KDWH_SOT363-6
PQ201 = FDMS7678_POWER56-8-5: room: 1.5V/0.75V
PQ202 PQ203 PQ205 = FDMS7678_POWER56-8-5
PQ204 PQ302 PQ401 PQ701 PQ702 PQ1411 PQ1412 = SON8-5X6-1_27-8P
PQ206 = 2N7002KW_SOT323-3
PQ301 = SON8-5X6-1_27-8P: room: ETY-ROOM
PQ904 = AON7405_DFN8-5
PQ1401-PQ1405 PQ1409 Q5-Q9 Q13 Q35 Q41 Q49 Q52 Q53 Q74-Q76 Q80-Q88 Q90-Q95 Q97 Q98 Q100 Q101 = AO5804EL_SC89-6
PR39 PR105 PR205 PR209-PR211 PR214 PR232 PR237 PR308 PR309 PR312 PR315 PR428 PR502 PR626 PR714 PR902-PR904 PR911 PR918 PR919 PR1001 PR1002 PR1008 PR1021 PR1022 PR1053 PR1145 PR1147 PR1149 PR1151 PR1154 PR1200 PR1257 PR1304 PR1309 PR1318 PR1321 PR1413 PR1471 PR1502 PR1503 PR1509 PR1510 PR1602 PR1603 PR1609 PR1610 PR1616 PR1617 PR3462 PR3537-PR3539 PR3549 PR3593 PR3594 R19 R20 R33-R37 R41 R53 R54 R65-R71 R115 R206 R208 R210 R211 R213-R215 R221 R223 R229-R231 R234 R271 R273 R284-R286 R290 R305 R329 R376 R378 R382 R421 R424 R433 R440 R559 R560 R1008 R1012 R2055 R2056 R2137 R2147 R2270 = R_0603NEW
PR101-PR104 = R_0402NEW: room: ETY-ROOM
PR116 PR218 PR417 PR418 PR716 PR905 PR912 PR1004 PR1011 PR1507 PR1514 PR1607 PR1614 PR1621 PR3460 PR3531 R283 R1011 R2330-R2332 R2335-R2338 = R_0805NEW
PR201 = R_1632NEW: room: 1.5V/0.75V
PR202 PR204 PR212 PR233 PR608 PR621 PR622 PR1222 PR1225 PR1501 PR1508 PR1601 PR1608 PR1615 PR3401 PR3404 PR3409 PR3434 PR3442 PR3445 PR3591 PR3592 = R_0603
PR207 = R_1632NEW
PR301-PR303 PR305 PR306 = R_0402NEW: room: 1.05V
PR304 = R_0603NEW: room: 1.05V
PR310 PR311 PR316 PR317 = R_1206NEW
PR401 = R_0603: room: P_1P8V
PR403 = R_0805NEW: room: ETY-ROOM
PR405 = R_0603: room: ETY-ROOM
PR406 = R_0402: room: ETY-ROOM
PR503 PR505-PR507 PR509 = R_0402NEW: room: CPU_CORE
PR504 = R_0805NEW: room: CPU_CORE
PR508 = R_0402: room: CPU_CORE
PR701 = R_1632NEW_4P: room: ETY-ROOM
PR703 PR704 = R_0402NEW: room: CHARGER
PR901 PR3552 = R_1632NEW_4P
PR3405 PR3410 PR3443 PR3447 = R_0805
PT602 PT603 PT1001 PT1003-PT1005 PT1501-PT1504 PT1601-PT1606 PTP901-PTP906 TP1-TP14 TP20-TP52 TP54-TP64 TP71-TP74 TP76 TP79 TP90-TP97 TP99 TP100 TP102 TP103 TP113-TP118 TP122 TP124 TP126-TP128 TP130 TP132-TP139 TP142-TP144 TP155 TP160 TP161 TP168-TP171 TP181 TP182 TP184-TP187 = TPC12
PU1 = SC59-1_9-3X1_6-1_4MM
PU5 = QFN17P-0_65-4X4-1MM
PU7 PU8 = TPS22913_4P
PU201 = ISL95520HRTZ_TQFN32_4X4
PU301 = TPS51225CRUKR_QFN20_3X3
PU401 = RT8231AGQW_WQFN20_3X3
PU402 PU1608-PU1610 = SOT23-8P-0_65-2_9X1_6-1_45MM
PU403 PU501 PU702 PU1309 = SYX198DQNC_QFN10_3X3
PU603 = DFN10P-0_5-3X3-0_8MM
PU605 = QFN36-4X7-5-37P
PU701 = QFN20-0_4-3X3X1MM: room: ETY-ROOM
PU901 PU902 PU1001 PU1002 PU1501 PU1502 PU1601-PU1603 PU1606 = NCP81382MNTXG_QFN39-31_6X4
PU1101 = QFN52-0_4-6X6X1MM
PU1204 = TPS51362RVER_QFN28_3P5X4P5
PU1252 PU1254 = SLG5NT1533VTR_STDFN8-6_1X1P6
PU1301 PU1304 = WSON7P-0_65-3X3-0_8MM
PU1303 = BGA8P-0_5-2X1X0_62MM
PU1306 = WDFN-10L_0_5-3X3X0_8MM
PU1307 PU1607 = SLG59M301VTR_FC-TDFN8-6_1P5X2
PU1308 = DFN6P-0_4-1_6X1-0_6MM
PU1604 = QFN20-0_4-3X3X1MM
PU1605 = QFN40-0_4-5X5X1MM
Q1 Q2 = AO5804EL_SC89-6: room: THERMAL
Q10 = MMST3904-7-F_SOT323-3
Q11 = SOT323-3P-1_3-2_15X1_3-1MM
Q12 = DMG1012T-7_SOT523-3
Q24 = MMBT3904WH_SOT323-3
Q29 = LP2301ALT1G_SOT23-3
Q104 Q105 = DFN3X3A_8L_EP1_P
Q106 = MMBT3906_PNP_SOT23-3
R7-R9 = R_0402NEW: room: FLASH ROM
R30 R407 = R_0402NEW: room: THERMAL
R52 = R0402_SHORT
R86 = R_0402NEW: room: HDMI
R106-R108 = R_0402NEW: room: EDP
RP1 RP2 RP4 = RP_0804_8P4R
SWPWR2 = SW-SKSHAAE010-4P
TL1 = TRF24P-1-15_1X7_5-4MM
TP15-TP19 TP77 TP78 TP145-TP147 TP152-TP154 = TPC40
U1 = BGA1445_SKL_HALO_28X42MM_MPI
U2 = SPT_H_BOP_23X23MM: room: USB
U3 U16 U2012 = W25Q64FVSSIG_SO8
U4 U26 U56 U58 U59 U61-U63 U2027-U2029 = SOT353-0_65-1_35X2_25X1_1MM
U5 U19 = IT8586VG-AX_VFBGA_128P
U6 = QFN41P-0_4-5X5X0_9MM
U7 = ALC286-CG_QFN56_7X7
U8 = TSOP49P-0_5-12_5X6_1-1_2MM
U9 = SSOP29P-0_65-9_7X4_4X1_2MM
U14 = QFN21P-0_5-4X4-0_75MM
U18 U50 U2030 U2031 = TPS2553DRV_SON6_2X2
U21 = TPS2546RTER_QFN16_4X4
U22 = QFN20P-0_4-3X2-0_6MM
U23 U24 = BGA8-TMP006
U25 = TSSOP10P-0_5-3X3-1_1MM
U48 U55 U60 U2022-U2026 = BGA170-HYNIX-H5GC2H24BFR
U51 = SOT-2_8-1_9-3P
U2005 = BGA337-INTEL-H38212
U2007 = BGA96-TEXAS-TPS65982
U2011 = 74AUP1G04GF_SOT891-6_1X1
U2013 U2014 = QFN48P-0_5-7X7X0_85MM
U2015 = TQFN42P-0_5-9X3_5X0_84MM
U2016 = TQFN10P-0_4-1_6X1_3X0_75MM
U2019 = TQFN42P-0_5-9X3_5X0_8MM
U2021 = SOP8-1_27-5X4X1_75MM
Y1 = Y_CM8V-T1A_2P
Y2 Y4 Y2001 = Y_EXS00A-CS07257_4P
Y6 = Y_7V27000011_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002KDWH_SOT363-6
  oval 0.356x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.6) 5(0.65,1.6) 6(0,1.6)
2N7002KW_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
74AUP1G04GF_SOT891-6_1X1
  oval 0.203x0.508 smd: 1(0,0) 2(0.35,0) 3(0.7,0) 4(0.7,0.7) 5(0.35,0.7) 6(0,0.7)
1005_BGA
  custom 0.15x0.15 smd: 1(0,0) 2(1,0)
50208-00601-001-6P
  rect 0.508x0.991 smd: 1(-2,1.95) 2(-1.2,1.95) 3(-0.4,1.95) 4(0.4,1.95) 5(1.2,1.95) 6(2,1.95)
  rect 1.194x1.702 smd: 7(-3.3,0) 8(3.3,0)
50281-00401-001-4P
  rect 0.787x2.007 smd: 1(1.875,4.05) 2(0.625,4.05) 3(-0.625,4.05) 4(-1.875,4.05)
  rect 2.007x2.489 smd: 5(4.075,0) 6(-4.075,0)
50376-00801-V01-8P-L
  rect 0.406x0.61 smd: 1(-2.1,1.375) 2(-1.5,1.375) 3(-0.9,1.375) 4(-0.3,1.375) 5(0.3,1.375) 6(0.9,1.375) 7(1.5,1.375) 8(2.1,1.375)
  rect 0.711x1.041 smd: 9(-3.05,0) 10(3.05,0)
50398-04071-001-40P
  rect 0.254x1.295 smd: 1(9.75,1.95) 2(9.25,1.95) 3(8.75,1.95) 4(8.25,1.95) 5(7.75,1.95) 6(7.25,1.95) 7(6.75,1.95) 8(6.25,1.95) 9(5.75,1.95) 10(5.25,1.95) 11(4.75,1.95) 12(4.25,1.95) 13(3.75,1.95) 14(3.25,1.95) 15(2.75,1.95) 16(2.25,1.95) 17(1.75,1.95) 18(1.25,1.95) 19(0.75,1.95) 20(0.25,1.95) 21(-0.25,1.95) 22(-0.75,1.95) 23(-1.25,1.95) 24(-1.75,1.95) 25(-2.25,1.95) 26(-2.75,1.95) 27(-3.25,1.95) 28(-3.75,1.95) 29(-4.25,1.95) 30(-4.75,1.95) 31(-5.25,1.95) 32(-5.75,1.95) 33(-6.25,1.95) 34(-6.75,1.95) 35(-7.25,1.95) 36(-7.75,1.95) 37(-8.25,1.95) 38(-8.75,1.95) 39(-9.25,1.95) 40(-9.75,1.95)
  rect 1.194x3.2 smd: 41(12.15,0) 42(-12.15,0)
  rect 2.311x1.295 smd: 43(8.9,-1.95) 44(0,-1.95) 45(-8.9,-1.95)
50458-00901-001-9P
  rect 0.559x1.295 smd: 1(-8,5.13) 2(-6,5.13) 3(-4,5.13) 4(-2,5.13) 5(0,5.13) 6(2,5.13) 7(4,5.13) 8(6,5.13) 9(8,5.13)
  oval 0.787x2.057 hole 0.406x1.651: 10(-11.5,0) 11(11.5,0)
006800650012846-50P-L
  rect 0.305x0.889 smd: 1(-12.25,3.745) 2(-11.75,3.745) 3(-11.25,3.745) 4(-10.75,3.745) 5(-10.25,3.745) 6(-9.75,3.745) 7(-9.25,3.745) 8(-8.75,3.745) 9(-8.25,3.745) 10(-7.75,3.745) 11(-7.25,3.745) 12(-6.75,3.745) 13(-6.25,3.745) 14(-5.75,3.745) 15(-5.25,3.745) 16(-4.75,3.745) 17(-4.25,3.745) 18(-3.75,3.745) 19(-3.25,3.745) 20(-2.75,3.745) 21(-2.25,3.745) 22(-1.75,3.745) 23(-1.25,3.745) 24(-0.75,3.745) 25(-0.25,3.745) 26(0.25,3.745) 27(0.75,3.745) 28(1.25,3.745) 29(1.75,3.745) 30(2.25,3.745) 31(2.75,3.745) 32(3.25,3.745) 33(3.75,3.745) 34(4.25,3.745) 35(4.75,3.745) 36(5.25,3.745) 37(5.75,3.745) 38(6.25,3.745) 39(6.75,3.745) 40(7.25,3.745) 41(7.75,3.745) 42(8.25,3.745) 43(8.75,3.745) 44(9.25,3.745) 45(9.75,3.745) 46(10.25,3.745) 47(10.75,3.745) 48(11.25,3.745) 49(11.75,3.745) 50(12.25,3.745)
  rect 1.397x1.168 smd: 51(-13.6,0) 52(13.6,0)
ACES_50208-01001-001_10P
  oval 0.508x0.991 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 9(6.4,0) 10(7.2,0)
  rect 1.194x1.702 smd: 11(-1.3,-1.95) 12(8.5,-1.95)
ACES_50271-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(3.8,-2.9) 4(-2.55,-2.9)
AIES12U020R2_0402-2
  rect 0.508x0.711 smd: 1(0,0) 2(1.04,0)
ALC286-CG_QFN56_7X7
  oval 0.94x0.305 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(6.95,-5.2) 30(6.95,-4.8) 31(6.95,-4.4) 32(6.95,-4) 33(6.95,-3.6) 34(6.95,-3.2) 35(6.95,-2.8) 36(6.95,-2.4) 37(6.95,-2) 38(6.95,-1.6) 39(6.95,-1.2) 40(6.95,-0.8) 41(6.95,-0.4) 42(6.95,0)
  oval 0.305x0.94 smd: 15(0.875,-6.075) 16(1.275,-6.075) 17(1.675,-6.075) 18(2.075,-6.075) 19(2.475,-6.075) 20(2.875,-6.075) 21(3.275,-6.075) 22(3.675,-6.075) 23(4.075,-6.075) 24(4.475,-6.075) 25(4.875,-6.075) 26(5.275,-6.075) 27(5.675,-6.075) 28(6.075,-6.075) 43(6.075,0.875) 44(5.675,0.875) 45(5.275,0.875) 46(4.875,0.875) 47(4.475,0.875) 48(4.075,0.875) 49(3.675,0.875) 50(3.275,0.875) 51(2.875,0.875) 52(2.475,0.875) 53(2.075,0.875) 54(1.675,0.875) 55(1.275,0.875) 56(0.875,0.875)
  rect 4.597x4.597 smd: 57(3.475,-2.6)
AO5804EL_SC89-6
  oval 0.305x0.457 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1,1.25) 5(0.5,1.25) 6(0,1.25)
AON7405_DFN8-5
  oval 0.356x0.559 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.57x0.57 smd: 5(0.975,1.42)
AZ5123-01F_0402-2
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
AZ5315_0402-3
  rect 0.152x0.254 smd: 1(0.175,-0.325) 2(-0.175,-0.325)
  rect 0.508x0.254 smd: 3(0,0.325)
AZ5425-01F_DFN1006P2E2
  rect 0.559x0.61 smd: 1(0,0) 2(0.85,0)
AZC099-04SPR7G_SOT23-6
  oval 0.559x1.092 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.5) 5(0.95,2.5) 6(0,2.5)
B140HW-7_SOD123-2
  rect 1.194x0.711 smd: 1(0,0) 2(3.7,0)
BGA8-TMP006
  round 0.254 smd: A1(-0.5,-0.5) A2(-0.5,0) A3(-0.5,0.5) B1(0,-0.5) B3(0,0.5) C1(0.5,-0.5) C2(0.5,0) C3(0.5,0.5)
BGA8P-0_5-2X1X0_62MM
  round 0.33 smd: A1(-0.75,0.25) A2(-0.25,0.25) A3(0.25,0.25) A4(0.75,0.25) B1(-0.75,-0.25) B2(-0.25,-0.25) B3(0.25,-0.25) B4(0.75,-0.25)
BGA96-TEXAS-TPS65982
  round 0.254 smd: A1(-2.5,-2.5) A2(-2.5,-2) A3(-2.5,-1.5) A4(-2.5,-1) A5(-2.5,-0.5) A6(-2.5,0) A7(-2.5,0.5) A8(-2.5,1) A9(-2.5,1.5) A10(-2.5,2) A11(-2.5,2.5) B1(-2,-2.5) B2(-2,-2) B3(-2,-1.5) B4(-2,-1) B5(-2,-0.5) B6(-2,0) B7(-2,0.5) B8(-2,1) B9(-2,1.5) B10(-2,2) B11(-2,2.5) C1(-1.5,-2.5) C2(-1.5,-2) C10(-1.5,2) C11(-1.5,2.5) D1(-1,-2.5) D2(-1,-2) D5(-1,-0.5) D6(-1,0) D7(-1,0.5) D8(-1,1) D10(-1,2) D11(-1,2.5) E1(-0.5,-2.5) E2(-0.5,-2) E4(-0.5,-1) E5(-0.5,-0.5) E6(-0.5,0) E7(-0.5,0.5) E8(-0.5,1) E10(-0.5,2) E11(-0.5,2.5) F1(0,-2.5) F2(0,-2) F4(0,-1) F5(0,-0.5) F6(0,0) F7(0,0.5) F8(0,1) F10(0,2) F11(0,2.5) G1(0.5,-2.5) G2(0.5,-2) G4(0.5,-1) G5(0.5,-0.5) G6(0.5,0) G7(0.5,0.5) G8(0.5,1) G10(0.5,2) G11(0.5,2.5) H1(1,-2.5) H2(1,-2) H4(1,-1) H5(1,-0.5) H6(1,0) H7(1,0.5) H8(1,1) H10(1,2) H11(1,2.5) J1(1.5,-2.5) J2(1.5,-2) J10(1.5,2) J11(1.5,2.5) K1(2,-2.5) K2(2,-2) K3(2,-1.5) K4(2,-1) K5(2,-0.5) K6(2,0) K7(2,0.5) K8(2,1) K9(2,1.5) K10(2,2) K11(2,2.5) L1(2.5,-2.5) L2(2.5,-2) L3(2.5,-1.5) L4(2.5,-1) L5(2.5,-0.5) L6(2.5,0) L7(2.5,0.5) L8(2.5,1) L9(2.5,1.5) L10(2.5,2) L11(2.5,2.5)
BGA170-HYNIX-H5GC2H24BFR
  round 0.356 smd: A1(-6.4,-5.2) A2(-6.4,-4.4) A3(-6.4,-3.6) A4(-6.4,-2.8) A5(-6.4,-2) A10(-6.4,2) A11(-6.4,2.8) A12(-6.4,3.6) A13(-6.4,4.4) A14(-6.4,5.2) B1(-5.6,-5.2) B2(-5.6,-4.4) B3(-5.6,-3.6) B4(-5.6,-2.8) B5(-5.6,-2) B10(-5.6,2) B11(-5.6,2.8) B12(-5.6,3.6) B13(-5.6,4.4) B14(-5.6,5.2) C1(-4.8,-5.2) C2(-4.8,-4.4) C3(-4.8,-3.6) C4(-4.8,-2.8) C5(-4.8,-2) C10(-4.8,2) C11(-4.8,2.8) C12(-4.8,3.6) C13(-4.8,4.4) C14(-4.8,5.2) D1(-4,-5.2) D2(-4,-4.4) D3(-4,-3.6) D4(-4,-2.8) D5(-4,-2) D10(-4,2) D11(-4,2.8) D12(-4,3.6) D13(-4,4.4) D14(-4,5.2) E1(-3.2,-5.2) E2(-3.2,-4.4) E3(-3.2,-3.6) E4(-3.2,-2.8) E5(-3.2,-2) E10(-3.2,2) E11(-3.2,2.8) E12(-3.2,3.6) E13(-3.2,4.4) E14(-3.2,5.2) F1(-2.4,-5.2) F2(-2.4,-4.4) F3(-2.4,-3.6) F4(-2.4,-2.8) F5(-2.4,-2) F10(-2.4,2) F11(-2.4,2.8) F12(-2.4,3.6) F13(-2.4,4.4) F14(-2.4,5.2) G1(-1.6,-5.2) G2(-1.6,-4.4) G3(-1.6,-3.6) G4(-1.6,-2.8) G5(-1.6,-2) G10(-1.6,2) G11(-1.6,2.8) G12(-1.6,3.6) G13(-1.6,4.4) G14(-1.6,5.2) H1(-0.8,-5.2) H2(-0.8,-4.4) H3(-0.8,-3.6) H4(-0.8,-2.8) H5(-0.8,-2) H10(-0.8,2) H11(-0.8,2.8) H12(-0.8,3.6) H13(-0.8,4.4) H14(-0.8,5.2) J1(0,-5.2) J2(0,-4.4) J3(0,-3.6) J4(0,-2.8) J5(0,-2) J10(0,2) J11(0,2.8) J12(0,3.6) J13(0,4.4) J14(0,5.2) K1(0.8,-5.2) K2(0.8,-4.4) K3(0.8,-3.6) K4(0.8,-2.8) K5(0.8,-2) K10(0.8,2) K11(0.8,2.8) K12(0.8,3.6) K13(0.8,4.4) K14(0.8,5.2) L1(1.6,-5.2) L2(1.6,-4.4) L3(1.6,-3.6) L4(1.6,-2.8) L5(1.6,-2) L10(1.6,2) L11(1.6,2.8) L12(1.6,3.6) L13(1.6,4.4) L14(1.6,5.2) M1(2.4,-5.2) M2(2.4,-4.4) M3(2.4,-3.6) M4(2.4,-2.8) M5(2.4,-2) M10(2.4,2) M11(2.4,2.8) M12(2.4,3.6) M13(2.4,4.4) M14(2.4,5.2) N1(3.2,-5.2) N2(3.2,-4.4) N3(3.2,-3.6) N4(3.2,-2.8) N5(3.2,-2) N10(3.2,2) N11(3.2,2.8) N12(3.2,3.6) N13(3.2,4.4) N14(3.2,5.2) P1(4,-5.2) P2(4,-4.4) P3(4,-3.6) P4(4,-2.8) P5(4,-2) P10(4,2) P11(4,2.8) P12(4,3.6) P13(4,4.4) P14(4,5.2) R1(4.8,-5.2) R2(4.8,-4.4) R3(4.8,-3.6) R4(4.8,-2.8) R5(4.8,-2) R10(4.8,2) R11(4.8,2.8) R12(4.8,3.6) R13(4.8,4.4) R14(4.8,5.2) T1(5.6,-5.2) T2(5.6,-4.4) T3(5.6,-3.6) T4(5.6,-2.8) T5(5.6,-2) T10(5.6,2) T11(5.6,2.8) T12(5.6,3.6) T13(5.6,4.4) T14(5.6,5.2) U1(6.4,-5.2) U2(6.4,-4.4) U3(6.4,-3.6) U4(6.4,-2.8) U5(6.4,-2) U10(6.4,2) U11(6.4,2.8) U12(6.4,3.6) U13(6.4,4.4) U14(6.4,5.2)
BGA337-INTEL-H38212
  round 0.229 smd: A1(-5.06,-5.06) A2(-5.06,-4.6) A3(-5.06,-4.14) A4(-5.06,-3.68) A5(-5.06,-3.22) A6(-5.06,-2.76) A7(-5.06,-2.3) A8(-5.06,-1.84) A9(-5.06,-1.38) A10(-5.06,-0.92) A11(-5.06,-0.46) A12(-5.06,0) A13(-5.06,0.46) A14(-5.06,0.92) A15(-5.06,1.38) A16(-5.06,1.84) A17(-5.06,2.3) A18(-5.06,2.76) A19(-5.06,3.22) A20(-5.06,3.68) A21(-5.06,4.14) A22(-5.06,4.6) A23(-5.06,5.06) AA1(4.14,-5.06) AA2(4.14,-4.6) AA22(4.14,4.6) AA23(4.14,5.06) AB1(4.6,-5.06) AB2(4.6,-4.6) AB3(4.6,-4.14) AB4(4.6,-3.68) AB5(4.6,-3.22) AB6(4.6,-2.76) AB7(4.6,-2.3) AB8(4.6,-1.84) AB9(4.6,-1.38) AB10(4.6,-0.92) AB11(4.6,-0.46) AB12(4.6,0) AB13(4.6,0.46) AB14(4.6,0.92) AB15(4.6,1.38) AB16(4.6,1.84) AB17(4.6,2.3) AB18(4.6,2.76) AB19(4.6,3.22) AB20(4.6,3.68) AB21(4.6,4.14) AB22(4.6,4.6) AB23(4.6,5.06) AC1(5.06,-5.06) AC2(5.06,-4.6) AC3(5.06,-4.14) AC4(5.06,-3.68) AC5(5.06,-3.22) AC6(5.06,-2.76) AC7(5.06,-2.3) AC8(5.06,-1.84) AC9(5.06,-1.38) AC10(5.06,-0.92) AC11(5.06,-0.46) AC12(5.06,0) AC13(5.06,0.46) AC14(5.06,0.92) AC15(5.06,1.38) AC16(5.06,1.84) AC17(5.06,2.3) AC18(5.06,2.76) AC19(5.06,3.22) AC20(5.06,3.68) AC21(5.06,4.14) AC22(5.06,4.6) AC23(5.06,5.06) B1(-4.6,-5.06) B2(-4.6,-4.6) B3(-4.6,-4.14) B4(-4.6,-3.68) B5(-4.6,-3.22) B6(-4.6,-2.76) B7(-4.6,-2.3) B8(-4.6,-1.84) B9(-4.6,-1.38) B10(-4.6,-0.92) B11(-4.6,-0.46) B12(-4.6,0) B13(-4.6,0.46) B14(-4.6,0.92) B15(-4.6,1.38) B16(-4.6,1.84) B17(-4.6,2.3) B18(-4.6,2.76) B19(-4.6,3.22) B20(-4.6,3.68) B21(-4.6,4.14) B22(-4.6,4.6) B23(-4.6,5.06) C1(-4.14,-5.06) C2(-4.14,-4.6) C22(-4.14,4.6) C23(-4.14,5.06) D1(-3.68,-5.06) D2(-3.68,-4.6) D4(-3.9,-3.9) D5(-3.9,-3.25) D6(-3.9,-2.6) D8(-3.9,-1.95) D9(-3.9,-1.3) D11(-3.9,-0.65) D12(-3.9,0) D13(-3.9,0.65) D15(-3.9,1.3) D16(-3.9,1.95) D18(-3.9,2.6) D19(-3.9,3.25) D20(-3.9,3.9) D22(-3.68,4.6) D23(-3.68,5.06) E1(-3.22,-5.06) E2(-3.22,-4.6) E4(-3.25,-3.9) E5(-3.25,-3.25) E6(-3.25,-2.6) E8(-3.25,-1.95) E9(-3.25,-1.3) E11(-3.25,-0.65) E12(-3.25,0) E13(-3.25,0.65) E15(-3.25,1.3) E16(-3.25,1.95) E18(-3.25,2.6) E19(-3.25,3.25) E20(-3.25,3.9) E22(-3.22,4.6) E23(-3.22,5.06) F1(-2.76,-5.06) F2(-2.76,-4.6) F4(-2.6,-3.9) F5(-2.6,-3.25) F6(-2.6,-2.6) F8(-2.6,-1.95) F9(-2.6,-1.3) F11(-2.6,-0.65) F12(-2.6,0) F13(-2.6,0.65) F15(-2.6,1.3) F16(-2.6,1.95) F18(-2.6,2.6) F19(-2.6,3.25) F20(-2.6,3.9) F22(-2.76,4.6) F23(-2.76,5.06) G1(-2.3,-5.06) G2(-2.3,-4.6) G22(-2.3,4.6) G23(-2.3,5.06) H1(-1.84,-5.06) H2(-1.84,-4.6) H4(-1.95,-3.9) H5(-1.95,-3.25) H6(-1.95,-2.6) H8(-1.95,-1.95) H9(-1.95,-1.3) H11(-1.95,-0.65) H12(-1.95,0) H13(-1.95,0.65) H15(-1.95,1.3) H16(-1.95,1.95) H18(-1.95,2.6) H19(-1.95,3.25) H20(-1.95,3.9) H22(-1.84,4.6) H23(-1.84,5.06) J1(-1.38,-5.06) J2(-1.38,-4.6) J4(-1.3,-3.9) J5(-1.3,-3.25) J6(-1.3,-2.6) J8(-1.3,-1.95) J9(-1.3,-1.3) J11(-1.3,-0.65) J12(-1.3,0) J13(-1.3,0.65) J15(-1.3,1.3) J16(-1.3,1.95) J18(-1.3,2.6) J19(-1.3,3.25) J20(-1.3,3.9) J22(-1.38,4.6) J23(-1.38,5.06) K1(-0.92,-5.06) K2(-0.92,-4.6) K22(-0.92,4.6) K23(-0.92,5.06) L1(-0.46,-5.06) L2(-0.46,-4.6) L4(-0.65,-3.9) L5(-0.65,-3.25) L6(-0.65,-2.6) L8(-0.65,-1.95) L9(-0.65,-1.3) L11(-0.65,-0.65) L12(-0.65,0) L13(-0.65,0.65) L15(-0.65,1.3) L16(-0.65,1.95) L18(-0.65,2.6) L19(-0.65,3.25) L20(-0.65,3.9) L22(-0.46,4.6) L23(-0.46,5.06) M1(0,-5.06) M2(0,-4.6) M4(0,-3.9) M5(0,-3.25) M6(0,-2.6) M8(0,-1.95) M9(0,-1.3) M11(0,-0.65) M12(0,0) M13(0,0.65) M15(0,1.3) M16(0,1.95) M18(0,2.6) M19(0,3.25) M20(0,3.9) M22(0,4.6) M23(0,5.06) N1(0.46,-5.06) N2(0.46,-4.6) N4(0.65,-3.9) N5(0.65,-3.25) N6(0.65,-2.6) N8(0.65,-1.95) N9(0.65,-1.3) N11(0.65,-0.65) N12(0.65,0) N13(0.65,0.65) N15(0.65,1.3) N16(0.65,1.95) N18(0.65,2.6) N19(0.65,3.25) N20(0.65,3.9) N22(0.46,4.6) N23(0.46,5.06) P1(0.92,-5.06) P2(0.92,-4.6) P22(0.92,4.6) P23(0.92,5.06) R1(1.38,-5.06) R2(1.38,-4.6) R4(1.3,-3.9) R5(1.3,-3.25) R6(1.3,-2.6) R8(1.3,-1.95) R9(1.3,-1.3) R11(1.3,-0.65) R12(1.3,0) R13(1.3,0.65) R15(1.3,1.3) R16(1.3,1.95) R18(1.3,2.6) R19(1.3,3.25) R20(1.3,3.9) R22(1.38,4.6) R23(1.38,5.06) T1(1.84,-5.06) T2(1.84,-4.6) T4(1.95,-3.9) T5(1.95,-3.25) T6(1.95,-2.6) T8(1.95,-1.95) T9(1.95,-1.3) T11(1.95,-0.65) T12(1.95,0) T13(1.95,0.65) T15(1.95,1.3) T16(1.95,1.95) T18(1.95,2.6) T19(1.95,3.25) T20(1.95,3.9) T22(1.84,4.6) T23(1.84,5.06) U1(2.3,-5.06) U2(2.3,-4.6) U22(2.3,4.6) U23(2.3,5.06) V1(2.76,-5.06) V2(2.76,-4.6) V4(2.6,-3.9) V5(2.6,-3.25) V6(2.6,-2.6) V8(2.6,-1.95) V9(2.6,-1.3) V11(2.6,-0.65) V12(2.6,0) V13(2.6,0.65) V15(2.6,1.3) V16(2.6,1.95) V18(2.6,2.6) V19(2.6,3.25) V20(2.6,3.9) V22(2.76,4.6) V23(2.76,5.06) W1(3.22,-5.06) W2(3.22,-4.6) W4(3.25,-3.9) W5(3.25,-3.25) W6(3.25,-2.6) W8(3.25,-1.95) W9(3.25,-1.3) W11(3.25,-0.65) W12(3.25,0) W13(3.25,0.65) W15(3.25,1.3) W16(3.25,1.95) W18(3.25,2.6) W19(3.25,3.25) W20(3.25,3.9) W22(3.22,4.6) W23(3.22,5.06) Y1(3.68,-5.06) Y2(3.68,-4.6) Y4(3.9,-3.9) Y5(3.9,-3.25) Y6(3.9,-2.6) Y8(3.9,-1.95) Y9(3.9,-1.3) Y11(3.9,-0.65) Y12(3.9,0) Y13(3.9,0.65) Y15(3.9,1.3) Y16(3.9,1.95) Y18(3.9,2.6) Y19(3.9,3.25) Y20(3.9,3.9) Y22(3.68,4.6) Y23(3.68,5.06)
BGA1445_SKL_HALO_28X42MM_MPI
  round 0.406 smd: A3(12.06,-20.314) A37(-12.739,-20.314) B2(12.654,-19.654) B38(-13.314,-19.761) BR1(13.314,19.748) BR38(-13.314,19.722) BT2(12.743,20.314) BT37(-12.722,20.314) C1(13.314,-19.047)
  round 0.381 smd: A4(11.343,-20.314) A34(-11.146,-20.314) A36(-11.958,-20.314) AA13(5.502,-5.766) AA14(4.851,-5.766) AA29(-7.411,-5.899) AA30(-8.061,-5.899) AB29(-7.411,-5.111) AB30(-8.061,-5.111) AC13(5.502,-4.852) AC14(4.851,-4.852) AC29(-7.411,-4.324) AC30(-8.061,-4.324) AD13(5.502,-3.937) AD14(4.851,-3.937) AD29(-7.411,-3.537) AD30(-8.061,-3.537) AE13(5.502,-3.023) AE14(4.851,-3.023) AE29(-7.411,-2.749) AE30(-8.061,-2.749) AF13(5.502,-2.108) AF14(4.851,-2.108) AF29(-7.411,-1.962) AF30(-8.061,-1.962) AG13(5.502,-1.194) AG14(4.851,-1.194) AG29(-7.411,-1.174) AG30(-8.061,-1.174) AH13(5.502,-0.28) AH14(4.851,-0.28) AH29(-7.411,-0.387) AH30(-8.061,-0.387) AJ13(5.502,0.635) AJ14(4.851,0.635) AJ29(-7.411,0.4) AJ30(-8.061,0.4) AK29(-7.411,1.188) AK30(-8.061,1.188) AL13(5.502,1.549) AL14(4.851,1.549) AL29(-7.411,1.975) AL30(-8.061,1.975) AM13(5.502,2.464) AM14(4.851,2.464) AM29(-7.411,2.763) AM30(-8.061,2.763) AN13(5.502,3.378) AN14(4.851,3.378) AN29(-7.411,3.55) AN30(-8.061,3.55) AP13(5.502,4.292) AP14(4.851,4.292) AP29(-7.411,4.337) AP30(-8.061,4.337) AR13(5.502,5.207) AR14(4.851,5.207) AR29(-7.411,5.125) AR30(-8.061,5.125) AT13(5.502,6.121) AT14(4.851,6.121) AT29(-7.411,5.912) AT30(-8.061,5.912) AU13(5.502,7.036) AU14(4.851,7.036) AU29(-7.411,6.7) AU30(-8.061,6.7) AV29(-7.411,7.487) AV30(-8.061,7.487) AW13(5.502,7.95) AW14(4.851,7.95) AW29(-7.411,8.274) AW30(-8.061,8.274) AY13(5.502,8.864) AY14(4.851,8.864) AY29(-7.411,9.062) AY30(-8.061,9.062) B3(11.933,-19.616) B37(-12.595,-19.612) BA13(5.502,9.779) BA14(4.851,9.779) BA29(-7.411,9.849) BA30(-8.061,9.849) BB13(5.502,10.693) BB14(4.851,10.693) BB29(-7.411,10.637) BB30(-8.061,10.637) BC13(5.502,11.608) BC14(4.851,11.608) BC29(-7.411,11.424) BC30(-8.061,11.424) BD13(5.502,12.522) BD14(4.851,12.522) BD29(-7.411,12.211) BD30(-8.061,12.211) BE29(-7.411,12.999) BE30(-8.061,12.999) BF13(5.502,13.436) BF14(4.851,13.436) BF29(-7.411,13.786) BF30(-8.061,13.786) BG13(5.502,14.351) BG14(4.851,14.351) BG29(-7.411,14.574) BG30(-8.061,14.574) BH13(5.502,15.265) BH14(4.851,15.227) BH29(-7.411,15.234) BH30(-8.061,15.361) BJ13(5.144,15.812) BJ14(4.463,15.762) BJ15(3.713,15.762) BJ16(2.926,15.762) BJ17(2.139,15.762) BJ18(1.351,15.762) BJ19(0.564,15.762) BJ20(-0.224,15.762) BJ21(-1.011,15.762) BJ22(-1.798,15.762) BJ23(-2.586,15.762) BJ24(-3.373,15.762) BJ25(-4.161,15.762) BJ26(-4.948,15.762) BJ27(-5.735,15.762) BJ28(-6.523,15.762) BJ29(-7.183,15.844) BJ30(-8.039,16.015) BK14(4.501,16.413) BK15(3.713,16.413) BK16(2.926,16.413) BK17(2.139,16.413) BK18(1.351,16.413) BK19(0.564,16.413) BK20(-0.224,16.413) BK21(-1.011,16.413) BK22(-1.798,16.413) BK23(-2.586,16.413) BK24(-3.373,16.413) BK25(-4.161,16.413) BK26(-4.948,16.413) BK27(-5.735,16.413) BK28(-6.523,16.413) BK29(-7.518,16.421) BN1(13.314,18.3) BN38(-13.314,18.285) BP1(13.314,19.024) BP38(-13.314,18.996) BR2(12.596,19.619) BR37(-12.59,19.613) BT3(12.019,20.314) BT4(11.295,20.314) BT35(-11.184,20.314) BT36(-11.996,20.314) C2(12.616,-18.953) C38(-13.314,-18.98) D1(13.314,-18.323) D38(-13.314,-18.218) H13(5.059,-15.712) H14(4.272,-15.712) H15(3.484,-15.712) H16(2.697,-15.712) H17(1.91,-15.712) H18(1.122,-15.712) H19(0.335,-15.712) H20(-0.453,-15.712) H21(-1.24,-15.712) H22(-2.027,-15.712) H23(-2.815,-15.712) H24(-3.602,-15.712) H25(-4.39,-15.712) H26(-5.177,-15.712) H27(-5.964,-15.712) H28(-6.752,-15.712) H29(-7.539,-15.762) J14(4.272,-15.061) J15(3.484,-15.061) J16(2.697,-15.061) J17(1.91,-15.061) J18(1.122,-15.061) J19(0.335,-15.061) J20(-0.453,-15.061) J21(-1.24,-15.061) J22(-2.027,-15.061) J23(-2.815,-15.061) J24(-3.602,-15.061) J25(-4.39,-15.061) J26(-5.177,-15.061) J27(-5.964,-15.061) J28(-6.752,-15.061) J30(-7.747,-15.146) K13(5.436,-15.138) K14(4.851,-14.656) K29(-7.411,-14.56) K30(-8.061,-14.56) L13(5.502,-13.996) L14(4.851,-13.996) L29(-7.411,-13.773) L30(-8.061,-13.773) M13(5.502,-13.081) M14(4.851,-13.081) M29(-7.411,-12.985) M30(-8.061,-12.985) N13(5.502,-12.167) N14(4.851,-12.167) N29(-7.411,-12.198) N30(-8.061,-12.198) P13(5.502,-11.252) P14(4.851,-11.252) P29(-7.411,-11.411) P30(-8.061,-11.411) R13(5.502,-10.338) R14(4.851,-10.338) R29(-7.411,-10.623) R30(-8.061,-10.623) T13(5.502,-9.424) T14(4.851,-9.424) T29(-7.411,-9.836) T30(-8.061,-9.836) U29(-7.411,-9.048) U30(-8.061,-9.048) V13(5.502,-8.509) V14(4.851,-8.509) V29(-7.411,-8.261) V30(-8.061,-8.261) W13(5.502,-7.595) W14(4.851,-7.595) W29(-7.411,-7.474) W30(-8.061,-7.474) Y13(5.502,-6.68) Y14(4.851,-6.68) Y29(-7.411,-6.686) Y30(-8.061,-6.686)
  round 0.356 smd: A5(10.543,-20.314) A33(-10.345,-20.314) B4(11.283,-19.344) B36(-11.884,-19.613) BM1(13.314,17.5) BM38(-13.314,17.573) BP2(12.486,18.965) BP37(-12.374,18.943) BR3(11.927,19.664) BR36(-11.879,19.657) BT5(10.495,20.314) BT34(-10.384,20.314) C37(-12.594,-18.912) D3(12.081,-18.492) E1(13.314,-17.536) E38(-13.314,-17.418)
  round 0.33 smd: A6(9.768,-20.314) A32(-9.558,-20.314) AA11(6.802,-5.766) AA12(6.152,-5.766) AC11(6.802,-4.852) AC12(6.152,-4.852) AD11(6.802,-3.937) AD12(6.152,-3.937) AE11(6.802,-3.023) AE12(6.152,-3.023) AF11(6.802,-2.108) AF12(6.152,-2.108) AG11(6.802,-1.194) AG12(6.152,-1.194) AH11(6.802,-0.28) AH12(6.152,-0.28) AJ11(6.802,0.635) AJ12(6.152,0.635) AL11(6.802,1.549) AL12(6.152,1.549) AM11(6.802,2.464) AM12(6.152,2.464) AN11(6.802,3.378) AN12(6.152,3.378) AP11(6.802,4.292) AP12(6.152,4.292) AR11(6.802,5.207) AR12(6.152,5.207) AT11(6.802,6.121) AT12(6.152,6.121) AU11(6.802,7.036) AU12(6.152,7.036) AW11(6.802,7.95) AW12(6.152,7.95) AY11(6.802,8.864) AY12(6.152,8.864) B5(10.571,-19.664) B34(-11.129,-19.645) BA11(6.802,9.779) BA12(6.152,9.779) BB11(6.802,10.693) BB12(6.152,10.693) BC11(6.802,11.608) BC12(6.152,11.608) BD11(6.802,12.522) BD12(6.152,12.522) BF11(6.802,13.436) BF12(6.152,13.436) BG11(6.802,14.351) BG12(6.152,14.351) BH11(6.802,15.265) BH12(6.152,15.265) BJ11(6.802,16.18) BJ12(6.032,16.091) BK1(13.314,16.722) BK13(5.415,16.413) BL38(-13.314,16.862) BN2(12.664,18.328) BN37(-12.651,18.35) BR5(11.148,19.67) BR35(-11.222,19.664) BT6(9.721,20.314) BT32(-9.609,20.314) D37(-12.289,-18.329) E2(12.664,-17.84) G1(13.314,-16.733) G38(-13.314,-16.643) K11(6.802,-14.834) K12(6.152,-14.834) L11(6.802,-13.996) L12(6.152,-13.996) M11(6.802,-13.081) M12(6.152,-13.081) N11(6.802,-12.167) N12(6.152,-12.167) P11(6.802,-11.252) P12(6.152,-11.252) R11(6.802,-10.338) R12(6.152,-10.338) T11(6.802,-9.424) T12(6.152,-9.424) V11(6.802,-8.509) V12(6.152,-8.509) W11(6.802,-7.595) W12(6.152,-7.595) Y11(6.802,-6.68) Y12(6.152,-6.68)
  round 0.305 smd: A8(8.996,-20.314) A9(8.209,-20.314) A10(7.421,-20.314) A11(6.634,-20.314) A12(5.847,-20.314) A13(5.059,-20.314) A14(4.272,-20.314) A15(3.484,-20.314) A16(2.697,-20.314) A17(1.91,-20.314) A18(1.122,-20.314) A19(0.335,-20.314) A20(-0.453,-20.314) A21(-1.24,-20.314) A22(-2.027,-20.314) A23(-2.815,-20.314) A24(-3.602,-20.314) A25(-4.39,-20.314) A26(-5.177,-20.314) A27(-5.964,-20.314) A28(-6.752,-20.314) A29(-7.539,-20.314) A30(-8.53,-20.314) AA1(13.314,-6.295) AA2(12.664,-6.295) AA3(12.014,-6.295) AA4(11.363,-6.295) AA5(10.713,-6.295) AA6(10.063,-6.346) AA7(9.403,-5.766) AA8(8.753,-5.766) AA9(8.103,-5.766) AA10(7.452,-5.766) AA31(-8.762,-5.899) AA32(-9.413,-5.899) AA33(-10.063,-5.899) AA34(-10.713,-5.899) AA35(-11.363,-5.899) AA36(-12.014,-5.899) AA37(-12.664,-5.899) AA38(-13.314,-5.899) AB1(13.314,-5.559) AB2(12.664,-5.559) AB3(12.014,-5.559) AB4(11.363,-5.559) AB5(10.713,-5.559) AB6(10.063,-5.508) AB31(-8.762,-5.111) AB32(-9.413,-5.111) AB33(-10.063,-5.111) AB34(-10.713,-5.111) AB35(-11.363,-5.111) AB36(-12.014,-5.111) AB37(-12.664,-5.111) AB38(-13.314,-5.111) AC1(13.314,-4.67) AC2(12.664,-4.67) AC3(12.014,-4.67) AC4(11.363,-4.67) AC5(10.713,-4.67) AC6(10.063,-4.67) AC7(9.403,-4.852) AC8(8.753,-4.852) AC9(8.103,-4.852) AC10(7.452,-4.852) AC31(-8.762,-4.324) AC32(-9.413,-4.324) AC33(-10.063,-4.324) AC34(-10.713,-4.324) AC35(-11.363,-4.324) AC36(-12.014,-4.324) AC37(-12.664,-4.324) AC38(-13.314,-4.324) AD1(13.314,-3.781) AD2(12.664,-3.781) AD3(12.014,-3.781) AD4(11.363,-3.781) AD5(10.713,-3.781) AD6(10.063,-3.831) AD7(9.403,-3.937) AD8(8.753,-3.937) AD9(8.103,-3.937) AD10(7.452,-3.937) AD31(-8.762,-3.537) AD32(-9.413,-3.537) AD33(-10.063,-3.537) AD34(-10.713,-3.537) AD35(-11.363,-3.537) AD36(-12.014,-3.537) AD37(-12.664,-3.537) AD38(-13.314,-3.537) AE1(13.314,-3.044) AE2(12.664,-3.044) AE3(12.014,-3.044) AE4(11.363,-3.044) AE5(10.713,-3.044) AE6(10.063,-2.993) AE7(9.403,-3.023) AE8(8.753,-3.023) AE9(8.103,-3.023) AE10(7.452,-3.023) AE31(-8.762,-2.749) AE32(-9.413,-2.749) AE33(-10.063,-2.749) AE34(-10.713,-2.749) AE35(-11.363,-2.749) AE36(-12.014,-2.749) AE37(-12.664,-2.749) AE38(-13.314,-2.749) AF1(13.314,-2.155) AF2(12.664,-2.155) AF3(12.014,-2.155) AF4(11.363,-2.155) AF5(10.713,-2.155) AF6(10.063,-2.155) AF7(9.403,-2.108) AF8(8.753,-2.108) AF9(8.103,-2.108) AF10(7.452,-2.108) AF31(-8.762,-1.962) AF32(-9.413,-1.962) AF33(-10.063,-1.962) AF34(-10.713,-1.962) AF35(-11.363,-1.962) AF36(-12.014,-1.962) AF37(-12.664,-1.962) AF38(-13.314,-1.962) AG1(13.314,-1.266) AG2(12.664,-1.266) AG3(12.014,-1.266) AG4(11.363,-1.266) AG5(10.713,-1.266) AG6(10.063,-1.317) AG7(9.403,-1.194) AG8(8.753,-1.194) AG9(8.103,-1.194) AG10(7.452,-1.194) AG31(-8.762,-1.174) AG32(-9.413,-1.174) AG33(-10.063,-1.174) AG34(-10.713,-1.174) AG35(-11.363,-1.174) AG36(-12.014,-1.174) AG37(-12.664,-1.174) AG38(-13.314,-1.174) AH1(13.314,-0.529) AH2(12.664,-0.529) AH3(12.014,-0.529) AH4(11.363,-0.529) AH5(10.713,-0.529) AH6(10.063,-0.479) AH7(9.403,-0.28) AH8(8.753,-0.28) AH9(8.103,-0.28) AH10(7.452,-0.28) AH31(-8.762,-0.387) AH32(-9.413,-0.387) AH33(-10.063,-0.387) AH34(-10.713,-0.387) AH35(-11.363,-0.387) AH36(-12.014,-0.387) AH37(-12.664,-0.387) AH38(-13.314,-0.387) AJ1(13.314,0.36) AJ2(12.664,0.36) AJ3(12.014,0.36) AJ4(11.363,0.36) AJ5(10.713,0.36) AJ6(10.063,0.36) AJ7(9.403,0.635) AJ8(8.753,0.635) AJ9(8.103,0.635) AJ10(7.452,0.635) AJ31(-8.762,0.4) AJ32(-9.413,0.4) AJ33(-10.063,0.4) AJ34(-10.713,0.4) AJ35(-11.363,0.4) AJ36(-12.014,0.4) AJ37(-12.664,0.4) AJ38(-13.314,0.4) AK1(13.314,1.249) AK2(12.664,1.249) AK3(12.014,1.249) AK4(11.363,1.249) AK5(10.713,1.249) AK6(10.063,1.198) AK31(-8.762,1.188) AK32(-9.413,1.188) AK33(-10.063,1.188) AK34(-10.713,1.188) AK35(-11.363,1.188) AK36(-12.014,1.188) AK37(-12.664,1.188) AK38(-13.314,1.188) AL1(13.314,1.985) AL2(12.664,1.985) AL3(12.014,1.985) AL4(11.363,1.985) AL5(10.713,1.985) AL6(10.063,2.036) AL7(9.403,1.549) AL8(8.753,1.549) AL9(8.103,1.549) AL10(7.452,1.549) AL31(-8.762,1.975) AL32(-9.413,1.975) AL33(-10.063,1.975) AL34(-10.713,1.975) AL35(-11.363,1.975) AL36(-12.014,1.975) AL37(-12.664,1.975) AL38(-13.314,1.975) AM1(13.314,2.874) AM2(12.664,2.874) AM3(12.014,2.874) AM4(11.363,2.874) AM5(10.713,2.874) AM6(10.063,2.874) AM7(9.403,2.464) AM8(8.753,2.464) AM9(8.103,2.464) AM10(7.452,2.464) AM31(-8.762,2.763) AM32(-9.413,2.763) AM33(-10.063,2.763) AM34(-10.713,2.763) AM35(-11.363,2.763) AM36(-12.014,2.763) AM37(-12.664,2.763) AM38(-13.314,2.763) AN1(13.314,3.763) AN2(12.664,3.763) AN3(12.014,3.763) AN4(11.363,3.763) AN5(10.713,3.763) AN6(10.063,3.712) AN7(9.403,3.378) AN8(8.753,3.378) AN9(8.103,3.378) AN10(7.452,3.378) AN31(-8.762,3.55) AN32(-9.413,3.55) AN33(-10.063,3.55) AN34(-10.713,3.55) AN35(-11.363,3.55) AN36(-12.014,3.55) AN37(-12.664,3.55) AN38(-13.314,3.55) AP1(13.314,4.5) AP2(12.664,4.5) AP3(12.014,4.5) AP4(11.363,4.5) AP5(10.713,4.5) AP6(10.063,4.551) AP7(9.403,4.292) AP8(8.753,4.292) AP9(8.103,4.292) AP10(7.452,4.292) AP31(-8.762,4.337) AP32(-9.413,4.337) AP33(-10.063,4.337) AP34(-10.713,4.337) AP35(-11.363,4.337) AP36(-12.014,4.337) AP37(-12.664,4.337) AP38(-13.314,4.337) AR1(13.314,5.389) AR2(12.664,5.389) AR3(12.014,5.389) AR4(11.363,5.389) AR5(10.713,5.389) AR6(10.063,5.389) AR7(9.403,5.207) AR8(8.753,5.207) AR9(8.103,5.207) AR10(7.452,5.207) AR31(-8.762,5.125) AR32(-9.413,5.125) AR33(-10.063,5.125) AR34(-10.713,5.125) AR35(-11.363,5.125) AR36(-12.014,5.125) AR37(-12.664,5.125) AR38(-13.314,5.125) AT1(13.314,6.278) AT2(12.664,6.278) AT3(12.014,6.278) AT4(11.363,6.278) AT5(10.713,6.278) AT6(10.063,6.227) AT7(9.403,6.121) AT8(8.753,6.121) AT9(8.103,6.121) AT10(7.452,6.121) AT31(-8.762,5.912) AT32(-9.413,5.912) AT33(-10.063,5.912) AT34(-10.713,5.912) AT35(-11.363,5.912) AT36(-12.014,5.912) AT37(-12.664,5.912) AT38(-13.314,5.912) AU1(13.314,7.014) AU2(12.664,7.014) AU3(12.014,7.014) AU4(11.363,7.014) AU5(10.713,7.014) AU6(10.063,7.065) AU7(9.403,7.036) AU8(8.753,7.036) AU9(8.103,7.036) AU10(7.452,7.036) AU31(-8.762,6.7) AU32(-9.413,6.7) AU33(-10.063,6.7) AU34(-10.713,6.7) AU35(-11.363,6.7) AU36(-12.014,6.7) AU37(-12.664,6.7) AU38(-13.314,6.7) AV31(-8.762,7.487) AV32(-9.413,7.487) AV33(-10.063,7.487) AV34(-10.713,7.487) AV35(-11.363,7.487) AV36(-12.014,7.487) AV37(-12.664,7.487) AV38(-13.314,7.487) AW1(13.314,7.903) AW2(12.664,7.903) AW3(12.014,7.903) AW4(11.363,7.903) AW5(10.713,7.903) AW6(10.063,7.903) AW7(9.403,7.95) AW8(8.753,7.95) AW9(8.103,7.95) AW10(7.452,7.95) AW31(-8.762,8.274) AW32(-9.413,8.274) AW33(-10.063,8.274) AW34(-10.713,8.274) AW35(-11.363,8.274) AW36(-12.014,8.274) AW37(-12.664,8.274) AW38(-13.314,8.274) AY1(13.314,8.792) AY2(12.664,8.792) AY3(12.014,8.792) AY4(11.363,8.792) AY5(10.713,8.792) AY6(10.063,8.742) AY7(9.403,8.864) AY8(8.753,8.864) AY9(8.103,8.864) AY10(7.452,8.864) AY31(-8.762,9.062) AY32(-9.413,9.062) AY33(-10.063,9.062) AY34(-10.713,9.062) AY35(-11.363,9.062) AY36(-12.014,9.062) AY37(-12.664,9.062) AY38(-13.314,9.062) B6(9.784,-19.664) B8(8.996,-19.664) B9(8.209,-19.664) B10(7.421,-19.664) B11(6.634,-19.664) B12(5.847,-19.664) B13(5.059,-19.664) B14(4.272,-19.664) B15(3.484,-19.664) B16(2.697,-19.664) B17(1.91,-19.664) B18(1.122,-19.664) B19(0.335,-19.664) B20(-0.453,-19.664) B21(-1.24,-19.664) B22(-2.027,-19.664) B23(-2.815,-19.664) B24(-3.602,-19.664) B25(-4.39,-19.664) B26(-5.177,-19.664) B27(-5.964,-19.664) B28(-6.752,-19.664) B29(-7.539,-19.664) B30(-8.327,-19.664) B31(-9.114,-19.664) B33(-9.901,-19.664) BA1(13.314,9.529) BA2(12.664,9.529) BA3(12.014,9.529) BA4(11.363,9.529) BA5(10.713,9.529) BA6(10.063,9.58) BA7(9.403,9.779) BA8(8.753,9.779) BA9(8.103,9.779) BA10(7.452,9.779) BA31(-8.762,9.849) BA32(-9.413,9.849) BA33(-10.063,9.849) BA34(-10.713,9.849) BA35(-11.363,9.849) BA36(-12.014,9.849) BA37(-12.664,9.849) BA38(-13.314,9.849) BB1(13.314,10.418) BB2(12.664,10.418) BB3(12.014,10.418) BB4(11.363,10.418) BB5(10.713,10.418) BB6(10.063,10.418) BB7(9.403,10.693) BB8(8.753,10.693) BB9(8.103,10.693) BB10(7.452,10.693) BB31(-8.762,10.637) BB32(-9.413,10.637) BB33(-10.063,10.637) BB34(-10.713,10.637) BB35(-11.363,10.637) BB36(-12.014,10.637) BB37(-12.664,10.637) BB38(-13.314,10.637) BC1(13.314,11.307) BC2(12.664,11.307) BC3(12.014,11.307) BC4(11.363,11.307) BC5(10.713,11.307) BC6(10.063,11.256) BC7(9.403,11.608) BC8(8.753,11.608) BC9(8.103,11.608) BC10(7.452,11.608) BC31(-8.762,11.424) BC32(-9.413,11.424) BC33(-10.063,11.424) BC34(-10.713,11.424) BC35(-11.363,11.424) BC36(-12.014,11.424) BC37(-12.664,11.424) BC38(-13.314,11.424) BD1(13.314,12.044) BD2(12.664,12.044) BD3(12.014,12.044) BD4(11.363,12.044) BD5(10.713,12.044) BD6(10.063,12.094) BD7(9.403,12.522) BD8(8.753,12.522) BD9(8.103,12.522) BD10(7.452,12.522) BD31(-8.762,12.211) BD32(-9.413,12.211) BD33(-10.063,12.211) BD34(-10.713,12.211) BD35(-11.363,12.211) BD36(-12.014,12.211) BD37(-12.664,12.211) BD38(-13.314,12.211) BE1(13.314,12.933) BE2(12.664,12.933) BE3(12.014,12.933) BE4(11.363,12.933) BE5(10.713,12.933) BE6(10.063,12.933) BE31(-8.762,12.999) BE32(-9.413,12.999) BE33(-10.063,12.999) BE34(-10.713,12.999) BE35(-11.363,12.999) BE36(-12.014,12.999) BE37(-12.664,12.999) BE38(-13.314,12.999) BF1(13.314,13.822) BF2(12.664,13.822) BF3(12.014,13.822) BF4(11.363,13.822) BF5(10.713,13.822) BF6(10.063,13.771) BF7(9.403,13.436) BF8(8.753,13.436) BF9(8.103,13.436) BF10(7.452,13.436) BF31(-8.762,13.786) BF32(-9.413,13.786) BF33(-10.063,13.786) BF34(-10.713,13.786) BF35(-11.363,13.786) BF36(-12.014,13.786) BF37(-12.664,13.786) BF38(-13.314,13.786) BG1(13.314,14.558) BG2(12.664,14.558) BG3(12.014,14.558) BG4(11.363,14.558) BG5(10.713,14.558) BG6(10.063,14.609) BG7(9.403,14.351) BG8(8.753,14.351) BG9(8.103,14.351) BG10(7.452,14.351) BG31(-8.762,14.574) BG32(-9.413,14.574) BG33(-10.063,14.574) BG34(-10.713,14.574) BG35(-11.363,14.574) BG36(-12.014,14.574) BG37(-12.664,14.574) BG38(-13.314,14.574) BH1(13.314,15.701) BH2(12.664,15.447) BH3(12.014,15.447) BH4(11.363,15.447) BH5(10.713,15.447) BH6(10.063,15.447) BH7(9.403,15.265) BH8(8.753,15.265) BH9(8.103,15.265) BH10(7.452,15.265) BH31(-8.762,15.361) BH32(-9.413,15.361) BH33(-10.063,15.361) BH34(-10.713,15.361) BH35(-11.363,15.361) BH36(-12.014,15.361) BH37(-12.664,15.361) BH38(-13.314,15.361) BJ7(9.403,16.18) BJ8(8.753,16.18) BJ9(8.103,16.18) BJ10(7.452,16.18) BJ31(-8.762,16.148) BJ32(-9.413,16.148) BJ33(-10.063,16.148) BJ34(-10.713,16.148) BJ35(-11.363,16.148) BJ36(-12.014,16.148) BJ37(-12.664,16.148) BJ38(-13.314,16.098) BK2(12.664,16.285) BK3(12.014,16.285) BK4(11.363,16.285) BK5(10.713,16.285) BK6(10.063,16.285) BL2(12.664,17.124) BL3(12.014,17.073) BL4(11.363,17.073) BL5(10.713,17.073) BL6(10.063,17.124) BL7(9.327,17.069) BL8(8.438,17.063) BL9(7.65,17.063) BL11(6.863,17.063) BL12(6.076,17.063) BL13(5.288,17.063) BL14(4.501,17.063) BL15(3.713,17.063) BL16(2.926,17.063) BL17(2.139,17.063) BL18(1.351,17.063) BL19(0.564,17.063) BL20(-0.224,17.063) BL21(-1.011,17.063) BL22(-1.798,17.063) BL23(-2.586,17.063) BL24(-3.373,17.063) BL25(-4.161,17.063) BL26(-4.948,17.063) BL27(-5.735,17.063) BL28(-6.523,17.063) BL29(-7.31,17.063) BL30(-8.112,16.936) BL31(-8.762,16.936) BL32(-9.413,16.936) BL33(-10.063,16.936) BL34(-10.713,16.936) BL35(-11.363,16.936) BL36(-12.014,16.936) BL37(-12.664,16.936) BM2(12.352,17.738) BM3(11.701,17.815) BM5(10.789,17.815) BM6(10.145,17.916) BM7(9.225,17.713) BM8(8.438,17.713) BM9(7.65,17.713) BM11(6.863,17.713) BM12(6.076,17.713) BM13(5.288,17.713) BM14(4.501,17.713) BM15(3.713,17.713) BM16(2.926,17.713) BM17(2.139,17.713) BM18(1.351,17.713) BM19(0.564,17.713) BM20(-0.224,17.713) BM21(-1.011,17.713) BM22(-1.798,17.713) BM23(-2.586,17.713) BM24(-3.373,17.713) BM25(-4.161,17.713) BM26(-4.948,17.713) BM27(-5.735,17.713) BM28(-6.523,17.713) BM29(-7.31,17.713) BM30(-8.098,17.713) BM31(-8.885,17.713) BM33(-9.672,17.713) BM34(-10.46,17.713) BM35(-11.247,17.713) BM36(-12.014,17.672) BM37(-12.664,17.672) BN3(12.014,18.387) BN4(11.209,18.315) BN5(10.566,18.479) BN7(9.225,18.363) BN8(8.438,18.363) BN9(7.65,18.363) BN11(6.863,18.363) BN12(6.076,18.363) BN13(5.288,18.363) BN14(4.501,18.363) BN15(3.713,18.363) BN16(2.926,18.363) BN17(2.139,18.363) BN18(1.351,18.363) BN19(0.564,18.363) BN20(-0.224,18.363) BN21(-1.011,18.363) BN22(-1.798,18.363) BN23(-2.586,18.363) BN24(-3.373,18.363) BN25(-4.161,18.363) BN26(-4.948,18.363) BN27(-5.735,18.363) BN28(-6.523,18.363) BN29(-7.31,18.363) BN30(-8.098,18.363) BN31(-8.885,18.363) BN33(-9.672,18.363) BN34(-10.46,18.363) BN35(-11.248,18.363) BN36(-11.999,18.324) BP3(11.831,19.02) BP5(10.94,19.037) BP6(10.02,18.974) BP7(9.225,19.014) BP8(8.438,19.014) BP9(7.65,19.014) BP11(6.863,19.014) BP12(6.076,19.014) BP13(5.288,19.014) BP14(4.501,19.014) BP15(3.713,19.014) BP16(2.926,19.014) BP17(2.139,19.014) BP18(1.351,19.014) BP19(0.564,19.014) BP20(-0.224,19.014) BP21(-1.011,19.014) BP22(-1.798,19.014) BP23(-2.586,19.014) BP24(-3.373,19.014) BP25(-4.161,19.014) BP26(-4.948,19.014) BP27(-5.735,19.014) BP28(-6.523,19.014) BP29(-7.31,19.014) BP30(-8.098,19.014) BP31(-8.885,19.014) BP33(-9.672,19.014) BP34(-10.46,19.014) BP35(-11.247,19.014) BR6(10.122,19.647) BR7(9.225,19.664) BR8(8.438,19.664) BR9(7.65,19.664) BR11(6.863,19.664) BR12(6.076,19.664) BR13(5.288,19.664) BR14(4.501,19.664) BR15(3.713,19.664) BR16(2.926,19.664) BR17(2.139,19.664) BR18(1.351,19.664) BR19(0.564,19.664) BR20(-0.224,19.664) BR21(-1.011,19.664) BR22(-1.798,19.664) BR23(-2.586,19.664) BR24(-3.373,19.664) BR25(-4.161,19.664) BR26(-4.948,19.664) BR27(-5.735,19.664) BR28(-6.523,19.664) BR29(-7.31,19.664) BR30(-8.098,19.664) BR31(-8.885,19.664) BR33(-9.672,19.664) BR34(-10.46,19.664) BT8(8.666,20.314) BT9(7.65,20.314) BT11(6.863,20.314) BT12(6.076,20.314) BT13(5.288,20.314) BT14(4.501,20.314) BT15(3.713,20.314) BT16(2.926,20.314) BT17(2.139,20.314) BT18(1.351,20.314) BT19(0.564,20.314) BT20(-0.224,20.314) BT21(-1.011,20.314) BT22(-1.798,20.314) BT23(-2.586,20.314) BT24(-3.373,20.314) BT25(-4.161,20.314) BT26(-4.948,20.314) BT27(-5.735,20.314) BT28(-6.523,20.314) BT29(-7.31,20.314) BT30(-8.098,20.314) BT31(-8.86,20.314) C5(10.571,-19.014) C6(9.784,-19.014) C8(8.996,-19.014) C9(8.209,-19.014) C10(7.421,-19.014) C11(6.634,-19.014) C12(5.847,-19.014) C13(5.059,-19.014) C14(4.272,-19.014) C15(3.484,-19.014) C16(2.697,-19.014) C17(1.91,-19.014) C18(1.122,-19.014) C19(0.335,-19.014) C20(-0.453,-19.014) C21(-1.24,-19.014) C22(-2.027,-19.014) C23(-2.815,-19.014) C24(-3.602,-19.014) C25(-4.39,-19.014) C26(-5.177,-19.014) C27(-5.964,-19.014) C28(-6.752,-19.014) C29(-7.539,-19.014) C30(-8.327,-19.014) C31(-9.114,-19.014) C33(-9.901,-19.014) C34(-10.697,-19.025) C36(-11.831,-18.926) D4(11.42,-18.66) D5(10.571,-18.363) D6(9.784,-18.363) D8(8.996,-18.363) D9(8.209,-18.363) D10(7.421,-18.363) D11(6.634,-18.363) D12(5.847,-18.363) D13(5.059,-18.363) D14(4.272,-18.363) D15(3.484,-18.363) D16(2.697,-18.363) D17(1.91,-18.363) D18(1.122,-18.363) D19(0.335,-18.363) D20(-0.453,-18.363) D21(-1.24,-18.363) D22(-2.027,-18.363) D23(-2.815,-18.363) D24(-3.602,-18.363) D25(-4.39,-18.363) D26(-5.177,-18.363) D27(-5.964,-18.363) D28(-6.752,-18.363) D29(-7.539,-18.363) D30(-8.327,-18.363) D31(-9.114,-18.363) D33(-9.901,-18.363) D34(-10.689,-18.363) D35(-11.341,-18.453) E3(12.014,-17.84) E4(11.363,-17.739) E5(10.571,-17.713) E6(9.784,-17.713) E8(8.996,-17.713) E9(8.209,-17.713) E10(7.421,-17.713) E11(6.634,-17.713) E12(5.847,-17.713) E13(5.059,-17.713) E14(4.272,-17.713) E15(3.484,-17.713) E16(2.697,-17.713) E17(1.91,-17.713) E18(1.122,-17.713) E19(0.335,-17.713) E20(-0.453,-17.713) E21(-1.24,-17.713) E22(-2.027,-17.713) E23(-2.815,-17.713) E24(-3.602,-17.713) E25(-4.39,-17.713) E26(-5.177,-17.713) E27(-5.964,-17.713) E28(-6.752,-17.713) E29(-7.539,-17.713) E30(-8.327,-17.713) E31(-9.114,-17.713) E33(-9.901,-17.713) E34(-10.689,-17.713) E35(-11.363,-17.71) E36(-12.014,-17.71) E37(-12.664,-17.71) F2(12.664,-17.155) F3(12.014,-17.155) F4(11.363,-17.053) F5(10.571,-17.041) F6(9.784,-17.041) F8(8.996,-17.063) F9(8.209,-17.063) F10(7.421,-17.063) F11(6.634,-17.063) F12(5.847,-17.063) F13(5.059,-17.063) F14(4.272,-17.063) F15(3.484,-17.063) F16(2.697,-17.063) F17(1.91,-17.063) F18(1.122,-17.063) F19(0.335,-17.063) F20(-0.453,-17.063) F21(-1.24,-17.063) F22(-2.027,-17.063) F23(-2.815,-17.063) F24(-3.602,-17.063) F25(-4.39,-17.063) F26(-5.177,-17.063) F27(-5.964,-17.063) F28(-6.752,-17.063) F29(-7.539,-17.063) F30(-8.327,-17.063) F31(-9.114,-17.063) F33(-9.901,-17.063) F34(-10.713,-16.922) F35(-11.363,-16.922) F36(-12.014,-16.922) F37(-12.664,-16.922) G2(12.664,-16.367) G3(12.014,-16.367) G4(11.363,-16.367) G5(10.713,-16.367) G6(10.063,-16.367) G8(8.996,-16.413) G9(8.209,-16.413) G10(7.421,-16.413) G11(6.634,-16.413) G12(5.847,-16.413) G13(5.059,-16.413) G14(4.272,-16.413) G15(3.484,-16.413) G16(2.697,-16.413) G17(1.91,-16.413) G18(1.122,-16.413) G19(0.335,-16.413) G20(-0.453,-16.413) G21(-1.24,-16.413) G22(-2.027,-16.413) G23(-2.815,-16.413) G24(-3.602,-16.413) G25(-4.39,-16.413) G26(-5.177,-16.413) G27(-5.964,-16.413) G28(-6.752,-16.413) G29(-7.539,-16.413) G30(-8.327,-16.413) H1(13.314,-15.871) H11(6.634,-15.762) H12(5.847,-15.762) H30(-8.289,-15.762) H32(-9.413,-16.135) H33(-10.063,-16.135) H34(-10.713,-16.135) H35(-11.363,-16.135) H36(-12.014,-16.135) H37(-12.664,-16.135) J2(12.664,-15.566) J3(12.014,-15.566) J4(11.363,-15.566) J5(10.713,-15.566) J6(10.063,-15.566) J7(9.421,-15.695) J8(8.773,-15.598) J9(8.103,-15.621) J10(7.421,-15.686) J31(-8.762,-15.31) J32(-9.413,-15.348) J33(-10.063,-15.348) J34(-10.713,-15.348) J35(-11.363,-15.348) J36(-12.014,-15.348) J37(-12.664,-15.348) J38(-13.314,-15.602) K1(13.314,-14.728) K2(12.664,-14.728) K3(12.014,-14.728) K4(11.363,-14.728) K5(10.713,-14.728) K6(10.063,-14.728) K7(9.403,-14.758) K8(8.753,-14.834) K9(8.103,-14.834) K10(7.452,-14.834) K31(-8.762,-14.56) K32(-9.413,-14.56) K33(-10.063,-14.56) K34(-10.713,-14.56) K35(-11.363,-14.56) K36(-12.014,-14.56) K37(-12.664,-14.56) K38(-13.314,-14.56) L1(13.314,-13.839) L2(12.664,-13.839) L3(12.014,-13.839) L4(11.363,-13.839) L5(10.713,-13.839) L6(10.063,-13.89) L7(9.403,-13.919) L8(8.753,-13.97) L9(8.103,-13.996) L10(7.452,-13.996) L31(-8.762,-13.773) L32(-9.413,-13.773) L33(-10.063,-13.773) L34(-10.713,-13.773) L35(-11.363,-13.773) L36(-12.014,-13.773) L37(-12.664,-13.773) L38(-13.314,-13.773) M1(13.314,-13.102) M2(12.664,-13.102) M3(12.014,-13.102) M4(11.363,-13.102) M5(10.713,-13.102) M6(10.063,-13.052) M7(9.403,-13.081) M8(8.753,-13.081) M9(8.103,-13.081) M10(7.452,-13.081) M31(-8.762,-12.985) M32(-9.413,-12.985) M33(-10.063,-12.985) M34(-10.713,-12.985) M35(-11.363,-12.985) M36(-12.014,-12.985) M37(-12.664,-12.985) M38(-13.314,-12.985) N1(13.314,-12.213) N2(12.664,-12.213) N3(12.014,-12.213) N4(11.363,-12.213) N5(10.713,-12.213) N6(10.063,-12.213) N7(9.403,-12.167) N8(8.753,-12.167) N9(8.103,-12.167) N10(7.452,-12.167) N31(-8.762,-12.198) N32(-9.413,-12.198) N33(-10.063,-12.198) N34(-10.713,-12.198) N35(-11.363,-12.198) N36(-12.014,-12.198) N37(-12.664,-12.198) N38(-13.314,-12.198) P1(13.314,-11.324) P2(12.664,-11.324) P3(12.014,-11.324) P4(11.363,-11.324) P5(10.713,-11.324) P6(10.063,-11.375) P7(9.403,-11.252) P8(8.753,-11.252) P9(8.103,-11.252) P10(7.452,-11.252) P31(-8.762,-11.411) P32(-9.413,-11.411) P33(-10.063,-11.411) P34(-10.713,-11.411) P35(-11.363,-11.411) P36(-12.014,-11.411) P37(-12.664,-11.411) P38(-13.314,-11.411) R1(13.314,-10.588) R2(12.664,-10.588) R3(12.014,-10.588) R4(11.363,-10.588) R5(10.713,-10.588) R6(10.063,-10.537) R7(9.403,-10.338) R8(8.753,-10.338) R9(8.103,-10.338) R10(7.452,-10.338) R31(-8.762,-10.623) R32(-9.413,-10.623) R33(-10.063,-10.623) R34(-10.713,-10.623) R35(-11.363,-10.623) R36(-12.014,-10.623) R37(-12.664,-10.623) R38(-13.314,-10.623) T1(13.314,-9.699) T2(12.664,-9.699) T3(12.014,-9.699) T4(11.363,-9.699) T5(10.713,-9.699) T6(10.063,-9.699) T7(9.403,-9.424) T8(8.753,-9.424) T9(8.103,-9.424) T10(7.452,-9.424) T31(-8.762,-9.836) T32(-9.413,-9.836) T33(-10.063,-9.836) T34(-10.713,-9.836) T35(-11.363,-9.836) T36(-12.014,-9.836) T37(-12.664,-9.836) T38(-13.314,-9.836) U1(13.314,-8.81) U2(12.664,-8.81) U3(12.014,-8.81) U4(11.363,-8.81) U5(10.713,-8.81) U6(10.063,-8.861) U31(-8.762,-9.048) U32(-9.413,-9.048) U33(-10.063,-9.048) U34(-10.713,-9.048) U35(-11.363,-9.048) U36(-12.014,-9.048) U37(-12.664,-9.048) U38(-13.314,-9.048) V1(13.314,-8.073) V2(12.664,-8.073) V3(12.014,-8.073) V4(11.363,-8.073) V5(10.713,-8.073) V6(10.063,-8.022) V7(9.403,-8.509) V8(8.753,-8.509) V9(8.103,-8.509) V10(7.452,-8.509) V31(-8.762,-8.261) V32(-9.413,-8.261) V33(-10.063,-8.261) V34(-10.713,-8.261) V35(-11.363,-8.261) V36(-12.014,-8.261) V37(-12.664,-8.261) V38(-13.314,-8.261) W1(13.314,-7.184) W2(12.664,-7.184) W3(12.014,-7.184) W4(11.363,-7.184) W5(10.713,-7.184) W6(10.063,-7.184) W7(9.403,-7.595) W8(8.753,-7.595) W9(8.103,-7.595) W10(7.452,-7.595) W31(-8.762,-7.474) W32(-9.413,-7.474) W33(-10.063,-7.474) W34(-10.713,-7.474) W35(-11.363,-7.474) W36(-12.014,-7.474) W37(-12.664,-7.474) W38(-13.314,-7.474) Y7(9.403,-6.68) Y8(8.753,-6.68) Y9(8.103,-6.68) Y10(7.452,-6.68) Y31(-8.762,-6.686) Y32(-9.413,-6.686) Y33(-10.063,-6.686) Y34(-10.713,-6.686) Y35(-11.363,-6.686) Y36(-12.014,-6.686) Y37(-12.664,-6.686) Y38(-13.314,-6.686)
