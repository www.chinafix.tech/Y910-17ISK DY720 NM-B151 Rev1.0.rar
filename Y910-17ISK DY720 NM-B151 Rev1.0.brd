# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DIM1_CK_DDR3_DP: length 71.1
  TOP w0.102: v1(168.56,82.2) 168.4,82.36 167.67,82.36 167.06,82.96 167.06,85.16 166.82,85.4 166.11,85.4 165.15,86.36 JDIMM2.138
  IN03 w0.076: 167.12,122.13 167.12,122.14 167.18,122.19 167.18,127.17 167.11,127.24 166.9,127.24 v1(166.76,127.09)
  IN03 w0.107: v1(168.56,82.2) 168.56,82.25 168.43,82.38 168.19,82.38 168.09,82.27 168.09,81.56 167.84,81.3 167.32,81.3 167.07,81.56 167.07,82.76 167.3,83 167.3,83.86 167.07,84.1 167.07,86.14 165.18,88.03 165.18,101.01 165.44,101.27 165.81,101.27 165.91,101.37 165.91,101.9 165.81,102 165.44,102 165.17,102.28 165.17,102.73 165.42,102.99 166.13,102.99 166.23,103.09 166.23,103.52 166.13,103.63 165.42,103.63 165.17,103.88 165.17,104.53 165.42,104.78 166.13,104.78 166.23,104.89 166.23,105.32 166.13,105.42 165.42,105.42 165.17,105.68 165.17,109.77 165.06,109.88 164.93,109.88 164.67,110.14 164.67,116.74 166.87,118.93 166.95,119.01 166.95,121.04 167.12,121.21 167.12,122.13
  BOTTOM w0.076: 168.16,130.58 168.16,130.6 168.09,130.67 168.09,131.17 167.92,131.35 167.77,131.35 U1.AL2
  BOTTOM w0.102: 168.16,130.58 168.16,128.71 167.79,128.34 167.79,128.16 168.24,127.7 168.24,126.53 167.98,126.27 167.49,126.27 167.23,126.53 167.23,127.17 167.14,127.26 166.85,127.26 166.76,127.17 v1(166.76,127.09)
M_A_DIM1_CKE2: length 64.5
  TOP w0.102: JDIMM2.109 157.9,80.17 157.58,80.5 156.8,80.5 v1(155.61,81.69)
  IN03 w0.14: v1(157.27,123.56) 151.38,117.66 151.38,115.27 149.58,113.47 149.58,95.53 151.73,93.37 151.73,88.09 153.21,86.62 153.21,83.7 155.21,81.69 v1(155.61,81.69)
  BOTTOM w0.076: 163.67,130.01 163.09,130.59 163.09,131.85 U1.AT3
  BOTTOM w0.152: 163.67,130.01 163.67,127.46 162.15,125.94 161.18,125.94 158.8,123.56 v1(157.27,123.56)
M_A_DIM1_CKE3: length 59.2
  TOP w0.102: v1(155.61,85.5) 155.96,85.86 157.23,85.86 158.15,86.78 JDIMM2.110
  IN03 w0.14: v1(163.8,133.09) 159.76,129.05 159.76,124.11 152.55,116.89 152.55,114.66 151.12,113.24 151.12,96.57 151.96,95.74 151.96,95.1 153.49,93.58 153.49,88.24 155.61,86.12 v1(155.61,85.5)
  BOTTOM w0.076: v1(163.8,133.09) 163.48,133.42 U1.AT5
M_A_DIM1_CS2_N: length 73.4
  TOP w0.102: JDIMM2.149 169.9,80.45 171.01,81.56 171.01,84.75 v1(170.59,85.17)
  IN03 w0.14: v1(170.59,85.17) 170.3,85.17 170.17,85.3 170.17,85.68 170.3,85.81 170.58,85.81 170.71,85.94 170.71,86.41 168.99,88.14 168.99,93.04 168.64,93.39 168.64,96.84 169.03,97.23 169.03,97.49 168.9,97.62 168.78,97.62 168.65,97.74 168.65,97.95 168.78,98.07 169.82,98.07 169.95,98.2 169.95,98.4 169.84,98.5 169.13,98.5 169.01,98.63 169.01,98.81 169.13,98.94 170.76,98.94 170.89,99.06 170.89,99.29 170.76,99.42 169.95,99.42 169.82,99.55 169.82,99.77 169.95,99.9 170.89,99.9 171.01,100.03 171.01,100.25 170.89,100.37 169.91,100.37 169.79,100.5 169.79,100.67 169.91,100.79 170.89,100.79 171.01,100.91 171.01,103.63 170.73,103.91 170.73,116.42 170.01,117.14 170.01,119.54 170.09,119.61 170.56,119.61 170.68,119.74 170.68,120.15 170.56,120.27 170.14,120.27 170.01,120.4 170.01,123.49 169.49,124.01 v1(169.34,124.01)
  BOTTOM w0.152: v1(169.34,124.01) 170.71,124.01 170.86,123.86 170.86,123.47 170.76,123.37 170.4,123.37 170.3,123.27 170.3,122.76 170.4,122.66 v2(171.04,122.66) 174.09,122.66 174.59,123.17 174.59,126.47 173.82,127.25 173.82,131.06 U1.AD2
M_A_DIM1_CS3_N: length 72
  TOP w0.102: JDIMM2.157 171.9,80.58 172.12,80.79 173.39,80.79 173.8,81.21 174.73,81.21 175.39,81.87 v1(176.44,81.87)
  IN03 w0.14: v1(176.44,81.87) 175.36,81.87 175.23,81.99 175.23,82.22 175.36,82.35 175.81,82.35 175.94,82.48 175.94,82.7 175.83,82.81 175.33,82.81 175.2,82.93 175.2,83.15 175.34,83.29 175.83,83.29 175.97,83.43 175.97,83.63 175.83,83.77 175.34,83.77 175.19,83.92 175.19,87.81 174.64,88.36 174.64,88.62 174.83,88.8 174.83,90.55 174.73,90.65 174.73,95.06 177.29,97.62 177.29,110.43 177.15,110.57 176.94,110.57 176.8,110.71 176.8,110.99 176.94,111.13 177.15,111.13 177.29,111.27 177.29,111.55 177.15,111.68 176.94,111.68 176.8,111.82 176.8,112.1 176.94,112.24 177.15,112.24 177.29,112.38 177.29,112.66 177.15,112.8 176.94,112.8 176.8,112.94 176.8,113.22 176.94,113.36 177.15,113.36 177.29,113.5 177.29,113.78 177.15,113.92 176.94,113.92 176.8,114.06 176.8,114.34 176.94,114.48 177.15,114.48 177.29,114.62 177.29,114.9 177.15,115.04 176.94,115.04 176.8,115.18 176.8,115.46 176.94,115.6 177.15,115.6 177.29,115.74 177.29,116.02 177.15,116.16 176.94,116.16 176.8,116.29 176.8,116.57 176.94,116.71 177.15,116.71 177.29,116.85 177.29,117.13 177.15,117.27 176.94,117.27 176.8,117.41 176.8,117.69 176.94,117.83 177.15,117.83 177.29,117.97 177.29,118.25 177.15,118.39 176.94,118.39 176.8,118.53 176.8,118.81 176.94,118.95 177.15,118.95 177.29,119.09 177.29,119.44 177.15,119.58 176.94,119.58 176.8,119.72 176.8,120 176.94,120.14 177.15,120.14 177.29,120.28 177.29,120.6 172.74,125.15 172.74,125.78 172.51,126.01 172.51,127.45 172.24,127.71 172.24,127.96 172.37,128.08 172.38,128.08 172.51,128.21 172.51,129.57 172.21,129.87 171.89,129.87 171.79,129.77 v1(171.79,129.66)
  BOTTOM w0.076: v1(171.79,129.66) 171.79,129.69 172.17,130.07 172.17,130.43 172.08,130.52 172.08,131.3 172.16,131.38 172.16,132.67 172.68,133.2 U1.AE5
M_A_DIM1_ODT2: length 69.6
  TOP w0.102: v1(176.44,82.5) 175.59,82.5 174.6,81.51 173.68,81.51 173.26,81.1 171.99,81.1 171.4,80.51 JDIMM2.155
  IN03 w0.14: v1(176.44,82.5) 176.52,82.5 177.16,81.87 177.16,81.03 177.06,80.93 176.8,80.93 176.7,81.03 176.7,81.26 176.6,81.36 176.37,81.36 176.27,81.26 176.27,81.03 176.17,80.93 175.89,80.93 175.79,81.03 175.79,81.26 175.69,81.36 175.43,81.36 175.33,81.26 175.33,81.03 175.23,80.93 174.95,80.93 174.85,81.03 174.85,87.67 173.98,88.54 173.98,90.63 174.26,90.92 174.26,95.33 176.8,97.87 176.8,104.21 176.66,104.35 176.46,104.35 176.32,104.49 176.32,104.77 176.46,104.91 176.66,104.91 176.8,105.05 176.8,105.33 176.66,105.47 176.46,105.47 176.32,105.61 176.32,105.89 176.46,106.03 176.66,106.03 176.8,106.17 176.8,106.45 176.66,106.59 176.46,106.59 176.32,106.73 176.32,107.01 176.46,107.15 176.66,107.15 176.8,107.29 176.8,107.57 176.66,107.71 176.46,107.71 176.32,107.85 176.32,108.13 176.46,108.27 176.66,108.27 176.8,108.41 176.8,108.69 176.66,108.82 176.46,108.82 176.32,108.96 176.32,109.24 176.46,109.38 176.66,109.38 176.8,109.52 176.8,109.8 176.66,109.94 176.46,109.94 176.32,110.08 176.32,121.09 172.46,124.95 172.46,125.66 172.26,125.86 172.26,127.32 v1(171.79,127.79)
  BOTTOM w0.076: U1.AE1 172.77,130.73 172.77,128.77 v1(171.79,127.79)
M_A_DIM1_ODT3: length 72.5
  TOP w0.102: v1(176.44,85.68) 176.84,85.27 176.84,81.7 176.6,81.46 175.42,81.46 174.7,80.75 173.78,80.75 173.51,80.49 173.17,80.49 172.9,80.22 JDIMM2.161
  IN03 w0.14: v1(173.86,133.09) 172.61,133.09 172.49,132.96 172.49,132.77 172.61,132.64 173.2,132.64 173.32,132.52 173.32,132.31 173.2,132.19 172.64,132.19 172.51,132.06 172.51,131.75 172.64,131.63 174.34,131.63 174.47,131.75 174.47,133.36 174.57,133.47 174.9,133.47 175,133.36 175,131.37 174.77,131.14 173.65,131.14 173.53,131.02 173.53,129.54 173.32,129.34 173.32,127.36 173.63,127.05 173.63,125.63 178.77,120.49 178.77,97 176.56,94.79 176.56,93.34 176.43,93.22 176.14,93.22 176.01,93.09 176.01,92.49 176.14,92.36 176.45,92.36 176.58,92.24 176.58,90.17 176.45,90.04 176.14,90.04 176.01,89.91 176.01,88.8 176.31,88.51 176.31,88.17 176.44,88.04 176.73,88.04 176.85,87.91 176.85,86.1 v1(176.44,85.68)
  BOTTOM w0.076: v1(173.86,133.09) 173.53,132.77 U1.AD4
M_A_DQ0: length 86
  TOP w0.102: JDIMM2.7 132.4,80.62 132.53,80.74 132.86,80.74 132.99,80.87 132.99,82.56 132.87,82.68 132.7,82.68 132.58,82.56 132.58,81.84 132.45,81.72 131.89,81.72 131.6,81.43 131.6,80.88 131.73,80.76 131.99,80.76 132.11,80.88 v1(132.11,81.26)
  IN03 w0.13: v1(148.04,133.63) 145.2,133.63 132.46,120.88 132.46,120.3 126.59,114.43 126.59,113.62 124.68,111.71 124.68,90.15 125.22,89.61 125.92,89.61 126.27,89.26 126.27,88.03 128.64,85.66 128.64,82.1 129.48,81.26 v1(132.11,81.26)
  BOTTOM w0.076: U1.BR6 149.93,133.95 148.99,133.95 148.86,134.08 148.49,134.08 v1(148.04,133.63)
  BOTTOM w0.102: JDIMM1.7 134.07,86.62 133.76,86.31 133.76,82.24 132.79,81.26 v1(132.11,81.26)
M_A_DQ1: length 91.1
  TOP w0.102: v1(132.11,84.92) 131.99,84.79 128.72,84.79 128.53,84.98 128.53,85.18 128.65,85.3 130.08,85.3 130.18,85.4 130.18,86.72 130.28,86.82 130.49,86.82 130.59,86.72 130.59,85.4 130.69,85.3 131.36,85.3 131.65,85.59 JDIMM2.4
  IN03 w0.13: v1(132.11,84.92) 132.33,84.92 132.53,85.12 132.53,86.11 132.2,86.44 130.91,86.44 130.56,86.08 130.12,86.08 127.38,88.82 127.38,88.99 127.63,89.24 127.63,89.41 125.45,91.6 125.45,107.36 125.6,107.51 125.6,107.87 125.45,108.03 125.45,108.39 125.6,108.54 125.6,108.91 125.45,109.06 125.45,109.43 125.6,109.58 125.6,109.95 125.45,110.1 125.45,110.46 125.6,110.62 125.6,110.98 125.45,111.13 125.45,111.46 127.35,113.36 127.35,114.18 133.5,120.32 133.5,121.06 144.74,132.3 v1(146.64,132.3)
  BOTTOM w0.076: v1(146.64,132.3) 146.64,133.36 147.68,134.41 U1.BT6
  BOTTOM w0.102: JDIMM1.4 133.32,80.32 133.18,80.46 130.79,80.46 128.62,82.63 128.62,84.28 129.26,84.92 v1(132.11,84.92)
M_A_DQ2: length 84.5
  TOP w0.102: JDIMM2.20 135.65,86.58 135.92,86.31 136.24,86.31 136.58,85.97 136.58,83.04 v1(136.18,82.63)
  IN03 w0.13: v1(136.18,82.63) 136.38,82.83 136.88,82.83 137.48,82.22 137.48,80.8 137.28,80.6 137.02,80.6 136.9,80.73 136.9,81.33 136.77,81.46 136.51,81.46 136.38,81.33 136.38,80.73 136.25,80.6 135.81,80.6 135.05,81.36 135.05,86.18 132.67,88.56 131.83,88.56 131.62,88.78 131.62,91.06 129.38,93.3 129.38,95.33 128.06,96.65 128.06,110.87 129.64,112.45 129.64,113.53 136.21,120.11 136.21,120.93 145.28,129.99 v1(146.67,129.99)
  BOTTOM w0.076: U1.BP3 150.18,131.86 149.88,131.86 149.68,131.67 149.66,131.64 149.66,131.27 149.66,131.19 149.6,131.12
  BOTTOM w0.102: v1(136.18,82.63) 135.66,82.63 135.15,82.12 135.15,81.46 135.45,81.16 136.8,81.16 137.32,80.64 JDIMM1.20
  BOTTOM w0.14: v1(146.67,129.99) 146.79,129.87 148.35,129.87 149.6,131.12
M_A_DQ3: length 83.6
  TOP w0.102: JDIMM2.21 135.9,81.23 135.77,81.36 135.77,83.49 v1(136.18,83.9)
  IN03 w0.13: v1(147.81,131.03) 147.81,130.47 146.88,129.54 145.26,129.54 136.62,120.91 136.62,120.01 130.06,113.44 130.06,112.34 128.44,110.72 128.44,110.44 128.57,110.31 129.02,110.31 129.15,110.18 129.15,109.92 129.02,109.79 128.57,109.79 128.44,109.66 128.44,109.4 128.57,109.27 129.02,109.27 129.15,109.14 129.15,108.89 129.02,108.76 128.57,108.76 128.44,108.63 128.44,108.37 128.57,108.24 129.02,108.24 129.15,108.11 129.15,107.85 129.02,107.72 128.57,107.72 128.44,107.59 128.44,107.33 128.57,107.2 129.02,107.2 129.15,107.07 129.15,106.81 129.02,106.68 128.57,106.68 128.44,106.55 128.44,106.29 128.57,106.17 129.02,106.17 129.15,106.04 129.15,105.78 129.02,105.65 128.57,105.65 128.44,105.52 128.44,105.26 128.57,105.13 129.02,105.13 129.15,105 129.15,104.74 129.02,104.61 128.57,104.61 128.44,104.48 128.44,104.22 128.57,104.1 129.02,104.1 129.15,103.97 129.15,103.71 129.02,103.58 128.57,103.58 128.44,103.45 128.44,96.83 129.8,95.47 129.8,93.36 129.98,93.18 130.17,93.18 131.25,94.26 131.43,94.26 131.61,94.07 131.61,93.89 130.53,92.81 130.53,92.63 132.02,91.14 132.02,90.29 132.15,90.16 132.43,90.16 132.56,90.03 132.56,89.11 132.68,88.98 132.99,88.98 133.12,88.85 133.12,88.59 135.38,86.32 135.38,83.79 135.51,83.67 136.05,83.67 136.18,83.79 v1(136.18,83.9)
  BOTTOM w0.076: 149.13,131.75 149.52,131.75 U1.BR3
  BOTTOM w0.102: JDIMM1.21 137.57,86.78 137.19,86.4 137.19,84.09 137,83.9 v1(136.18,83.9)
  BOTTOM w0.14: v1(147.81,131.03) 148.41,131.03 149.13,131.75
M_A_DQ4: length 86.6
  TOP w0.102: JDIMM2.3 131.4,80.47 131.28,80.6 131.05,80.6 130.95,80.7 130.95,81.18 130.84,81.28 130.64,81.28 130.54,81.18 130.54,80.7 130.44,80.6 129.97,80.6 129.74,80.83 129.74,81.36 130.12,81.74 130.55,81.74 130.7,81.59 131.11,81.59 131.67,82.15 v1(132.11,82.15)
  IN03 w0.13: v1(132.11,82.15) 132.51,82.15 132.87,82.51 132.87,86.25 132.34,86.77 130.04,86.77 128.06,88.75 128.06,88.93 128.25,89.12 128.25,89.3 126.1,91.45 126.1,105.46 125.9,105.66 125.9,105.98 126.1,106.18 126.1,106.5 125.9,106.69 125.9,107.02 126.1,107.21 126.1,111.58 127.73,113.21 127.73,114.05 134.03,120.35 134.03,121.16 144.72,131.85 v1(146.19,131.85)
  BOTTOM w0.076: v1(146.19,131.85) 146.19,133.22 147.63,134.66 148.92,134.66 148.99,134.72 149.59,134.72 149.72,134.58 150.6,134.58 150.95,134.23 150.95,133.77 U1.BN5
  BOTTOM w0.102: v1(132.11,82.15) 132.13,82.15 132.77,82.79 132.77,84.88 132.23,85.42 132,85.42 131.69,85.73 131.69,86.16 131.87,86.34 132.79,86.34 133.07,86.62 JDIMM1.3
M_A_DQ5: length 89.4
  TOP w0.102: v1(132.11,85.93) 132.11,86.19 132.24,86.31 132.51,86.31 132.63,86.19 132.63,84.13 132.74,84.03 132.88,84.03 132.99,84.13 132.99,84.43 133.27,84.71 133.27,84.84 133.04,85.07 133.04,85.17 133.14,85.27 133.82,85.27 133.92,85.37 133.92,85.5 133.82,85.6 133.12,85.6 133.01,85.71 133.01,85.85 133.12,85.96 133.83,85.96 133.95,86.08 133.95,86.31 133.83,86.44 132.81,86.44 132.65,86.6 JDIMM2.8
  IN03 w0.13: v1(132.11,85.93) 131.87,85.93 131.11,85.17 130.14,85.17 126.87,88.45 126.87,89.56 126.05,90.38 125.87,90.38 125.55,90.07 125.37,90.07 125.19,90.26 125.19,90.44 125.5,90.75 125.5,90.93 125.06,91.37 125.06,111.59 126.97,113.49 126.97,114.3 132.96,120.3 132.96,120.96 145.18,133.18 v1(147.59,133.18)
  BOTTOM w0.076: U1.BP6 150.47,134.3 149.74,134.3 149.54,134.1 149.19,134.1 149.05,134.25 148.31,134.25 148.12,134.06 147.8,134.06 147.59,133.86 v1(147.59,133.18)
  BOTTOM w0.102: v1(132.11,85.93) 132.46,85.93 133.26,85.13 133.26,82.5 132.47,81.72 131.83,81.72 131.6,81.49 131.6,81.11 131.9,80.81 133.81,80.81 134.32,80.3 JDIMM1.8
M_A_DQ6: length 84.1
  TOP w0.102: JDIMM2.16 134.65,86.57 134.7,86.52 134.7,83.06 v1(134.27,82.63)
  IN03 w0.076: 147.23,131.02 147.69,131.48 v1(148.26,131.48)
  IN03 w0.13: 147.23,131.02 147.07,131.02 146.38,130.33 145.18,130.33 135.81,120.96 135.81,120.21 129.26,113.66 129.26,112.6 127.68,111.03 127.68,96.52 129,95.2 129,93.2 131.26,90.94 131.26,88.62 131.66,88.23 132.53,88.23 134.72,86.04 134.72,80.98 134.59,80.85 133.33,80.85 133.2,80.98 133.2,81.36 133.33,81.49 133.72,81.49 133.85,81.61 133.85,82.05 133.72,82.17 133.33,82.17 133.2,82.3 133.2,82.74 133.33,82.86 134.14,82.86 134.27,82.74 v1(134.27,82.63)
  BOTTOM w0.076: U1.BP2 150.67,131.91 150.97,132.21 150.97,132.41 150.72,132.67 150.46,132.67 150.3,132.5 149.76,132.5 149.7,132.44 148.93,132.44 148.83,132.34 148.58,132.34 148.26,132.02 v1(148.26,131.48)
  BOTTOM w0.102: JDIMM1.16 136.32,80.72 136.19,80.85 134.72,80.85 134.49,81.07 134.49,81.38 134.69,81.58 134.69,82.22 134.28,82.63 v1(134.27,82.63)
M_A_DQ7: length 85.4
  TOP w0.102: v1(136.18,85.17) 135.47,84.46 135.47,81.16 134.9,80.59 JDIMM2.17
  IN03 w0.13: v1(136.18,85.17) 135.86,85.17 135.73,85.3 135.73,86.44 133.47,88.7 133.47,89.59 133.07,90 133.07,90.25 132.45,90.87 132.45,91.38 132.88,91.81 132.88,91.99 132.69,92.18 132.51,92.18 132.07,91.74 131.89,91.74 131.09,92.54 131.09,92.72 132.18,93.8 132.18,93.98 131.34,94.82 131.16,94.82 130.5,94.15 130.32,94.15 130.13,94.34 130.13,94.52 130.79,95.18 130.79,95.36 129.51,96.65 129.51,97.26 129.38,97.39 128.93,97.39 128.8,97.52 128.8,97.78 128.93,97.91 129.38,97.91 129.51,98.04 129.51,98.3 129.38,98.43 128.93,98.43 128.8,98.56 128.8,98.81 128.93,98.94 129.38,98.94 129.51,99.07 129.51,99.33 129.38,99.46 128.93,99.46 128.8,99.59 128.8,99.85 128.93,99.98 129.38,99.98 129.51,100.11 129.51,100.37 129.38,100.5 128.93,100.5 128.8,100.63 128.8,100.89 128.93,101.02 129.38,101.02 129.51,101.15 129.51,101.41 129.38,101.53 128.93,101.53 128.8,101.66 128.8,101.92 128.93,102.05 129.38,102.05 129.51,102.18 129.51,102.44 129.38,102.57 128.93,102.57 128.8,102.7 128.8,102.96 128.93,103.09 129.38,103.09 129.51,103.22 129.51,111.28 130.45,112.22 130.45,113.33 137,119.88 137,120.86 145.14,128.99 v1(145.65,128.99)
  BOTTOM w0.097: U1.BN3 151.25,132.1 150.97,131.83 150.97,130.68 150.68,130.38 150.34,130.38 150.21,130.25
  BOTTOM w0.102: JDIMM1.17 136.57,86.78 136.25,86.46 136.25,86.31 136.32,86.24 136.79,86.24 136.89,86.14 136.89,86 136.79,85.91 136.46,85.91 136.37,85.82 136.37,85.69 136.46,85.6 136.76,85.6 136.89,85.47 136.89,84.29 136.8,84.2 136.67,84.2 136.58,84.29 136.58,84.98 136.39,85.17 v1(136.18,85.17)
  BOTTOM w0.14: 150.21,130.25 148.56,128.6 146.04,128.6 v1(145.65,128.99)
M_A_DQ8: length 78.3
  TOP w0.102: JDIMM2.28 137.65,86.78 137.45,86.57 137.45,86.45 137.54,86.36 137.83,86.36 137.92,86.28 137.92,86.12 137.83,86.03 137.7,86.03 137.62,85.96 137.62,85.77 137.7,85.7 137.88,85.7 137.98,85.61 137.98,85.47 137.88,85.37 137.7,85.37 137.62,85.3 137.62,84.24 137.71,84.15 137.84,84.15 137.93,84.24 137.93,85.09 138.06,85.22 138.28,85.22 v1(138.34,85.17)
  IN03 w0.13: v1(138.34,85.17) 137.89,85.61 137.89,86.04 135.42,88.5 135.42,90.39 134.77,91.05 134.77,92.22 135.07,92.52 135.07,93.19 131.13,97.13 131.13,97.78 131.26,97.91 131.39,97.91 131.52,98.04 131.52,98.3 131.39,98.43 131.26,98.43 131.13,98.56 131.13,98.82 131.26,98.94 131.84,98.94 131.97,99.07 131.97,99.34 131.84,99.46 131.26,99.46 131.13,99.59 131.13,99.85 131.26,99.98 131.84,99.98 131.97,100.11 131.97,100.37 131.84,100.5 131.26,100.5 131.13,100.63 131.13,100.89 131.26,101.02 131.71,101.02 131.84,101.14 131.84,101.41 131.71,101.54 131.26,101.54 131.13,101.67 131.13,106.4 131.95,107.22 131.95,112.73 138.79,119.57 138.79,120.84 145.13,127.18 146.04,127.18 150.72,131.85 152.37,131.85 v1(152.95,132.44)
  BOTTOM w0.102: v1(138.34,85.17) 139.1,84.41 139.1,80.89 139.32,80.67 JDIMM1.28
  BOTTOM w0.14: v1(152.95,132.44) 152.63,132.77 U1.BL4
M_A_DQ9: length 77
  TOP w0.102: v1(138.34,83.9) 138.28,83.85 137.54,83.85 137.32,84.07 137.32,86.11 136.65,86.78 JDIMM2.24
  IN03 w0.13: v1(152.95,133.09) 152.17,132.31 150.67,132.31 145.89,127.54 145,127.54 138.43,120.97 138.43,119.72 131.58,112.87 131.58,111.75 130.68,110.85 130.68,108.94 130.81,108.81 131.46,108.81 131.59,108.68 131.59,108.42 131.46,108.29 130.81,108.29 130.68,108.16 130.68,107.91 130.81,107.78 131.36,107.78 131.49,107.65 131.49,107.38 131.36,107.26 130.81,107.26 130.68,107.13 130.68,97.08 134.69,93.07 134.69,92.62 134.39,92.31 134.39,90.88 135.09,90.18 135.09,88.36 137.54,85.92 137.54,84.03 137.84,83.72 138.16,83.72 v1(138.34,83.9)
  BOTTOM w0.102: v1(138.34,83.9) 138.36,83.9 138.79,83.47 138.79,81.56 138.32,81.09 JDIMM1.24
  BOTTOM w0.14: U1.BL5 152.63,133.42 v1(152.95,133.09)
M_A_DQ10: length 77.4
  TOP w0.102: v1(142.27,83.9) 142.22,83.85 141.54,83.85 141.19,84.19 141.19,84.92 140.88,85.23 140.88,85.98 140.15,86.71 JDIMM2.38
  IN03 w0.076: v1(150.5,129.34) 150.5,128.46 147.97,125.94 147.64,125.94
  IN03 w0.13: 147.64,125.94 146.96,125.25 146.81,125.25 141.3,119.74 141.3,118.66 135.4,112.77 135.4,99.52 135.53,99.39 135.88,99.39 136.01,99.26 136.01,99 135.88,98.87 135.53,98.87 135.4,98.74 135.4,98.49 135.53,98.36 135.88,98.36 136.01,98.23 136.01,97.97 135.88,97.84 135.53,97.84 135.4,97.71 135.4,97.45 135.53,97.32 135.88,97.32 136.01,97.19 136.01,96.93 135.88,96.8 135.53,96.8 135.4,96.67 135.4,96.35 138.78,92.97 138.78,91.27 138.68,91.16 138.33,91.16 138.2,91.03 138.2,90.77 138.33,90.64 138.68,90.64 138.76,90.56 138.76,88.3 141.17,85.89 141.17,85.17 141.3,85.04 141.67,85.04 141.8,84.91 141.8,84.65 141.67,84.52 141.3,84.52 141.17,84.39 141.17,84.14 141.3,84.01 141.44,84.01 141.57,83.88 141.57,83.62 141.44,83.49 141.3,83.49 141.17,83.36 141.17,82.21 141.38,81.99 141.6,81.99 141.83,82.23 141.83,83.57 142.16,83.9 v1(142.27,83.9)
  BOTTOM w0.076: U1.BL2 152.51,130.72 151.13,129.34 v1(150.5,129.34)
  BOTTOM w0.102: v1(142.27,83.9) 142.69,83.48 142.69,81.78 141.82,80.91 JDIMM1.38
M_A_DQ11: length 78.2
  TOP w0.102: v1(142.27,85.17) 142.06,85.17 141.85,84.97 141.85,84.45 141.76,84.36 141.62,84.36 141.52,84.45 141.52,85.22 141.62,85.32 141.73,85.32 141.83,85.42 141.83,85.6 141.75,85.68 141.29,85.68 141.22,85.75 141.22,85.96 141.32,86.06 141.66,86.06 141.78,86.18 141.78,86.35 141.66,86.47 141.25,86.47 141.15,86.57 JDIMM2.42
  IN03 w0.076: v1(151.4,130.23) 151.4,129.03 148.03,125.66 147.77,125.66
  IN03 w0.13: v1(142.27,85.17) 142.01,85.17 141.83,85.36 141.83,85.7 139.12,88.42 139.12,93.15 136.39,95.87 136.39,99.75 136.26,99.88 135.94,99.88 135.81,100.01 135.81,100.27 135.94,100.4 136.26,100.4 136.39,100.53 136.39,100.79 136.26,100.92 135.94,100.92 135.81,101.05 135.81,101.3 135.94,101.43 136.26,101.43 136.39,101.56 136.39,101.82 136.26,101.95 135.94,101.95 135.81,102.08 135.81,102.34 135.94,102.47 136.26,102.47 136.39,102.6 136.39,102.86 136.26,102.99 135.89,102.99 135.76,103.12 135.76,103.37 135.89,103.5 136.26,103.5 136.39,103.63 136.39,103.89 136.26,104.02 135.89,104.02 135.76,104.15 135.76,104.41 135.89,104.54 136.26,104.54 136.39,104.67 136.39,104.93 136.26,105.06 135.89,105.06 135.76,105.19 135.76,105.45 135.89,105.58 136.26,105.58 136.39,105.71 136.39,105.97 136.26,106.1 135.89,106.1 135.76,106.22 135.76,106.48 135.89,106.61 136.26,106.61 136.39,106.74 136.39,107 136.26,107.13 135.89,107.13 135.76,107.26 135.76,107.52 135.89,107.65 136.26,107.65 136.39,107.78 136.39,108.04 136.26,108.17 135.89,108.17 135.76,108.3 135.76,108.56 135.89,108.69 136.26,108.69 136.39,108.82 136.39,109.07 136.26,109.2 135.89,109.2 135.76,109.33 135.76,109.59 135.89,109.72 136.26,109.72 136.39,109.85 136.39,110.11 136.26,110.24 135.89,110.24 135.76,110.37 135.76,110.63 135.89,110.76 136.26,110.76 136.39,110.89 136.39,111.08 136.26,111.21 136.09,111.21 135.96,111.34 135.96,111.59 136.09,111.72 136.26,111.72 136.39,111.85 136.39,113.25 141.66,118.51 141.66,119.54 147.77,125.66
  BOTTOM w0.102: JDIMM1.42 142.82,81.27 143,81.45 143,83.61 142.68,83.92 142.68,84.7 142.27,85.11 v1(142.27,85.17)
  BOTTOM w0.14: v1(151.4,130.23) 151.98,130.82 U1.BM1
M_A_DQ12: length 77.7
  TOP w0.102: JDIMM2.29 137.9,81.32 138.12,81.54 138.55,81.54 138.82,81.8 138.82,82.39 139.31,82.88 139.96,82.88 140.22,82.63 v1(140.37,82.63)
  IN03 w0.13: v1(140.37,82.63) 139.94,82.2 139.06,82.2 138.76,82.5 138.76,85.98 138.51,86.23 138.17,86.23 135.76,88.64 135.76,90.53 135.2,91.09 135.2,92.18 135.43,92.41 135.43,93.34 132.33,96.44 132.33,101.43 131.52,102.24 131.52,106.25 132.33,107.06 132.33,112.6 139.11,119.38 139.11,120.65 145.31,126.85 146.25,126.85 150.21,130.81 152.14,130.81 152.45,131.12 152.45,131.13 153.56,132.24 v1(153.76,132.44)
  BOTTOM w0.102: JDIMM1.29 139.57,83.05 139.99,82.63 v1(140.37,82.63)
  BOTTOM w0.14: U1.BK4 v1(153.76,132.44)
M_A_DQ13: length 77.3
  TOP w0.102: JDIMM2.25 136.9,80.55 137.03,80.67 137.46,80.67 137.59,80.8 137.59,81.08 137.46,81.21 137.11,81.21 136.98,81.33 136.98,81.61 137.11,81.74 137.43,81.74 137.56,81.87 137.56,82.48 137.71,82.63 v1(138.34,82.63)
  IN03 w0.13: v1(153.74,133.09) 153.25,133.58 151.48,133.58 147.06,129.16 146.53,129.16 145.41,128.04 145.05,128.04 138.07,121.07 138.07,119.87 131.22,113.02 131.22,111.9 130.3,110.98 130.3,96.96 133.85,93.4 133.85,90.78 134.69,89.94 134.69,88.29 137,85.98 137,83.95 138.32,82.63 v1(138.34,82.63)
  BOTTOM w0.102: JDIMM1.25 138.57,86.61 137.93,85.97 137.93,83.04 v1(138.34,82.63)
  BOTTOM w0.14: U1.BK5 v1(153.74,133.09)
M_A_DQ14: length 78
  TOP w0.102: v1(142.27,82.63) 141.88,82.63 141.65,82.86 141.65,83.11 141.57,83.19 141.37,83.19 141.22,83.04 141.22,81.61 140.66,81.05 140.66,80.65 140.89,80.42 140.9,80.42 JDIMM2.41
  IN03 w0.076: 147.49,126.24 147.96,126.24 150.05,128.33 v1(150.05,128.89)
  IN03 w0.13: 147.49,126.24 146.86,125.61 146.68,125.61 140.94,119.87 140.94,118.81 135.02,112.89 135.02,96.23 137.87,93.38 137.87,92.37 138,92.24 138.32,92.24 138.45,92.11 138.45,91.85 138.32,91.72 138,91.72 137.87,91.59 137.87,88.72 140.81,85.78 140.81,81.08 140.94,80.95 141.5,80.95 141.62,81.08 141.62,81.33 141.75,81.46 142.08,81.46 142.2,81.33 142.2,80.85 142.33,80.72 142.69,80.72 143.07,81.11 143.07,82.43 142.87,82.63 v1(142.27,82.63)
  BOTTOM w0.076: U1.BK1 152.91,130.79 151.01,128.89 v1(150.05,128.89)
  BOTTOM w0.102: JDIMM1.41 142.57,86.67 142.16,86.26 142.01,86.26 141.87,86.12 141.87,83.04 v1(142.27,82.63)
M_A_DQ15: length 80.6
  TOP w0.102: JDIMM2.37 139.9,80.5 139.8,80.6 139.42,80.6 139.31,80.7 139.31,80.91 139.42,81.01 139.8,81.01 139.9,81.11 139.9,81.34 140.1,81.54 140.66,81.54 140.88,81.75 140.88,84.78 140.48,85.17 v1(140.37,85.17)
  IN03 w0.13: v1(140.37,85.17) 140.37,85.75 137.51,88.61 137.51,93.23 134.66,96.08 134.66,96.43 134.53,96.56 134.43,96.56 134.3,96.69 134.3,96.95 134.43,97.08 134.53,97.08 134.66,97.21 134.66,97.47 134.53,97.6 134.43,97.6 134.3,97.73 134.3,97.99 134.43,98.12 134.53,98.12 134.66,98.25 134.66,98.5 134.53,98.63 134.43,98.63 134.3,98.76 134.3,99.02 134.43,99.15 134.53,99.15 134.66,99.28 134.66,99.54 134.53,99.67 134.43,99.67 134.3,99.8 134.3,100.06 134.43,100.19 134.53,100.19 134.66,100.32 134.66,100.58 134.53,100.71 134.43,100.71 134.3,100.84 134.3,101.1 134.43,101.23 134.53,101.23 134.66,101.35 134.66,101.61 134.53,101.74 134.43,101.74 134.3,101.87 134.3,102.13 134.43,102.26 134.53,102.26 134.66,102.39 134.66,102.65 134.53,102.78 134.43,102.78 134.3,102.91 134.3,103.17 134.43,103.3 134.53,103.3 134.66,103.43 134.66,103.69 134.53,103.82 134.43,103.82 134.3,103.95 134.3,104.2 134.43,104.33 134.53,104.33 134.66,104.46 134.66,104.72 134.53,104.85 134.43,104.85 134.3,104.98 134.3,105.24 134.43,105.37 134.53,105.37 134.66,105.5 134.66,105.76 134.53,105.89 134.43,105.89 134.3,106.02 134.3,106.28 134.43,106.41 134.53,106.41 134.66,106.54 134.66,106.8 134.53,106.92 134.43,106.92 134.3,107.05 134.3,107.31 134.43,107.44 134.53,107.44 134.66,107.57 134.66,107.83 134.53,107.96 134.43,107.96 134.3,108.09 134.3,108.35 134.43,108.48 134.53,108.48 134.66,108.61 134.66,108.87 134.53,109 134.43,109 134.3,109.13 134.3,109.39 134.43,109.52 134.53,109.52 134.66,109.65 134.66,109.9 134.53,110.03 134.43,110.03 134.3,110.16 134.3,110.42 134.43,110.55 134.53,110.55 134.66,110.68 134.66,110.94 134.53,111.07 134.43,111.07 134.3,111.2 134.3,111.46 134.43,111.59 134.53,111.59 134.66,111.72 134.66,111.98 134.53,112.11 134.43,112.11 134.3,112.24 134.3,112.5 134.43,112.62 134.53,112.62 134.66,112.75 134.66,113.04 140.58,118.96 140.58,119.99 146.48,125.89 146.65,125.89 147.41,126.64 v1(147.8,126.64)
  BOTTOM w0.076: 153.63,130.22 153.63,131.18 U1.BK2
  BOTTOM w0.102: v1(140.37,85.17) 140,85.17 139.87,85.3 139.87,85.48 140,85.6 141.02,85.6 141.24,85.37 141.4,85.37 141.52,85.5 141.52,85.93 141.4,86.06 139.98,86.06 139.87,86.16 139.87,86.43 139.97,86.52 141.47,86.52 141.57,86.62 JDIMM1.37
  BOTTOM w0.14: v1(147.8,126.64) 150.05,126.64 150.41,127 153.63,130.22
M_A_DQ16: length 74.2
  TOP w0.102: JDIMM2.50 143.15,86.49 143,86.34 143,86.03 143.1,85.93 143.66,85.93 143.76,85.82 143.76,85.62 143.66,85.52 143.1,85.52 143,85.42 143,84.48 143.33,84.15 143.8,84.15 v1(144.18,84.53)
  IN03 w0.076: v1(153.48,129.18) 152.34,129.18 148.25,125.1
  IN03 w0.13: 148.25,125.1 142.73,119.57 142.73,117.97 137.56,112.8 137.56,96.13 139.95,93.75 139.95,88.77 141.59,87.13 142.07,87.13 143.07,86.12 143.07,85.24 143.2,85.11 143.55,85.11 143.68,84.98 143.68,84.73 143.55,84.6 143.2,84.6 143.07,84.47 143.07,84.13 143.3,83.9 143.58,83.9 144.18,84.5 v1(144.18,84.53)
  BOTTOM w0.076: 154.26,129.18 154.98,129.91 154.98,130.26 154.63,130.61 154.63,131.24 154.78,131.39 154.78,132.68 154.87,132.77 U1.BG4
  BOTTOM w0.102: JDIMM1.50 144.82,80.39 145.23,80.8 145.23,82.68 144.6,83.32 144.6,84.36 144.42,84.53 v1(144.18,84.53)
  BOTTOM w0.14: v1(153.48,129.18) 154.26,129.18
M_A_DQ17: length 74.3
  TOP w0.102: v1(144.18,83.26) 143.25,83.26 142.69,83.82 142.69,86.24 142.15,86.78 JDIMM2.46
  IN03 w0.076: 147.9,125.33 148.19,125.33 152.5,129.63 v1(153.93,129.63)
  IN03 w0.13: 147.9,125.33 142.37,119.8 142.37,118.12 137.18,112.93 137.18,96.01 139.61,93.58 139.61,88.63 141.47,86.77 141.96,86.77 142.72,86.01 142.72,83.7 143.15,83.26 v1(144.18,83.26)
  BOTTOM w0.076: U1.BG5 154.48,132.82 154.48,130.54 154.77,130.25 154.77,129.94 154.47,129.63 v1(153.93,129.63)
  BOTTOM w0.102: JDIMM1.46 143.82,80.91 143.94,81.04 144.83,81.04 144.93,81.14 144.93,81.34 144.83,81.44 144.69,81.44 144.58,81.54 144.58,81.75 144.69,81.85 144.83,81.85 144.93,81.95 144.93,82.15 144.83,82.26 144.69,82.26 144.58,82.36 144.58,82.86 v1(144.18,83.26)
M_A_DQ18: length 74.4
  TOP w0.102: v1(146.21,82.38) 146.21,82.5 146.34,82.62 147.03,82.62 147.16,82.5 147.16,81.46 147.03,81.33 146.16,81.33 146.04,81.22 146.04,81.05 146.16,80.93 146.32,80.93 146.44,80.81 146.44,80.64 146.32,80.52 145.75,80.52 145.4,80.17 JDIMM2.59
  IN03 w0.13: v1(156.26,132.44) 155.16,131.35 155.16,129.92 152.12,126.88 152.12,125.5 145.39,118.78 145.39,117.22 140.79,112.61 140.79,102.06 141.37,101.48 141.37,95.73 143.38,93.72 143.38,88.7 143.89,88.19 144.47,88.19 146.66,86 146.66,82.44 147.12,81.97 147.12,81.82 147.01,81.72 146.87,81.72 v1(146.21,82.38)
  BOTTOM w0.102: v1(146.21,82.38) 146.65,82.38 147.66,83.38 147.66,86.19 147.07,86.78 JDIMM1.59
  BOTTOM w0.14: v1(156.26,132.44) 155.93,132.77 U1.BF4
M_A_DQ19: length 75.4
  TOP w0.102: v1(146.21,85.55) 146.27,85.61 146.27,85.98 146.02,86.24 145.77,86.24 145.49,85.96 145.49,85.3 145.64,85.14 145.64,84.46 145.51,84.33 145.21,84.33 145.05,84.48 145.05,86.27 145.15,86.36 JDIMM2.58
  IN03 w0.13: v1(156.26,133.09) 154.81,131.64 154.81,129.95 151.61,126.75 151.61,125.4 145.03,118.83 145.03,117.37 140.41,112.74 140.41,101.37 140.54,101.24 140.86,101.24 140.99,101.12 140.99,100.85 140.86,100.72 140.54,100.72 140.41,100.6 140.41,100.34 140.54,100.21 140.86,100.21 140.99,100.08 140.99,99.82 140.86,99.69 140.54,99.69 140.41,99.56 140.41,99.3 140.54,99.17 140.86,99.17 140.99,99.04 140.99,98.78 140.86,98.65 140.54,98.65 140.41,98.52 140.41,98.26 140.54,98.13 140.86,98.13 140.99,98.01 140.99,97.74 140.86,97.62 140.54,97.62 140.41,97.49 140.41,97.23 140.54,97.1 140.81,97.1 140.94,96.97 140.94,96.71 140.81,96.58 140.54,96.58 140.41,96.45 140.41,96.19 143.02,93.57 143.02,88.57 143.76,87.84 144.35,87.84 146.21,85.98 v1(146.21,85.55)
  BOTTOM w0.102: v1(146.21,85.55) 146.17,85.55 145.7,85.08 145.7,81.63 146.82,80.51 JDIMM1.58
  BOTTOM w0.14: U1.BF5 155.93,133.42 v1(156.26,133.09)
M_A_DQ20: length 77
  TOP w0.102: JDIMM2.49 142.9,80.85 143.63,81.57 144.33,81.57 144.58,81.83 144.58,85.68 144.46,85.8 v1(144.18,85.8)
  IN03 w0.076: v1(152.58,128.29) 151.73,128.29 149.47,126.03 149.47,125.84
  IN03 w0.13: 149.47,125.84 143.09,119.45 143.09,117.82 138.15,112.88 138.15,112.04 137.92,111.82 137.92,111.53 138.15,111.3 138.15,111.01 137.92,110.78 137.92,110.49 138.15,110.26 138.15,109.97 137.92,109.74 137.92,109.45 138.15,109.23 138.15,108.93 137.92,108.71 137.92,108.42 138.15,108.19 138.15,107.9 137.92,107.67 137.92,107.38 138.15,107.15 138.15,106.86 137.92,106.64 137.92,106.34 138.15,106.12 138.15,105.83 137.92,105.6 137.92,105.31 138.15,105.08 138.15,104.79 137.92,104.56 137.92,104.27 138.15,104.05 138.15,103.75 137.92,103.53 137.92,103.27 138.17,103.02 138.17,102.75 137.92,102.5 137.92,102.25 138.17,102 138.17,101.73 137.92,101.48 137.92,101.22 138.17,100.97 138.17,100.7 137.92,100.46 137.92,96.28 140.79,93.41 140.79,92.5 140.66,92.37 140.41,92.37 140.28,92.24 140.28,91.85 140.41,91.72 140.63,91.72 140.76,91.59 140.76,91.33 140.63,91.2 140.41,91.2 140.28,91.08 140.28,90.81 140.41,90.69 140.68,90.69 140.79,90.58 140.79,88.39 141.72,87.46 142.21,87.46 143.43,86.24 143.43,85.78 143.63,85.58 143.95,85.58 v1(144.18,85.8)
  BOTTOM w0.076: U1.BG2 155.07,131.21 154.78,130.92 154.78,130.68 155.19,130.27 155.19,129.83 154.21,128.85 153.74,128.85
  BOTTOM w0.102: v1(144.18,85.8) 144.36,85.98 144.5,85.98 144.62,85.86 144.62,84.89 144.9,84.61 144.9,83.59 145.03,83.47 145.28,83.47 145.38,83.57 145.38,84.59 145.11,84.86 145.11,85.82 144.57,86.37 JDIMM1.49
  BOTTOM w0.14: v1(152.58,128.29) 153.17,128.29 153.74,128.85
M_A_DQ21: length 74
  TOP w0.102: v1(144.18,82.63) 143.67,82.63 143.36,82.93 143.02,82.93 142.84,82.75 142.84,81.89 142.39,81.44 142.08,81.44 141.9,81.26 JDIMM2.45
  IN03 w0.076: v1(152.13,127.84) 151.57,127.84 149.85,126.12 149.85,125.76
  IN03 w0.13: v1(144.18,82.63) 143.94,82.63 143.61,82.3 143.61,81.69 143.91,81.39 144.42,81.39 144.65,81.61 144.65,85.93 144.35,86.23 143.91,86.23 142.35,87.79 141.86,87.79 141.12,88.53 141.12,93.59 138.53,96.18 138.53,112.75 143.45,117.67 143.45,119.35 149.85,125.76
  BOTTOM w0.076: U1.BG1 155.07,130.6 155.39,130.29 155.39,129.78 154.18,128.56 153.85,128.56
  BOTTOM w0.102: JDIMM1.45 143.57,86.75 143.23,86.41 143.23,85.27 143.77,84.72 143.77,83.04 v1(144.18,82.63)
  BOTTOM w0.14: v1(152.13,127.84) 153.13,127.84 153.85,128.56
M_A_DQ22: length 74
  TOP w0.102: v1(148.37,83.65) 147.16,83.65 146.62,84.19 146.62,86.07 146.15,86.53 JDIMM2.62
  IN03 w0.13: v1(156.26,130.49) 155.8,130.03 155.8,129.72 153,126.93 153,125.58 146.11,118.69 146.11,116.92 142.13,112.94 142.13,108.48 142,108.35 141.68,108.35 141.55,108.22 141.55,107.96 141.68,107.83 142,107.83 142.13,107.7 142.13,107.44 142,107.31 141.68,107.31 141.55,107.18 141.55,106.92 141.68,106.79 142,106.79 142.13,106.66 142.13,106.4 142,106.27 141.68,106.27 141.55,106.14 141.55,105.88 141.68,105.75 142,105.75 142.13,105.63 142.13,105.37 142,105.24 141.68,105.24 141.55,105.11 141.55,104.85 141.68,104.72 142,104.72 142.13,104.59 142.13,104.33 142,104.2 141.68,104.2 141.55,104.07 141.55,103.81 141.68,103.68 142,103.68 142.13,103.55 142.13,103.3 142,103.17 141.73,103.17 141.6,103.04 141.6,102.78 141.73,102.65 142,102.65 142.13,102.52 142.13,95.98 144.6,93.52 144.6,92.38 144.44,92.23 144.2,92.23 144.07,92.1 144.07,91.84 144.2,91.71 144.47,91.71 144.6,91.58 144.6,91.32 144.47,91.19 144.2,91.19 144.07,91.06 144.07,90.8 144.2,90.67 144.47,90.67 144.6,90.54 144.6,89 147.32,86.28 147.32,84 147.67,83.65 v1(148.37,83.65)
  BOTTOM w0.076: U1.BF1 155.93,130.82 v1(156.26,130.49)
  BOTTOM w0.102: JDIMM1.62 147.82,80.86 147.47,81.21 147.47,81.61 147.74,81.89 148.46,81.89 148.77,82.21 148.77,83.24 v1(148.37,83.65)
M_A_DQ23: length 73.5
  TOP w0.102: v1(148.37,82.38) 148.13,82.38 147.97,82.53 147.97,82.91 147.85,83.04 147.59,83.04 147.47,82.91 147.47,81.23 146.4,80.17 JDIMM2.63
  IN03 w0.13: v1(148.37,82.38) 147.19,82.38 147.06,82.5 147.06,82.68 147.19,82.81 147.67,82.81 147.8,82.93 147.8,83.11 147.67,83.24 147.39,83.24 146.99,83.64 146.99,86.14 144.58,88.55 144.01,88.55 143.73,88.83 143.73,93.88 141.75,95.86 141.75,101.88 141.17,102.47 141.17,108.71 141.3,108.84 141.55,108.84 141.68,108.96 141.68,109.23 141.55,109.36 141.3,109.36 141.17,109.48 141.17,109.74 141.3,109.87 141.52,109.87 141.65,110 141.65,110.26 141.52,110.39 141.3,110.39 141.17,110.52 141.17,110.78 141.3,110.91 141.52,110.91 141.65,111.04 141.65,111.3 141.52,111.43 141.3,111.43 141.17,111.56 141.17,112.49 145.75,117.07 145.75,118.73 152.62,125.61 152.62,126.98 155.49,129.85 155.49,130.38 v1(156.26,131.14)
  BOTTOM w0.076: U1.BF2 155.93,131.47 v1(156.26,131.14)
  BOTTOM w0.102: v1(148.37,82.38) 147.96,82.78 147.96,86.16 148.07,86.27 JDIMM1.63
M_A_DQ24: length 74.5
  TOP w0.102: v1(148.37,84.92) 148.37,85.04 148.24,85.16 147.99,85.16 147.86,85.04 147.86,84.53 147.73,84.41 147.48,84.41 147.35,84.53 147.35,85.69 147.47,85.8 148.05,85.8 148.17,85.93 148.17,86.15 148.05,86.27 147.48,86.27 147.15,86.6 JDIMM2.66
  IN03 w0.13: v1(154.91,127.87) 154.35,127.87 153.61,127.14 153.61,125.56 146.87,118.81 146.87,116.6 142.92,112.65 142.92,100.43 143.05,100.3 143.53,100.3 143.65,100.17 143.65,99.91 143.53,99.78 143.05,99.78 142.92,99.65 142.92,99.39 143.05,99.26 143.53,99.26 143.65,99.13 143.65,98.87 143.53,98.74 143.05,98.74 142.92,98.61 142.92,98.35 143.05,98.23 143.53,98.23 143.65,98.1 143.65,97.83 143.53,97.71 143.05,97.71 142.92,97.58 142.92,97.32 143.05,97.19 143.53,97.19 143.65,97.06 143.65,96.8 143.53,96.67 143.05,96.67 142.92,96.54 142.92,96.22 145.46,93.68 145.46,92.48 145.84,92.1 145.84,90.34 145.43,89.93 145.43,88.69 145.9,88.23 146.06,88.23 148.28,86.01 148.6,86.01 148.84,85.77 148.84,85.12 148.64,84.92 v1(148.37,84.92)
  BOTTOM w0.076: v1(154.91,127.87) 155.49,127.87 156.13,128.51 156.72,128.51 157.37,129.16 157.37,130.41 157.3,130.49 157.3,130.94 157.59,131.23 U1.BD2
  BOTTOM w0.102: v1(148.37,84.92) 149.56,83.72 149.56,82.21 149.17,81.82 149.17,80.5 148.82,80.15 JDIMM1.66
M_A_DQ25: length 74.7
  TOP w0.102: JDIMM2.70 148.15,86.6 148.77,85.98 148.77,83.07 149.47,82.38 v1(150.27,82.38)
  IN03 w0.13: v1(150.27,82.38) 150.78,81.87 150.78,81.65 150.44,81.31 150.11,81.31 149.26,82.16 149.26,85.82 148.71,86.36 148.39,86.36 146.2,88.56 146.04,88.56 145.77,88.83 145.77,89.79 146.17,90.2 146.17,92.23 145.79,92.62 145.79,93.86 144.01,95.63 144.01,100.36 143.3,101.07 143.3,112.53 147.23,116.45 147.23,118.74 154.46,125.97 v1(154.46,127.42)
  BOTTOM w0.076: v1(154.46,127.42) 155.57,127.42 156.44,128.29 157.01,128.29 157.59,128.87 U1.BD1
  BOTTOM w0.102: JDIMM1.70 149.82,80.25 149.69,80.37 149.6,80.37 149.47,80.5 149.47,81.69 149.58,81.8 149.74,81.8 149.85,81.69 149.85,80.77 149.97,80.65 150.14,80.65 150.26,80.77 150.26,81.26 150.34,81.33 150.44,81.33 150.68,81.57 150.68,82.16 150.46,82.38 v1(150.27,82.38)
M_A_DQ26: length 73.1
  TOP w0.102: JDIMM2.80 150.65,86.78 151.16,86.27 151.16,84.01 152.17,83.01 v1(152.18,83.01)
  IN03 w0.13: v1(152.18,83.01) 151.91,83.01 151.76,83.16 151.76,86.11 149.83,88.04 149.83,89.13 149.7,89.26 149.3,89.26 149.17,89.39 149.17,89.65 149.3,89.78 149.7,89.78 149.83,89.91 149.83,92.54 149.58,92.79 149.58,93.04 149.83,93.3 149.83,93.53 149.63,93.72 149.45,93.72 149.09,93.36 148.9,93.36 148.72,93.54 148.72,93.73 149.08,94.09 149.08,94.27 147.49,95.86 147.49,96.33 147.36,96.45 147.17,96.45 147.04,96.58 147.04,96.84 147.17,96.97 147.36,96.97 147.49,97.1 147.49,97.36 147.36,97.49 147.17,97.49 147.04,97.62 147.04,97.88 147.17,98.01 147.36,98.01 147.49,98.14 147.49,98.4 147.36,98.53 147.17,98.53 147.04,98.66 147.04,98.92 147.17,99.05 147.36,99.05 147.49,99.18 147.49,99.43 147.36,99.56 147.17,99.56 147.04,99.69 147.04,99.95 147.17,100.08 147.36,100.08 147.49,100.21 147.49,100.53 147.36,100.66 147.19,100.66 147.06,100.79 147.06,101.04 147.19,101.17 147.36,101.17 147.49,101.3 147.49,103.51 147.42,103.58 147.29,103.58 147.16,103.71 147.16,103.89 147.34,104.07 147.34,104.3 147.16,104.47 147.16,113.16 149.89,115.89 149.89,118.28 157.58,125.96 157.58,131.24 v1(158.77,132.44)
  BOTTOM w0.102: v1(152.18,83.01) 152.29,83.01 152.78,82.53 152.78,81.72 152.22,81.16 151.78,81.16 151.68,81.06 151.68,80.85 151.78,80.75 152.22,80.75 152.32,80.65 JDIMM1.80
  BOTTOM w0.14: v1(158.77,132.44) 158.45,132.77 U1.BC4
M_A_DQ27: length 74
  TOP w0.102: v1(152.18,81.74) 151.96,81.74 151.76,81.94 151.76,82.91 151.58,83.09 151.2,83.09 151.02,82.91 151.02,81.05 150.4,80.43 JDIMM2.79
  IN03 w0.13: v1(158.77,133.09) 158.77,133.08 157.09,131.4 157.09,125.96 149.53,118.4 149.53,116.04 146.68,113.19 146.68,103.34 146.81,103.21 146.98,103.21 147.11,103.08 147.11,102.82 146.98,102.69 146.81,102.69 146.68,102.56 146.68,102.3 146.81,102.17 146.98,102.17 147.11,102.04 147.11,101.78 146.98,101.65 146.81,101.65 146.68,101.52 146.68,96.17 148.39,94.46 148.39,93.37 149.37,92.38 149.37,90.53 148.81,89.97 148.81,88.83 148.94,88.7 149.22,88.7 149.35,88.57 149.35,88.05 151.43,85.98 151.43,81.61 151.55,81.49 152.05,81.49 152.18,81.61 v1(152.18,81.74)
  BOTTOM w0.102: JDIMM1.79 152.07,86.04 151.77,85.74 151.77,82.15 v1(152.18,81.74)
  BOTTOM w0.14: v1(158.77,133.09) 158.45,133.42 U1.BC5
M_A_DQ28: length 76.2
  TOP w0.102: JDIMM2.71 148.4,80.17 148.78,80.55 149.93,80.55 150.7,81.32 150.7,85.32 150.46,85.55 v1(150.27,85.55)
  IN03 w0.13: v1(150.27,85.55) 150.27,85.74 148.99,87.03 148.67,87.03 146.96,88.74 146.96,93.75 144.77,95.94 144.77,102.54 144.5,102.82 144.17,102.82 144.04,102.95 144.04,103.46 144.17,103.58 144.37,103.58 144.5,103.71 144.5,104.23 144.37,104.36 144.25,104.36 144.06,104.55 144.06,108.64 144.77,109.35 144.77,109.58 144.64,109.71 144.29,109.71 144.16,109.84 144.16,110.1 144.29,110.23 144.64,110.23 144.77,110.36 144.77,110.62 144.64,110.75 144.29,110.75 144.16,110.88 144.16,111.14 144.29,111.27 144.64,111.27 144.77,111.4 144.77,111.65 144.64,111.78 144.29,111.78 144.16,111.91 144.16,112.17 144.29,112.3 144.64,112.3 144.77,112.43 144.77,112.98 147.95,116.16 147.95,118.67 155.21,125.93 155.21,127.06 156.56,128.41 156.56,128.92 v1(156.26,129.22)
  BOTTOM w0.076: U1.BD5 157.07,132.9 157.07,131.55 156.99,131.47 156.99,129.95 v1(156.26,129.22)
  BOTTOM w0.102: v1(150.27,85.55) 150.29,85.55 150.97,84.86 150.97,84.51 151.1,84.38 151.3,84.38 151.43,84.51 151.43,85.86 151.68,86.11 151.68,86.34 151.53,86.49 150.87,86.49 150.44,86.06 149.64,86.06 149.51,86.19 149.51,86.36 149.64,86.49 149.94,86.49 150.07,86.62 JDIMM1.71
M_A_DQ29: length 74.3
  TOP w0.102: v1(150.27,81.74) 150.27,81.32 150.15,81.19 149.52,81.19 149.4,81.32 149.4,82.02 149.19,82.22 148.9,82.22 148.77,82.1 148.77,81.25 148.52,80.99 148.19,80.99 147.4,80.2 JDIMM2.67
  IN03 w0.13: v1(155.81,128.77) 155.81,128.14 154.86,127.19 154.86,125.96 147.59,118.69 147.59,116.31 143.68,112.4 143.68,102.51 143.81,102.38 144.29,102.38 144.42,102.26 144.42,101.99 144.29,101.86 143.81,101.86 143.68,101.73 143.68,101.3 143.81,101.17 144.27,101.17 144.39,101.04 144.39,95.79 146.63,93.55 146.63,88.6 148.53,86.7 148.85,86.7 149.64,85.91 149.64,82.25 150.15,81.74 v1(150.27,81.74)
  BOTTOM w0.076: v1(155.81,128.77) 156.47,128.77 157.14,129.44 157.14,131.11 157.3,131.26 157.3,132.47 U1.BD4
  BOTTOM w0.102: v1(150.27,81.74) 150.26,81.74 149.87,82.13 149.87,84.89 149.07,85.69 JDIMM1.67
M_A_DQ30: length 75.2
  TOP w0.102: JDIMM2.83 151.4,80.34 152.69,81.63 152.69,85.04 v1(152.18,85.55)
  IN03 w0.13: v1(158.77,130.49) 158.06,129.78 158.06,125.94 150.25,118.13 150.25,115.74 147.64,113.14 147.64,104.53 147.87,104.3 148.18,104.3 148.31,104.17 148.31,103.84 148.18,103.71 148.06,103.71 147.87,103.52 147.87,103.26 148,103.13 148.3,103.13 148.43,103 148.43,102.74 148.3,102.61 148,102.61 147.87,102.48 147.87,102.23 148,102.1 148.3,102.1 148.43,101.97 148.43,101.71 148.3,101.58 148,101.58 147.87,101.45 147.87,101.19 148,101.06 148.3,101.06 148.43,100.93 148.43,100.67 148.3,100.54 148,100.54 147.87,100.41 147.87,100.15 148,100.02 148.3,100.02 148.43,99.89 148.43,99.63 148.3,99.51 148,99.51 147.87,99.38 147.87,99.12 148,98.99 148.3,98.99 148.43,98.86 148.43,98.6 148.3,98.47 148,98.47 147.87,98.34 147.87,98.08 148,97.95 148.3,97.95 148.43,97.82 148.43,97.56 148.3,97.43 148,97.43 147.87,97.3 147.87,97.06 148,96.93 148.28,96.93 148.41,96.8 148.41,96.6 148.28,96.47 148,96.47 147.87,96.35 147.87,95.99 150.79,93.07 150.79,92.5 150.67,92.37 150.29,92.37 150.16,92.24 150.16,92.03 150.29,91.9 150.67,91.9 150.79,91.77 150.79,91.57 150.67,91.44 150.29,91.44 150.16,91.32 150.16,91.11 150.29,90.99 150.67,90.99 150.79,90.86 150.79,90.63 150.67,90.5 150.29,90.5 150.17,90.38 150.17,90.16 150.29,90.03 150.57,90.03 150.69,89.91 150.69,88.81 150.34,88.45 150.34,88.01 152.18,86.16 v1(152.18,85.55)
  BOTTOM w0.102: v1(152.18,85.55) 152.18,85.53 152.74,84.97 153.74,84.97 153.87,85.09 153.87,85.27 153.74,85.4 152.95,85.4 152.83,85.52 152.83,85.7 152.95,85.83 153.74,85.83 153.87,85.96 153.87,86.16 153.74,86.29 153.2,86.29 153.08,86.41 153.08,87.57 JDIMM1.83
  BOTTOM w0.14: U1.BC1 158.45,130.82 v1(158.77,130.49)
M_A_DQ31: length 73.2
  TOP w0.102: v1(152.18,84.28) 152.09,84.28 151.65,84.72 151.65,85.83 151.8,85.98 152.62,85.98 152.72,86.08 152.72,86.21 152.6,86.34 151.86,86.34 151.66,86.54 151.65,86.54 JDIMM2.84
  IN03 w0.13: v1(158.77,131.14) 159.27,130.65 159.27,129.78 158.62,129.14 158.62,125.99 150.61,117.98 150.61,115.59 148.79,113.77 148.79,112.8 148.66,112.67 148.23,112.67 148.1,112.54 148.1,112.28 148.23,112.15 148.66,112.15 148.79,112.02 148.79,111.76 148.66,111.63 148.23,111.63 148.1,111.51 148.1,111.24 148.23,111.12 148.66,111.12 148.79,110.99 148.79,110.73 148.66,110.6 148.23,110.6 148.1,110.47 148.1,110.21 148.23,110.08 148.66,110.08 148.79,109.95 148.79,109.69 148.66,109.56 148.23,109.56 148.1,109.43 148.1,109.17 148.23,109.04 148.66,109.04 148.79,108.91 148.79,108.65 148.66,108.52 148.23,108.52 148.1,108.4 148.1,108.13 148.23,108.01 148.66,108.01 148.79,107.88 148.79,107.62 148.66,107.49 148.23,107.49 148.1,107.36 148.1,107.1 148.23,106.97 148.66,106.97 148.79,106.84 148.79,106.58 148.66,106.45 148.23,106.45 148.1,106.32 148.1,106.06 148.23,105.93 148.66,105.93 148.79,105.8 148.79,105.54 148.66,105.42 148.23,105.42 148.1,105.29 148.1,105.02 148.23,104.9 148.66,104.9 148.79,104.77 148.79,95.58 151.13,93.24 151.13,87.69 152.6,86.21 152.6,84.41 152.47,84.28 v1(152.18,84.28)
  BOTTOM w0.102: v1(152.18,84.28) 153.13,83.33 153.13,80.66 153.32,80.47 JDIMM1.84
  BOTTOM w0.14: v1(158.77,131.14) 158.45,131.47 U1.BC2
M_A_DQ32: length 72.1
  TOP w0.102: v1(179.74,82.12) 179.69,82.12 178.83,82.99 178.83,85.2 178.33,85.71 177.44,85.71 176.63,86.51 176.28,86.51 176.15,86.64 JDIMM2.174
  IN03 w0.13: v1(179.74,82.12) 178.71,82.12 178.51,82.32 178.51,94.27 181.17,96.94 181.17,110.54 181.33,110.7 181.33,116.44 181.23,116.53 180.79,116.53 180.66,116.66 180.66,116.92 180.79,117.05 181.15,117.05 181.27,117.17 181.27,117.44 181.15,117.56 180.77,117.56 180.64,117.69 180.64,117.96 180.77,118.08 181.15,118.08 181.27,118.21 181.27,118.47 181.15,118.6 180.77,118.6 180.64,118.73 180.64,118.99 180.77,119.12 181.04,119.12 181.17,119.25 181.17,119.67 174.75,126.09 v1(174.75,127.28)
  BOTTOM w0.076: U1.AB1 175.28,130.73 175.28,129.34 175.03,129.09 175.03,127.56 v1(174.75,127.28)
  BOTTOM w0.102: JDIMM1.174 177.82,80.38 177.96,80.52 178.2,80.52 178.3,80.62 178.3,81.44 178.4,81.54 178.61,81.54 178.71,81.44 178.71,80.62 178.81,80.52 178.95,80.52 179.07,80.65 179.07,80.76 179.17,80.86 179.31,80.86 179.43,80.98 179.43,81.14 179.31,81.26 179.31,81.5 179.22,81.59 179.07,81.59 178.66,82 178.66,82.23 178.79,82.36 179.61,82.36 179.74,82.23 v1(179.74,82.12)
M_A_DQ33: length 72
  TOP w0.102: v1(178.09,84.92) 177.38,84.2 177.38,81.65 176.68,80.95 175.69,80.95 174.9,80.17 JDIMM2.169
  IN03 w0.076: v1(174.3,127.73) 174.3,126.91 174.51,126.7 174.51,125.99
  IN03 w0.13: v1(178.09,84.92) 178.09,88.39 177.67,88.81 177.67,90.66 177.79,90.78 178.05,90.78 178.17,90.91 178.17,91.21 178.05,91.34 177.82,91.34 177.69,91.47 177.69,91.75 177.82,91.88 178.05,91.88 178.17,92 178.17,92.24 178.05,92.37 177.79,92.37 177.67,92.5 177.67,93.94 180.79,97.07 180.79,110.37 180.36,110.8 180.36,111.31 180.49,111.44 180.84,111.44 180.97,111.57 180.97,111.83 180.84,111.96 180.49,111.96 180.36,112.09 180.36,112.35 180.49,112.48 180.84,112.48 180.97,112.6 180.97,112.86 180.84,112.99 180.49,112.99 180.36,113.12 180.36,113.38 180.49,113.51 180.84,113.51 180.97,113.64 180.97,113.9 180.84,114.03 180.49,114.03 180.36,114.16 180.36,114.42 180.49,114.55 180.84,114.55 180.97,114.68 180.97,114.94 180.84,115.07 180.49,115.07 180.36,115.2 180.36,115.45 180.49,115.58 180.84,115.58 180.97,115.71 180.97,115.97 180.84,116.1 180.49,116.1 180.26,116.33 180.26,120.24 174.51,125.99
  BOTTOM w0.076: U1.AB2 174.91,131.19 174.91,130.7 175.08,130.54 175.08,129.52 174.73,129.17 174.73,128.16 v1(174.3,127.73)
  BOTTOM w0.102: v1(178.09,84.92) 178.09,84.77 177.54,84.22 176.95,84.22 176.84,84.33 176.84,84.47 176.95,84.58 177.47,84.58 177.59,84.7 177.59,84.87 177.47,84.98 177.01,84.98 176.88,85.11 176.88,85.91 176.69,86.1 176.01,86.1 175.89,86.22 175.89,86.39 176.01,86.51 176.42,86.51 176.57,86.66 JDIMM1.169
M_A_DQ34: length 70
  TOP w0.102: v1(181.39,82.38) 181.39,82.18 180.16,80.95 179.46,80.95 179.35,80.84 179.35,80.59 179.23,80.47 179.07,80.47 178.95,80.59 178.95,80.84 178.85,80.95 178.62,80.95 178.4,80.73 JDIMM2.183
  IN03 w0.076: 179.5,123.52 179.33,123.52 175.31,127.55 175.31,130.53 175.79,131.02 175.79,131.86 v1(176.37,132.44)
  IN03 w0.13: 179.5,123.52 182.16,120.86 182.75,120.86 184.07,119.54 184.07,109.35 183.43,108.72 183.43,96.81 180.64,94.01 180.64,84.97 180.51,84.84 180.31,84.84 180.18,84.71 180.18,84.45 180.31,84.32 180.51,84.32 180.64,84.19 180.64,83.93 180.51,83.8 180.31,83.8 180.18,83.67 180.18,83.41 180.31,83.28 180.51,83.28 180.64,83.15 180.64,82.63 180.89,82.38 v1(181.39,82.38)
  BOTTOM w0.076: v1(176.37,132.44) 176.05,132.77 U1.AA4
  BOTTOM w0.102: JDIMM1.183 180.07,86.17 180.51,85.73 180.51,83.12 181.25,82.38 v1(181.39,82.38)
M_A_DQ35: length 70.6
  TOP w0.102: JDIMM2.182 178.21,87.52 178.21,86.6 178.11,86.51 177.48,86.51 177.39,86.42 177.39,86.19 177.52,86.06 178.43,86.06 178.59,85.9 178.72,85.9 178.99,86.17 179.17,86.17 179.43,85.9 179.43,85.73 179.14,85.43 179.14,85.09 179.23,84.99 179.5,84.99 179.74,85.23 v1(179.74,85.3)
  IN03 w0.076: v1(176.37,133.09) 175.48,132.2 175.48,131.12 175.03,130.66 175.03,127.56 179.12,123.47
  IN03 w0.13: 179.12,123.47 182.04,120.55 182.57,120.55 183.66,119.46 183.66,109.68 183.05,109.07 183.05,96.93 180.3,94.18 180.3,92.09 180.17,91.96 179.85,91.96 179.72,91.83 179.72,91.57 179.85,91.44 180.17,91.44 180.3,91.31 180.3,91.05 180.17,90.92 179.85,90.92 179.72,90.79 179.72,90.53 179.85,90.4 180.17,90.4 180.3,90.27 180.3,88.54 180.17,88.41 179.85,88.41 179.72,88.28 179.72,88.02 179.85,87.89 180.17,87.89 180.3,87.76 180.3,87.51 180.17,87.38 179.85,87.38 179.72,87.25 179.72,86.99 179.85,86.86 180.17,86.86 180.3,86.73 180.3,85.47 180.13,85.3 v1(179.74,85.3)
  BOTTOM w0.076: v1(176.37,133.09) 176.05,133.42 U1.AA5
  BOTTOM w0.102: JDIMM1.182 179.82,81.31 180.16,81.66 180.16,84.87 v1(179.74,85.3)
M_A_DQ36: length 72.9
  TOP w0.102: v1(178.09,82.07) 178.51,82.5 178.51,85.08 178.22,85.37 177.34,85.37 176.61,86.1 175.8,86.1 175.15,86.75 JDIMM2.170
  IN03 w0.076: 174.23,125.58 173.88,125.93 173.88,127.26 173.65,127.49 173.65,128.99 v1(174.3,129.63)
  IN03 w0.13: 174.23,125.58 179.54,120.27 179.54,102.55 179.67,102.42 179.93,102.42 180.05,102.3 180.05,102.03 179.93,101.91 179.67,101.91 179.54,101.78 179.54,96.83 177,94.29 177,88.33 177.33,87.99 177.33,83.85 177.62,83.56 177.62,82.53 v1(178.09,82.07)
  BOTTOM w0.076: v1(174.3,129.63) 174.72,130.05 174.72,130.44 174.61,130.55 174.61,132.83 U1.AB5
  BOTTOM w0.102: JDIMM1.170 176.82,80.43 176.72,80.53 176.15,80.53 176.03,80.65 176.03,80.82 176.15,80.94 176.72,80.94 177.09,81.31 177.09,83.64 177.22,83.77 177.44,83.77 177.57,83.64 177.57,82.57 178.07,82.07 v1(178.09,82.07)
M_A_DQ37: length 70.9
  TOP w0.102: v1(178.09,84.15) 177.68,83.75 177.68,81.52 176.8,80.65 176.11,80.65 175.9,80.45 JDIMM2.173
  IN03 w0.076: v1(174.3,129) 173.86,128.55 173.86,127.54 174.09,127.31 174.09,126.07 174.26,125.9
  IN03 w0.13: v1(178.09,84.15) 178.09,84.32 177.67,84.74 177.67,88.24 177.33,88.58 177.33,94.11 180.41,97.19 180.41,102.78 180.28,102.91 180.03,102.91 179.9,103.04 179.9,103.3 180.03,103.43 180.28,103.43 180.41,103.56 180.41,103.82 180.28,103.94 180.03,103.94 179.9,104.07 179.9,104.33 180.03,104.46 180.28,104.46 180.41,104.59 180.41,104.85 180.28,104.98 180.03,104.98 179.9,105.11 179.9,105.37 180.03,105.5 180.28,105.5 180.29,105.51 180.41,105.63 180.41,105.89 180.28,106.02 180.03,106.02 179.9,106.15 179.9,106.41 180.03,106.54 180.28,106.54 180.41,106.67 180.41,106.92 180.28,107.05 180.03,107.05 179.9,107.18 179.9,107.44 180.03,107.57 180.28,107.57 180.41,107.7 180.41,107.96 180.28,108.09 180.03,108.09 179.9,108.22 179.9,108.48 180.03,108.61 180.28,108.61 180.41,108.74 180.41,109 180.28,109.13 180.03,109.13 179.9,109.26 179.9,109.51 180.03,109.64 180.28,109.64 180.41,109.77 180.41,110.03 180.28,110.16 180.03,110.16 179.9,110.29 179.9,120.25 174.26,125.9
  BOTTOM w0.076: U1.AB4 174.92,132.5 174.92,131.66 174.76,131.49 174.76,130.64 174.88,130.52 174.88,129.67 174.3,129.1 v1(174.3,129)
  BOTTOM w0.102: JDIMM1.173 177.57,86.57 177.46,86.47 177.03,86.47 176.96,86.39 176.96,86.26 177.18,86.03 177.18,85.44 177.31,85.32 177.38,85.32 177.39,85.32 177.46,85.32 177.57,85.42 177.57,85.73 177.64,85.8 177.79,85.8 177.87,85.73 177.87,85.5 178.02,85.35 178.23,85.35 178.51,85.07 178.51,84.46 178.2,84.15 v1(178.09,84.15)
