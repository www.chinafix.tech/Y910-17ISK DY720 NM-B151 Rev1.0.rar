# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PT1004  -  [TPC12]  243.94 201.76 180 bottom
PT1005  -  [TPC12]  245.08 195.66 180 bottom
PT1501  -  [TPC12]  163.29 190.33 180 bottom
PT1502  -  [TPC12]  163.04 184.36 180 bottom
PT1503  -  [TPC12]  174.04 190.07 180 bottom
PT1504  -  [TPC12]  173.83 184.31 180 bottom
PT1601  -  [TPC12]  195.63 190.07 180 bottom
PT1602  -  [TPC12]  196.18 184.1 180 bottom
PT1603  -  [TPC12]  184.83 190.07 180 bottom
PT1604  -  [TPC12]  185.39 184.1 180 bottom
PT1605  -  [TPC12]  206.55 190.07 180 bottom
PT1606  -  [TPC12]  207.11 184.1 180 bottom
PTP901  -  [TPC12]  256.13 201.76 180 bottom
PTP902  -  [TPC12]  257.4 195.66 180 bottom
PTP903  -  [TPC12]  268.32 201.76 180 bottom
PTP904  -  [TPC12]  269.59 195.66 180 bottom
PTP905  -  [TPC12]  220.82 195.66 180 bottom
PTP906  -  [TPC12]  233.01 195.66 180 bottom
PU1  -  [SC59-1_9-3X1_6-1_4MM]  10.26 142.07 90 bottom
PU5  -  [QFN17P-0_65-4X4-1MM]  303.11 198.93 270 bottom
PU7  -  [TPS22913_4P]  276.96 76.03 0 top
PU8  -  [TPS22913_4P]  210.92 124.16 180 top
PU201  -  [ISL95520HRTZ_TQFN32_4X4]  83.29 11 90 top
PU301  -  [TPS51225CRUKR_QFN20_3X3]  43.75 12.5 0 top
PU401  -  [RT8231AGQW_WQFN20_3X3]  111.26 90.96 270 top
PU402  -  [SOT23-8P-0_65-2_9X1_6-1_45MM]  103.6 88.09 0 top
PU403  -  [SYX198DQNC_QFN10_3X3]  211.24 114.09 90 top
PU501  -  [SYX198DQNC_QFN10_3X3]  263.19 49.21 270 top
PU603  -  [DFN10P-0_5-3X3-0_8MM]  272.77 62.56 180 top
PU605  -  [QFN36-4X7-5-37P]  78.33 51.51 270 top
PU701  -  [QFN20-0_4-3X3X1MM]  301.98 97.49 270 bottom
PU702  -  [SYX198DQNC_QFN10_3X3]  216.5 165.79 90 bottom
PU901  -  [NCP81382MNTXG_QFN39-31_6X4]  257.96 199.83 180 bottom
PU902  -  [NCP81382MNTXG_QFN39-31_6X4]  270.15 199.83 180 bottom
PU1001  -  [NCP81382MNTXG_QFN39-31_6X4]  221.39 199.83 180 bottom
PU1002  -  [NCP81382MNTXG_QFN39-31_6X4]  233.58 199.83 180 bottom
PU1101  -  [QFN52-0_4-6X6X1MM]  126.33 191.6 270 top
PU1204  -  [TPS51362RVER_QFN28_3P5X4P5]  133.85 151.16 180 bottom
PU1252  -  [SLG5NT1533VTR_STDFN8-6_1X1P6]  206.84 155.31 180 top
PU1254  -  [SLG5NT1533VTR_STDFN8-6_1X1P6]  189.57 128.64 180 top
PU1301  -  [WSON7P-0_65-3X3-0_8MM]  62.2 42.24 90 bottom
PU1303  -  [BGA8P-0_5-2X1X0_62MM]  152.05 198.44 90 bottom
PU1304  -  [WSON7P-0_65-3X3-0_8MM]  19.53 17.1 90 top
PU1306  -  [WDFN-10L_0_5-3X3X0_8MM]  181.33 196.55 0 bottom
PU1307  -  [SLG59M301VTR_FC-TDFN8-6_1P5X2]  195.46 193.89 90 bottom
PU1308  -  [DFN6P-0_4-1_6X1-0_6MM]  201.01 153.37 90 top
PU1309  -  [SYX198DQNC_QFN10_3X3]  123.31 132.68 90 bottom
PU1501  -  [NCP81382MNTXG_QFN39-31_6X4]  165.07 188.16 180 bottom
PU1502  -  [NCP81382MNTXG_QFN39-31_6X4]  175.87 188.16 180 bottom
PU1601  -  [NCP81382MNTXG_QFN39-31_6X4]  197.46 188.16 180 bottom
PU1602  -  [NCP81382MNTXG_QFN39-31_6X4]  186.66 188.16 180 bottom
PU1603  -  [NCP81382MNTXG_QFN39-31_6X4]  208.38 188.16 180 bottom
PU1604  -  [QFN20-0_4-3X3X1MM]  214.22 98.5 90 bottom
PU1605  -  [QFN40-0_4-5X5X1MM]  292.2 184.23 180 top
PU1606  -  [NCP81382MNTXG_QFN39-31_6X4]  245.77 199.83 180 bottom
PU1607  -  [SLG59M301VTR_FC-TDFN8-6_1P5X2]  207.9 122.01 90 bottom
PU1608  -  [SOT23-8P-0_65-2_9X1_6-1_45MM]  301.34 87.2 270 top
PU1609  -  [SOT23-8P-0_65-2_9X1_6-1_45MM]  213.46 108.16 270 bottom
PU1610  -  [SOT23-8P-0_65-2_9X1_6-1_45MM]  300.83 174.7 0 top
Q1  -  [AO5804EL_SC89-6]  193.4 54.19 90 bottom
Q2  -  [AO5804EL_SC89-6]  217.91 45.92 0 bottom
Q5  -  [AO5804EL_SC89-6]  205.84 199.12 0 top
Q6  -  [AO5804EL_SC89-6]  75.42 95.21 90 bottom
Q7  -  [AO5804EL_SC89-6]  76.16 98.5 270 bottom
Q8  -  [AO5804EL_SC89-6]  267.82 76.04 0 top
Q9  -  [AO5804EL_SC89-6]  94.83 53.79 270 bottom
Q10  -  [MMST3904-7-F_SOT323-3]  141.89 162.64 90 bottom
Q11  -  [SOT323-3P-1_3-2_15X1_3-1MM]  75.03 20.02 90 top
Q12  -  [DMG1012T-7_SOT523-3]  244.83 46.05 0 top
Q13  -  [AO5804EL_SC89-6]  206.21 131.53 180 bottom
Q24  -  [MMBT3904WH_SOT323-3]  204.33 119.98 90 top
Q29  -  [LP2301ALT1G_SOT23-3]  15.95 42.24 90 bottom
Q35  -  [AO5804EL_SC89-6]  51.52 72.73 90 top
Q41  -  [AO5804EL_SC89-6]  8.09 120.49 180 bottom
Q49  -  [AO5804EL_SC89-6]  209.27 197.05 0 bottom
Q52  -  [AO5804EL_SC89-6]  19.65 45.03 180 top
Q53  -  [AO5804EL_SC89-6]  49.11 46.3 270 bottom
Q74  -  [AO5804EL_SC89-6]  67.78 79.44 180 top
Q75  -  [AO5804EL_SC89-6]  200.38 130.12 270 top
Q76  -  [AO5804EL_SC89-6]  245.58 103.57 180 top
Q80  -  [AO5804EL_SC89-6]  218.16 120.85 270 top
Q81  -  [AO5804EL_SC89-6]  246.99 176.22 0 bottom
Q82  -  [AO5804EL_SC89-6]  282.3 174.44 0 bottom
Q83  -  [AO5804EL_SC89-6]  302.85 124.91 270 bottom
Q84  -  [AO5804EL_SC89-6]  258.66 84.42 180 bottom
Q85  -  [AO5804EL_SC89-6]  287.51 174.44 270 top
Q86  -  [AO5804EL_SC89-6]  301.73 78.18 270 top
Q87  -  [AO5804EL_SC89-6]  301.48 59.25 270 top
Q88  -  [AO5804EL_SC89-6]  301.48 61.79 270 top
Q90  -  [AO5804EL_SC89-6]  293.86 173.81 270 top
Q91  -  [AO5804EL_SC89-6]  296.02 73.1 270 top
Q92  -  [AO5804EL_SC89-6]  210.02 153.87 180 top
Q93  -  [AO5804EL_SC89-6]  244.56 108.35 180 top
Q94  -  [AO5804EL_SC89-6]  301.73 83.26 270 top
Q95  -  [AO5804EL_SC89-6]  280 193.79 270 bottom
Q97  -  [AO5804EL_SC89-6]  291.7 77.03 270 top
Q98  -  [AO5804EL_SC89-6]  302.73 55.97 90 top
Q100  -  [AO5804EL_SC89-6]  205.7 124.93 90 top
Q101  -  [AO5804EL_SC89-6]  287.51 171.9 270 top
Q104  -  [DFN3X3A_8L_EP1_P]  217.01 159.85 90 top
Q105  -  [DFN3X3A_8L_EP1_P]  297.28 168.99 90 top
Q106  -  [MMBT3906_PNP_SOT23-3]  82.57 78.24 90 bottom
R1  -  [R_0402NEW]  189.45 127 90 bottom
R2  -  [R_0402NEW]  189.25 160.35 0 bottom
R4  -  [R_0402NEW]  191.94 127.97 180 bottom
R5  -  [R_0402NEW]  187.42 127 90 bottom
R6  -  [R_0402NEW]  186.28 127 90 bottom
R7  -  [R_0402NEW]  145.13 162.69 90 bottom
R8  -  [R_0402NEW]  146.15 163.6 270 bottom
R9  -  [R_0402NEW]  146.15 161.57 270 bottom
R10  -  [R_0402NEW]  152.45 149.43 180 top
R11  -  [R_0402NEW]  145.05 153.24 0 bottom
R12  -  [R_0402NEW]  150.21 147.83 90 top
R13  -  [R_0402NEW]  145.97 152.35 180 bottom
R14  -  [R_0402NEW]  189.96 153.04 90 top
R15  -  [R_0402NEW]  195.3 158.5 90 bottom
R16  -  [R_0402NEW]  244.04 134.55 270 top
R17  -  [R_0402NEW]  185.64 141.13 270 top
R18  -  [R_0402NEW]  145.05 154.38 0 bottom
R19  -  [R_0603NEW]  226.6 125.68 180 top
R20  -  [R_0603NEW]  225.2 126.95 0 top
R21  -  [R_0402NEW]  146.2 127.97 0 bottom
R22  -  [R_0402NEW]  145.05 147.91 0 bottom
R23  -  [R_0402NEW]  149.07 145.11 0 top
R24  -  [R_0402NEW]  145.97 149.69 180 bottom
R25  -  [R_0402NEW]  145.97 156.16 180 bottom
R26  -  [R_0402NEW]  148.81 141.48 90 top
R27  -  [R_0402NEW]  150.51 151.08 0 top
R28  -  [R_0402NEW]  152.37 144.25 270 top
R29  -  [R_0402NEW]  149.58 152.43 270 top
R30  -  [R_0402NEW]  149.4 154.26 180 top
R31  -  [R_0402NEW]  183.94 147.42 180 top
R32  -  [R_0402NEW]  150.92 144.12 270 top
R33  -  [R_0603NEW]  226.59 123.71 270 top
R34  -  [R_0603NEW]  225.27 123.71 270 top
R35  -  [R_0603NEW]  234.35 128.98 0 top
R36  -  [R_0603NEW]  233.97 126.06 0 top
R37  -  [R_0603NEW]  236 122.63 0 top
R41  -  [R_0603NEW]  233.97 127.33 0 top
R46  -  [R_0402NEW]  147.29 161.57 270 bottom
R48  -  [R_0402NEW]  145.13 161.57 270 bottom
R49  -  [R_0402NEW]  106.8 94.75 90 top
R51  -  [R_0402NEW]  135.78 149.61 270 bottom
R52  -  [R0402_SHORT]  176.22 138.33 0 top
R53  -  [R_0603NEW]  195.3 160.42 90 bottom
R54  -  [R_0603NEW]  183.55 165.69 0 bottom
R56  -  [R_0402NEW]  41.8 39.45 0 bottom
R57  -  [R_0402NEW]  108.22 97.49 0 top
R59  -  [R_0402NEW]  170.73 160.1 180 bottom
R60  -  [R_0402NEW]  134.46 144.22 90 bottom
R61  -  [R_0402NEW]  46.25 42.88 0 bottom
R62  -  [R_0402NEW]  247.59 61.19 180 top
R63  -  [R_0402NEW]  252.14 61.04 180 bottom
R64  -  [R_0402NEW]  48.56 48.34 180 bottom
R65  -  [R_0603NEW]  198.04 195.09 90 bottom
R66  -  [R_0603NEW]  265.4 40 270 top
R67  -  [R_0603NEW]  266.62 40 270 top
R68  -  [R_0603NEW]  279.62 40.15 270 top
R69  -  [R_0603NEW]  278.35 40.15 270 top
R70  -  [R_0603NEW]  292.13 49.36 180 top
R71  -  [R_0603NEW]  292.13 50.63 180 top
R81  -  [R_0402NEW]  193.14 57.92 90 bottom
R82  -  [R_0402NEW]  194.41 57.92 90 bottom
R84  -  [R_0402NEW]  161.77 58.93 90 bottom
R86  -  [R_0402NEW]  159.94 59.01 180 bottom
R89  -  [R_0402NEW]  165.96 94.52 270 bottom
R90  -  [R_0402NEW]  163.72 94.57 0 bottom
R91  -  [R_0402NEW]  168.12 93.6 90 bottom
R92  -  [R_0402NEW]  159.99 93.6 90 bottom
R93  -  [R_0402NEW]  169.39 58.8 90 bottom
R94  -  [R_0402NEW]  167.53 58.88 0 bottom
R95  -  [R_0402NEW]  170.78 59.72 270 bottom
R96  -  [R_0402NEW]  163.67 59.85 270 bottom
R97  -  [R_0402NEW]  226.71 67.01 0 top
R99  -  [R_0402NEW]  250.54 47.4 270 bottom
R102  -  [R_0402NEW]  251.43 47.4 270 bottom
R103  -  [R_0402NEW]  226.54 68.46 90 top
R106  -  [R_0402NEW]  223.31 55.83 180 top
R107  -  [R_0402NEW]  223.31 55.83 180 bottom
R108  -  [R_0402NEW]  225.65 69.37 270 top
R109  -  [R_0402NEW]  223.31 54.94 180 top
R110  -  [R_0402NEW]  223.06 63.83 180 bottom
R111  -  [R_0402NEW]  223.31 54.94 180 bottom
R112  -  [R_0402NEW]  229.2 47.4 270 top
R113  -  [R_0402NEW]  230.91 62.94 0 top
R114  -  [R_0402NEW]  242.29 47.37 90 top
R115  -  [R_0603NEW]  217.33 61.55 0 bottom
R116  -  [R_0402NEW]  215.87 46.87 90 bottom
R117  -  [R_0402NEW]  248.51 46 270 top
R118  -  [R_0402NEW]  216.38 58.93 90 bottom
R119  -  [R_0402NEW]  216.38 49.53 90 top
R120  -  [R_0402NEW]  215.49 59.85 270 bottom
R121  -  [R_0402NEW]  214.98 47.78 270 bottom
R122  -  [R_0402NEW]  214.73 51.82 90 top
R123  -  [R_0402NEW]  247.7 43.77 180 bottom
R124  -  [R_0402NEW]  213.58 51.82 90 top
R125  -  [R_0402NEW]  233.32 50.24 0 top
R126  -  [R_0402NEW]  233.19 51.64 0 top
R129  -  [R_0402NEW]  240.18 76.03 0 bottom
R130  -  [R_0402NEW]  247.24 60.35 270 top
R131  -  [R_0402NEW]  251.23 50.75 0 top
R132  -  [R_0402NEW]  245.61 48.29 180 bottom
R134  -  [R_0402NEW]  247.03 48.97 0 top
R135  -  [R_0402NEW]  247.39 48.31 180 bottom
R136  -  [R_0402NEW]  236.57 47.37 90 bottom
R137  -  [R_0402NEW]  238.35 48.29 270 bottom
R138  -  [R_0402NEW]  240.13 48.29 270 top
R139  -  [R_0402NEW]  241.02 47.37 90 bottom
R142  -  [R_0402NEW]  239.24 48.29 270 top
R143  -  [R_0402NEW]  251.23 51.64 0 top
R144  -  [R_0402NEW]  238.35 48.29 270 top
R145  -  [R_0402NEW]  240.13 48.29 270 bottom
R146  -  [R_0402NEW]  249.14 53.85 90 top
R147  -  [R_0402NEW]  244.32 54.89 270 top
R148  -  [R_0402NEW]  242.46 56.98 0 top
R149  -  [R_0402NEW]  243.05 55.78 270 top
R150  -  [R_0402NEW]  223.31 54.05 180 bottom
R151  -  [R_0402NEW]  227.43 47.4 270 top
R152  -  [R_0402NEW]  19.98 46.94 180 top
R153  -  [R_0402NEW]  223.31 54.05 180 top
R155  -  [R_0402NEW]  223.31 51.39 180 top
R158  -  [R_0402NEW]  223.31 52.28 180 top
R159  -  [R_0402NEW]  223.31 53.17 180 top
R160  -  [R_0402NEW]  243.17 48.29 270 top
R161  -  [R_0402NEW]  195.68 54.23 90 bottom
R162  -  [R_0402NEW]  192.5 55.02 270 bottom
R163  -  [R_0402NEW]  245.03 48.21 180 top
R164  -  [R_0402NEW]  231.87 47.4 270 top
R165  -  [R_0402NEW]  218.59 43.64 0 bottom
R166  -  [R_0402NEW]  216.89 46.51 270 bottom
R167  -  [R_0402NEW]  252.37 48.59 0 top
R168  -  [R_0402NEW]  232.76 47.4 270 bottom
R169  -  [R_0402NEW]  225.65 46.49 90 top
R170  -  [R_0402NEW]  228.32 47.4 270 bottom
R171  -  [R_0402NEW]  232.99 55.22 90 top
R173  -  [R_0402NEW]  222.52 66.25 0 top
R174  -  [R_0402NEW]  251.23 56.21 0 bottom
R175  -  [R_0402NEW]  251.23 58.37 0 bottom
R176  -  [R_0402NEW]  251.23 57.23 0 top
R177  -  [R_0402NEW]  249.73 60.28 180 top
R178  -  [R_0402NEW]  251.23 51.64 0 bottom
R179  -  [R_0402NEW]  239.87 52.23 270 top
R180  -  [R_0402NEW]  237.46 48.29 270 bottom
R181  -  [R_0402NEW]  246.3 57.1 180 top
R182  -  [R_0402NEW]  224.76 69.37 270 top
R183  -  [R_0402NEW]  239.24 47.37 90 bottom
R184  -  [R_0402NEW]  4.44 168.43 90 top
R185  -  [R_0402NEW]  223.18 59.64 180 top
R186  -  [R_0402NEW]  223.31 59.39 180 bottom
R187  -  [R_0402NEW]  225.09 59.64 180 top
R188  -  [R_0402NEW]  222.4 60.28 0 bottom
R189  -  [R_0402NEW]  250.67 73.66 90 bottom
R190  -  [R_0402NEW]  247.7 75.77 180 bottom
R191  -  [R_0402NEW]  5.3 168.43 90 top
R192  -  [R_0402NEW]  243.61 46.82 0 bottom
R200  -  [R_0402NEW]  251.23 52.53 0 top
R201  -  [R_0402NEW]  251.23 53.42 0 top
R202  -  [R_0402NEW]  251.23 50.75 0 bottom
R203  -  [R_0402NEW]  252.14 57.23 180 bottom
R204  -  [R_0402NEW]  253.33 65.94 270 bottom
R205  -  [R_0402NEW]  256.05 59.9 0 top
R206  -  [R_0603NEW]  239.43 44.78 0 bottom
R207  -  [R_0402NEW]  250.21 68.41 0 top
R208  -  [R_0603NEW]  223.68 50.24 180 bottom
R209  -  [R_0402NEW]  251.73 67.26 0 top
R210  -  [R_0603NEW]  223.68 51.64 180 bottom
R211  -  [R_0603NEW]  228.76 57.86 180 top
R212  -  [R_0402NEW]  251.73 64.98 0 top
R213  -  [R_0603NEW]  221.71 62.63 270 bottom
R214  -  [R_0603NEW]  251.49 66.12 0 top
R215  -  [R_0603NEW]  248.19 58.25 0 top
R216  -  [R_0402NEW]  251.23 52.53 0 bottom
R217  -  [R_0402NEW]  252.14 60.28 180 top
R218  -  [R_0402NEW]  234.33 65.74 0 top
R219  -  [R_0402NEW]  252.45 65.94 270 bottom
R220  -  [R_0402NEW]  248.18 57.1 0 top
R221  -  [R_0603NEW]  253.27 63.2 180 top
R222  -  [R_0402NEW]  240.58 45.93 180 bottom
R223  -  [R_0603NEW]  254.6 66.06 270 bottom
R224  -  [R_0402NEW]  244.98 58.5 180 top
R225  -  [R_0402NEW]  237.46 47.37 90 top
R226  -  [R_0402NEW]  242.21 59.26 0 top
R228  -  [R_0402NEW]  227.43 46.49 90 bottom
R229  -  [R_0603NEW]  252.69 63.33 180 bottom
R230  -  [R_0603NEW]  223.68 52.91 180 bottom
R231  -  [R_0603NEW]  250.98 49.61 0 bottom
R232  -  [R_0402NEW]  30.5 45.04 0 bottom
R233  -  [R_0402NEW]  32.35 57.31 270 top
R234  -  [R_0603NEW]  231.17 76.15 180 top
R235  -  [R_0402NEW]  31.64 54.44 0 top
R236  -  [R_0402NEW]  38.96 44.2 90 bottom
R237  -  [R_0402NEW]  33.24 59.46 270 bottom
R238  -  [R_0402NEW]  35.28 56.54 270 top
R239  -  [R_0402NEW]  27.07 48.47 0 bottom
R240  -  [R_0402NEW]  25.67 56.59 0 bottom
R241  -  [R_0402NEW]  40.86 45.11 270 bottom
R242  -  [R_0402NEW]  41.75 45.11 270 bottom
R243  -  [R_0402NEW]  39.85 44.2 90 bottom
R244  -  [R_0402NEW]  34.26 56.54 270 top
R245  -  [R_0402NEW]  31.41 42.37 180 bottom
R246  -  [R_0402NEW]  27.71 55.2 0 top
R247  -  [R_0402NEW]  42.72 47.96 180 bottom
R248  -  [R_0402NEW]  30.5 43.26 0 bottom
R249  -  [R_0402NEW]  33.62 44.71 90 bottom
R250  -  [R_0402NEW]  30.5 45.93 0 top
R251  -  [R_0402NEW]  35.4 61.24 270 bottom
R252  -  [R_0402NEW]  27.99 45.93 180 top
R253  -  [R_0402NEW]  38.2 58.7 270 top
R254  -  [R_0402NEW]  39.09 58.7 270 top
R255  -  [R_0402NEW]  28.62 58.63 180 bottom
R256  -  [R_0402NEW]  35.4 58.55 90 bottom
R257  -  [R_0402NEW]  36.29 58.55 90 bottom
R258  -  [R_0402NEW]  28.06 49.79 270 top
R259  -  [R_0402NEW]  28.62 56.09 180 top
R260  -  [R_0402NEW]  38.07 45.11 270 bottom
R261  -  [R_0402NEW]  27.07 49.36 0 bottom
R262  -  [R_0402NEW]  27.99 46.69 180 bottom
R263  -  [R_0402NEW]  34.51 49.81 270 top
R264  -  [R_0402NEW]  27.71 54.31 0 bottom
R265  -  [R_0402NEW]  33.62 47.4 270 bottom
R266  -  [R_0402]  222.4 56.72 0 top
R267  -  [R_0402NEW]  39.19 53.42 90 top
R268  -  [R_0402NEW]  69.41 18.57 270 bottom
R269  -  [R_0402NEW]  145.97 150.57 180 bottom
R270  -  [R_0402NEW]  223.06 65.23 180 bottom
R271  -  [R_0603NEW]  47.47 68.72 90 bottom
R272  -  [R_0402NEW]  44.17 65.56 270 bottom
R273  -  [R_0603NEW]  41.88 67.58 90 bottom
R274  -  [R_0402NEW]  54.27 69.04 180 top
R275  -  [R_0402NEW]  52.52 69.04 180 top
R276  -  [R_0402NEW]  50.29 69.12 270 top
R277  -  [R_0402NEW]  49.37 69.12 270 top
R278  -  [R_0402NEW]  52.75 60.28 180 top
R279  -  [R_0402NEW]  52.75 61.17 180 top
R280  -  [R_0402NEW]  44.75 67.26 180 top
R281  -  [R_0402NEW]  46.78 67.14 180 top
R282  -  [R_0402NEW]  48.48 68.2 90 top
R283  -  [R_0805NEW]  22.41 106.25 180 top
R284  -  [R_0603NEW]  289.15 26.05 270 top
R285  -  [R_0603NEW]  282.61 34.88 180 bottom
R286  -  [R_0603NEW]  281.91 31.26 270 bottom
R287  -  [R_0402NEW]  251.23 59.26 0 top
R288  -  [R_0402NEW]  241.9 48.29 270 bottom
R289  -  [R_0402NEW]  282.11 34.88 180 top
R290  -  [R_0603NEW]  223.68 50.24 180 top
R292  -  [R_0402NEW]  286.23 39.12 90 top
R293  -  [R_0402NEW]  284.96 40.29 270 top
R294  -  [R_0402NEW]  27.07 51.13 0 bottom
R295  -  [R_0402NEW]  283.1 39.32 0 top
R296  -  [R_0402NEW]  281.2 38.56 0 top
R297  -  [R_0402NEW]  33.5 46.99 90 top
R298  -  [R_0402NEW]  281.2 37.67 0 top
R299  -  [R_0402NEW]  38.15 49.86 180 top
R300  -  [R_0402NEW]  43.66 38.1 90 bottom
R301  -  [R_0402NEW]  281.2 36.78 0 top
R302  -  [R_0402NEW]  281.2 35.89 0 top
R303  -  [R_0402NEW]  223.06 66.12 180 bottom
R304  -  [R_0402NEW]  230.98 46.49 90 top
R305  -  [R_0603NEW]  252.51 71.45 180 top
R306  -  [R_0402NEW]  251.23 54.31 0 top
R307  -  [R_0402NEW]  283.69 27.97 270 top
R308  -  [R_0402NEW]  42.59 49.23 180 bottom
R309  -  [R_0402NEW]  231.87 46.49 90 bottom
R310  -  [R_0402NEW]  282.11 33.86 180 top
R311  -  [R_0402NEW]  302.53 29.42 0 top
R312  -  [R_0402NEW]  303.45 28.4 180 top
R313  -  [R_0402NEW]  285.54 25.61 180 top
R314  -  [R_0402NEW]  286.4 25.61 0 top
R315  -  [R_0402NEW]  291.43 25.4 90 top
R316  -  [R_0402NEW]  296.77 37.42 270 bottom
R317  -  [R_0402NEW]  294.86 22.86 90 bottom
R318  -  [R_0402NEW]  265.58 29.54 0 top
R319  -  [R_0402NEW]  265.58 27.77 0 top
R320  -  [R_0402NEW]  265.58 28.65 0 top
R321  -  [R_0402NEW]  265.58 26.88 0 top
R322  -  [R_0402NEW]  265.58 25.99 0 top
R323  -  [R_0402NEW]  278.35 26.17 90 top
R324  -  [R_0402NEW]  41.9 56.85 180 top
R325  -  [R_0402NEW]  266.42 33.56 270 top
R326  -  [R_0402NEW]  44.11 4.65 180 bottom
R327  -  [R_0402NEW]  44.11 5.79 180 bottom
R328  -  [R_0402NEW]  265.48 32.59 180 top
R329  -  [R_0603NEW]  283.12 45.8 0 bottom
R330  -  [R_0402NEW]  278.05 54.44 180 top
R331  -  [R_0402NEW]  279.55 47.58 0 bottom
R332  -  [R_0402NEW]  278.1 48.92 270 bottom
R333  -  [R_0402NEW]  289.78 50.42 90 top
R334  -  [R_0402NEW]  289.78 49.56 270 top
R335  -  [R_0402NEW]  282.04 46.13 270 bottom
R336  -  [R_0402NEW]  232.07 45.04 180 bottom
R337  -  [R_0402NEW]  27.99 47.58 180 bottom
R338  -  [R_0402NEW]  281.15 26.29 90 top
R339  -  [R_0402NEW]  275.81 43.34 270 top
R340  -  [R_0402NEW]  275.31 45.24 270 top
R341  -  [R_0402NEW]  276.96 53.5 270 top
R342  -  [R_0402NEW]  276.96 50.3 90 top
R343  -  [R_0402NEW]  277.46 43.34 270 top
R344  -  [R_0402NEW]  278.1 45.24 270 top
R345  -  [R_0402NEW]  277.85 52.58 90 top
R346  -  [R_0402NEW]  278.99 44.61 270 top
R347  -  [R_0402NEW]  275.31 46.1 90 top
R348  -  [R_0402NEW]  277.85 51.21 270 top
R368  -  [R_0402NEW]  183.87 194.06 90 top
R369  -  [R_0402NEW]  182.98 194.06 90 top
R370  -  [R_0402NEW]  42.59 50.12 180 bottom
R372  -  [R_0402NEW]  228.32 47.4 270 top
R373  -  [R_0402NEW]  199.11 195.96 90 bottom
R374  -  [R_0402NEW]  200.63 196.47 90 bottom
R376  -  [R_0603NEW]  20.04 42.43 270 bottom
R377  -  [R_0402NEW]  20.04 43.44 90 bottom
R378  -  [R_0603NEW]  18.07 39.58 180 bottom
R379  -  [R_0402NEW]  35.99 44.2 90 bottom
R380  -  [R_0402NEW]  63.6 9.43 270 top
R381  -  [R_0402NEW]  221.53 51.39 180 top
R382  -  [R_0603NEW]  71.79 84.41 0 top
R386  -  [R_0402NEW]  76.68 94.01 270 bottom
R387  -  [R_0402NEW]  74.39 96.04 270 bottom
R389  -  [R_0402NEW]  67.03 83.19 90 bottom
R390  -  [R_0402NEW]  71.6 96.04 270 bottom
R391  -  [R_0402NEW]  70.71 96.04 270 bottom
R392  -  [R_0402NEW]  65.12 94.39 270 bottom
R393  -  [R_0402NEW]  66.26 96.04 270 bottom
R394  -  [R_0402NEW]  67.15 96.04 270 bottom
R395  -  [R_0402NEW]  74.01 98.45 270 bottom
R396  -  [R_0402NEW]  77.11 97.23 0 bottom
R397  -  [R_0402NEW]  68.04 96.04 270 bottom
R398  -  [R_0402NEW]  68.93 96.04 270 bottom
R399  -  [R_0402NEW]  69.82 96.04 270 bottom
R402  -  [R_0402NEW]  75.53 88.01 90 top
R403  -  [R_0402NEW]  74.65 88.01 90 top
R405  -  [R_0402NEW]  17.57 160.1 180 top
R406  -  [R_0402NEW]  17.57 160.99 180 top
R407  -  [R_0402NEW]  61.31 6.1 90 top
R408  -  [R_0402NEW]  10.64 159.13 90 bottom
R409  -  [R_0402NEW]  14.12 161.12 90 bottom
R410  -  [R_0402NEW]  18.43 160.96 90 top
R411  -  [R_0402NEW]  18.43 160.13 270 top
R420  -  [R_0402NEW]  72.49 66.7 270 bottom
R421  -  [R_0603NEW]  69.31 78.25 90 bottom
R422  -  [R_0402NEW]  77.36 72.09 0 top
R423  -  [R_0402NEW]  61.69 56.42 270 bottom
R424  -  [R_0603NEW]  60.29 68.85 90 top
R425  -  [R_0402NEW]  67.58 62.56 0 top
R428  -  [R_0402NEW]  245.03 44.28 180 top
R429  -  [R_0402NEW]  77.87 21.54 0 top
R430  -  [R_0402NEW]  80.56 20.78 180 top
R431  -  [R_0402NEW]  51.35 3.64 180 top
R432  -  [R_0402NEW]  51.35 2.37 180 top
R433  -  [R_0603NEW]  52.42 5.6 90 top
R434  -  [R_0402NEW]  40.05 3.25 180 top
R435  -  [R_0402NEW]  46.71 47.53 270 bottom
R436  -  [R_0402NEW]  77.82 65.79 90 bottom
R437  -  [R_0402NEW]  67.66 55.5 90 bottom
R438  -  [R_0402NEW]  64.49 67.69 90 bottom
R439  -  [R_0402NEW]  61.82 67.69 90 bottom
R440  -  [R_0603NEW]  6.83 141.62 90 bottom
R443  -  [R_0402NEW]  14.75 134.57 0 top
R444  -  [R_0402NEW]  14.75 135.59 0 top
R445  -  [R_0402NEW]  18.59 130.38 180 top
R446  -  [R_0402NEW]  18.59 131.27 180 top
R447  -  [R_0402NEW]  18.59 128.48 180 top
R448  -  [R_0402NEW]  18.59 129.37 180 top
R449  -  [R_0402NEW]  18.59 126.7 180 top
R450  -  [R_0402NEW]  18.59 127.59 180 top
R451  -  [R_0402NEW]  12.21 137.87 0 top
R452  -  [R_0402NEW]  18.59 132.16 180 top
R453  -  [R_0402NEW]  18.59 133.05 180 top
R454  -  [R_0402NEW]  77.36 71.2 0 top
R455  -  [R_0402NEW]  75.15 66.7 270 bottom
R456  -  [R_0402NEW]  258.36 63.58 180 top
R457  -  [R_0402NEW]  266.54 77.24 270 top
R458  -  [R_0402NEW]  258.36 64.85 180 top
R459  -  [R_0402NEW]  265.65 77.24 270 top
R460  -  [R_0402NEW]  267.48 75.01 0 top
R461  -  [R_0402NEW]  279.88 69.62 270 top
R462  -  [R_0402NEW]  280.51 60.07 90 top
R463  -  [R_0402NEW]  279.62 60.99 270 top
R464  -  [R_0402NEW]  284.58 68.71 90 bottom
R465  -  [R_0402NEW]  281.4 60.99 270 top
R466  -  [R_0402NEW]  284.07 60.99 270 top
R467  -  [R_0402NEW]  285.47 68.71 90 bottom
R468  -  [R_0402NEW]  282.75 68.69 180 bottom
R469  -  [R_0402NEW]  282.54 68.71 90 top
R470  -  [R_0402NEW]  285.21 68.71 90 top
R471  -  [R_0402NEW]  282.29 60.07 90 top
R472  -  [R_0402NEW]  283.18 60.07 90 top
R473  -  [R_0402NEW]  286.35 69.62 270 bottom
R474  -  [R_0402NEW]  283.69 69.62 270 bottom
R475  -  [R_0402NEW]  283.43 69.62 270 top
R476  -  [R_0402NEW]  284.32 69.62 270 top
R477  -  [R_0402NEW]  54.15 71.33 180 top
R478  -  [R_0402NEW]  33.24 61.24 270 bottom
R479  -  [R_0402NEW]  93.87 55.07 0 bottom
R480  -  [R_0402NEW]  94.13 49.99 0 bottom
R481  -  [R_0402NEW]  110.15 57.99 180 bottom
R482  -  [R_0402NEW]  110.15 56.98 180 bottom
R483  -  [R_0402NEW]  96.11 76.1 270 bottom
R484  -  [R_0402NEW]  258.36 66.12 180 top
R485  -  [R_0402NEW]  94.13 51.77 0 bottom
R486  -  [R_0402NEW]  92.68 54.26 270 bottom
R487  -  [R_0402NEW]  69.77 63.58 180 top
R488  -  [R_0402NEW]  64.99 56.42 270 bottom
R489  -  [R_0402NEW]  74.26 77.98 90 bottom
R492  -  [R_0402NEW]  76.93 65.79 90 bottom
R495  -  [R_0402NEW]  20.21 67.39 0 top
R496  -  [R_0402NEW]  21.13 69.68 180 top
R497  -  [R_0402NEW]  22.17 58.25 180 top
R498  -  [R_0402NEW]  22.7 44.1 270 top
R499  -  [R_0402NEW]  22.17 60.41 180 top
R500  -  [R_0402NEW]  22.17 57.36 180 top
R501  -  [R_0402NEW]  22.17 59.39 180 top
R503  -  [R_0402NEW]  23.72 43.18 90 top
R504  -  [R_0402NEW]  20.67 36.22 270 top
R505  -  [R_0402NEW]  21.56 36.22 270 top
R506  -  [R_0402NEW]  232.1 55.22 90 top
R507  -  [R_0402NEW]  251.23 55.2 0 top
R508  -  [R_0402NEW]  94.13 50.88 0 bottom
R510  -  [R_0402NEW]  71.6 77.98 90 bottom
R511  -  [R_0402NEW]  71.09 4.19 90 top
R512  -  [R_0402NEW]  95.73 54.23 90 bottom
R513  -  [R_0402NEW]  64.82 5.36 180 top
R517  -  [R_0402NEW]  258.36 67.39 180 top
R518  -  [R_0402NEW]  76.93 65.79 90 top
R519  -  [R_0402NEW]  17.57 58.83 270 bottom
R520  -  [R_0402NEW]  137 151.39 180 bottom
R521  -  [R_0402NEW]  47.16 40.97 180 bottom
R522  -  [R_0402NEW]  18.59 58.83 270 bottom
R523  -  [R_0402NEW]  40.41 51.69 90 top
R524  -  [R_0402NEW]  67.53 4.73 270 top
R525  -  [R_0402NEW]  75.92 4.45 90 top
R526  -  [R_0402NEW]  29.3 48.9 90 top
R528  -  [R_0402NEW]  18.21 28.4 180 top
R529  -  [R_0402NEW]  18.59 30.43 180 top
R530  -  [R_0402NEW]  18.21 27.38 180 top
R531  -  [R_0402NEW]  18.59 29.42 180 top
R532  -  [R_0402NEW]  17.37 40.49 270 top
R533  -  [R_0402NEW]  16.35 40.49 270 top
R534  -  [R_0402]  227.3 56.8 270 top
R535  -  [R_0402]  222.4 56.72 0 bottom
R536  -  [R_0402]  226.28 57.81 270 top
R537  -  [R_0402NEW]  137 150.5 180 bottom
R538  -  [R_0402NEW]  42.72 40.34 180 bottom
R540  -  [R_0402NEW]  36.55 42.19 270 bottom
R541  -  [R_0402NEW]  76.04 65.79 90 bottom
R546  -  [R_0402NEW]  42.59 51.01 180 bottom
R547  -  [R_0402NEW]  235.3 57.18 270 top
R548  -  [R_0402NEW]  222.4 57.61 0 bottom
R549  -  [R_0402NEW]  222.4 58.5 0 bottom
R550  -  [R_0402NEW]  271.8 15.32 0 top
R551  -  [R_0402NEW]  274.62 15.32 180 top
R552  -  [R_0402NEW]  277.72 10.16 90 top
R553  -  [R_0402NEW]  202.97 111.46 0 bottom
R554  -  [R_0402NEW]  203.55 109.76 270 bottom
R555  -  [R_0402NEW]  42.34 42.75 180 bottom
R556  -  [R_0402]  45.61 44.28 0 bottom
R557  -  [R_0402NEW]  42.59 52.78 180 bottom
R558  -  [R_0402NEW]  155.49 133.43 180 top
R559  -  [R_0603NEW]  290.1 78.31 0 bottom
R560  -  [R_0603NEW]  98.84 91.65 180 bottom
R563  -  [R_0402NEW]  36.29 48.9 90 top
R564  -  [R_0402NEW]  35.4 48.9 90 top
R565  -  [R_0402NEW]  16.99 137.04 90 top
R566  -  [R_0402NEW]  44.17 50.17 90 bottom
R567  -  [R_0402NEW]  71.17 3.25 180 top
R568  -  [R_0402NEW]  13.18 125.02 90 top
R569  -  [R_0402NEW]  76.93 20.58 90 top
R570  -  [R_0402NEW]  81.17 19.76 0 top
R571  -  [R_0402NEW]  72.99 19.59 270 top
R572  -  [R_0402NEW]  271.5 20.58 90 top
R573  -  [R_0402NEW]  272.38 20.58 90 top
R574  -  [R_0402NEW]  279.19 27.89 180 bottom
R575  -  [R_0402NEW]  274.24 19.82 180 top
R576  -  [R_0402NEW]  275.86 19.82 0 top
R578  -  [R_0402NEW]  41.9 55.07 180 top
R579  -  [R_0402NEW]  41.9 55.96 180 top
R580  -  [R_0402]  45.77 46.54 180 bottom
R584  -  [R_0402NEW]  73.38 77.98 90 bottom
R585  -  [R_0402NEW]  72.49 77.98 90 bottom
R588  -  [R_0402NEW]  212.57 49.41 90 top
R590  -  [R_0402NEW]  65.88 55.5 90 bottom
R591  -  [R_0402NEW]  68.55 55.5 90 bottom
R593  -  [R_0402NEW]  212.57 52.73 270 top
R594  -  [R_0402NEW]  232.76 46.49 90 top
R595  -  [R_0402NEW]  66.77 55.5 90 bottom
R596  -  [R_0402NEW]  257.86 61.8 180 top
R600  -  [R_0402NEW]  207.36 129.92 90 bottom
R601  -  [R_0402NEW]  208.2 132.29 180 bottom
R606  -  [R_0402NEW]  235.55 141.94 0 top
R607  -  [R_0402NEW]  259.69 156.91 0 top
R608  -  [R_0402NEW]  248.94 150.19 0 top
R609  -  [R_0402NEW]  272.13 149.23 90 top
R610  -  [R_0402NEW]  275.13 136.6 180 top
R611  -  [R_0402NEW]  275.18 129.95 270 top
R612  -  [R_0402NEW]  274.21 118.82 0 top
R613  -  [R_0402NEW]  266.03 109.25 270 top
R614  -  [R_0402NEW]  255.87 108.46 90 top
R620  -  [R_0402NEW]  72.94 3.25 180 top
R632  -  [R_0402NEW]  62.71 67.69 90 bottom
R660  -  [R_0402NEW]  243.3 116.74 270 top
R773  -  [R_0402NEW]  63.6 67.69 90 bottom
R774  -  [R_0402NEW]  247.97 168.01 0 top
R777  -  [R_0402NEW]  42.59 51.9 180 bottom
R780  -  [R_0402NEW]  208.25 196.88 270 bottom
R781  -  [R_0402NEW]  211.3 195.71 90 bottom
R783  -  [R_0402NEW]  43.53 2.87 0 bottom
R784  -  [R_0402NEW]  205.46 196.88 270 bottom
R785  -  [R_0402NEW]  257.86 94.57 180 top
R787  -  [R_0402NEW]  237.76 57.79 270 top
R788  -  [R_0402NEW]  50.44 4.91 0 top
R791  -  [R_0402NEW]  17.16 46.05 0 top
R793  -  [R_0402NEW]  62.76 6.23 0 top
R796  -  [R_0402NEW]  249.27 108.46 90 top
R797  -  [R_0402NEW]  250.16 108.46 90 top
R798  -  [R_0402NEW]  304.59 59.26 180 top
R807  -  [R_0402NEW]  12.67 159.13 90 bottom
R808  -  [R_0402NEW]  300.53 60.4 180 top
R809  -  [R_0402NEW]  293.21 73.82 270 top
R810  -  [R_0402NEW]  299.13 73.1 180 top
R813  -  [R_0402NEW]  294.15 73.87 0 top
R814  -  [R_0402NEW]  63.67 6.85 180 bottom
R825  -  [R_0402NEW]  63.67 7.73 180 bottom
R826  -  [R_0402NEW]  246.96 170.96 180 top
R827  -  [R_0402NEW]  50.13 45.34 90 bottom
R830  -  [R_0402NEW]  55.87 39.07 180 bottom
R831  -  [R_0402NEW]  56.41 40.21 0 bottom
R832  -  [R_0402NEW]  54.96 40.92 270 bottom
R833  -  [R_0402NEW]  54.07 40.92 270 bottom
R834  -  [R_0402NEW]  53.18 40.92 270 bottom
R835  -  [R_0402NEW]  52.29 40.92 270 bottom
R836  -  [R_0402NEW]  51.4 40.92 270 bottom
R837  -  [R_0402NEW]  50.52 40.92 270 bottom
R838  -  [R_0402NEW]  50.08 44.02 180 bottom
R839  -  [R_0402NEW]  50.08 41.99 180 bottom
R840  -  [R_0402NEW]  50.08 43.01 180 bottom
R841  -  [R_0402NEW]  51.66 47.53 270 bottom
R842  -  [R_0402NEW]  52.93 47.53 270 bottom
R843  -  [R_0402NEW]  53.94 47.53 270 bottom
R844  -  [R_0402NEW]  54.96 47.53 270 bottom
R845  -  [R_0402NEW]  293.64 36 0 top
R846  -  [R_0402NEW]  293.64 35.11 0 top
R847  -  [R_0402NEW]  295.53 32.47 0 bottom
R848  -  [R_0402NEW]  295.53 33.58 0 bottom
R849  -  [R_0402NEW]  296.85 33.36 90 top
R850  -  [R_0402NEW]  296.84 32.54 270 top
R854  -  [R_0402NEW]  105.51 2.04 90 top
R855  -  [R_0402NEW]  227.05 59.82 90 top
R856  -  [R_0402NEW]  228.06 60.73 270 top
R857  -  [R_0402NEW]  272.33 92.66 180 top
R858  -  [R_0402NEW]  247.16 177.63 0 bottom
R859  -  [R_0402NEW]  293.14 144.45 0 top
R862  -  [R_0402NEW]  18 137.04 90 top
R865  -  [R_0402NEW]  294.05 159.85 180 bottom
R866  -  [R_0402NEW]  282.33 171.2 90 bottom
R867  -  [R_0402NEW]  295.96 159.85 180 bottom
R868  -  [R_0402NEW]  294.48 156.16 0 top
R869  -  [R_0402NEW]  282.39 171.46 180 top
R871  -  [R_0402NEW]  282.4 169.33 180 top
R872  -  [R_0402NEW]  62.76 12.02 0 bottom
R873  -  [R_0402NEW]  57.63 8.77 90 bottom
R874  -  [R_0402NEW]  264.13 173.51 270 top
R875  -  [R_0402NEW]  226.84 65.48 0 top
R876  -  [R_0402NEW]  69.44 5.11 270 top
R877  -  [R_0402NEW]  63.55 9.76 180 bottom
R878  -  [R_0402NEW]  63.55 8.88 180 bottom
R879  -  [R_0402NEW]  76.68 12.6 270 top
R880  -  [R_0402NEW]  76.73 10.24 0 top
R894  -  [R_0402NEW]  207.31 197.06 180 bottom
R895  -  [R_0402NEW]  294.18 124.67 180 bottom
R896  -  [R_0402NEW]  68.55 4.73 270 top
R897  -  [R_0402NEW]  296.08 124.67 180 bottom
R898  -  [R_0402NEW]  294.61 121.11 0 top
R899  -  [R_0402NEW]  294.57 129.41 0 top
R900  -  [R_0402NEW]  293.26 109.4 0 top
R901  -  [R_0402NEW]  292.2 125.76 90 top
R903  -  [R_0402NEW]  291.18 125.76 90 top
R904  -  [R_0402NEW]  295.57 141.18 180 top
R905  -  [R_0402NEW]  207.26 194.72 270 top
R906  -  [R_0402NEW]  257.86 93.55 180 top
R908  -  [R_0402NEW]  256.79 91.52 90 bottom
R909  -  [R_0402NEW]  258.92 90.58 270 bottom
R910  -  [R_0402NEW]  257.91 89.67 90 bottom
R911  -  [R_0402NEW]  254.1 91.14 270 top
R912  -  [R_0402NEW]  262.53 91.18 270 top
R913  -  [R_0402NEW]  242.54 92.48 270 top
R914  -  [R_0402NEW]  258.85 93.55 0 top
R916  -  [R_0402NEW]  258.85 94.57 0 top
R917  -  [R_0402NEW]  67.05 25.86 270 bottom
R918  -  [R_0402NEW]  66.16 25.86 270 bottom
R919  -  [R_0402NEW]  238.22 120.48 180 top
R920  -  [R_0402NEW]  240.33 118.44 180 top
R921  -  [R_0402NEW]  242.23 118.82 180 top
R922  -  [R_0402NEW]  237.79 126.32 180 top
R923  -  [R_0402NEW]  235.99 123.9 0 top
R924  -  [R_0402NEW]  230.55 116.67 180 bottom
R925  -  [R_0402NEW]  230.55 117.55 180 bottom
R926  -  [R_0402NEW]  234.67 119.71 180 top
R927  -  [R_0402NEW]  235.55 119.71 0 top
R928  -  [R_0402NEW]  280.82 85.68 0 bottom
R929  -  [R_0402NEW]  277.72 87.76 90 bottom
R930  -  [R_0402NEW]  74.14 4.45 90 top
R931  -  [R_0402NEW]  213.58 49.41 90 top
R934  -  [R_0402NEW]  245.26 51.51 0 top
R936  -  [R_0402NEW]  216.38 52.73 270 top
R937  -  [R_0402NEW]  217.27 50.45 270 top
R938  -  [R_0402NEW]  214.73 49.41 90 top
R940  -  [R_0402NEW]  74.26 66.7 270 bottom
R942  -  [R_0402NEW]  63.47 56.42 270 bottom
R944  -  [R_0402NEW]  281.73 83.9 180 bottom
R962  -  [R_0402NEW]  219.17 116.11 270 top
R963  -  [R_0402NEW]  219.12 114 180 top
R973  -  [R_0402NEW]  240.76 109.88 270 bottom
R974  -  [R_0402NEW]  243.3 108.84 90 bottom
R975  -  [R_0402NEW]  246.73 108.84 90 bottom
R976  -  [R_0402NEW]  247.49 109.38 270 top
R977  -  [R_0402NEW]  244.19 108.84 90 bottom
R979  -  [R_0402NEW]  205.89 196.29 0 top
R980  -  [R_0402NEW]  245.84 106.68 90 top
R981  -  [R_0402NEW]  245.84 109.38 270 top
R982  -  [R_0402NEW]  243.61 109.22 0 top
R983  -  [R_0402NEW]  252.19 109.38 270 top
R985  -  [R_0402NEW]  208.81 167.08 0 top
R986  -  [R_0402NEW]  249.07 107.52 0 top
R987  -  [R_0402NEW]  245.97 100.46 90 top
R988  -  [R_0402NEW]  243.56 103.53 270 top
R989  -  [R_0402NEW]  245.21 105.44 270 top
R990  -  [R_0402NEW]  244.32 105.44 270 top
R991  -  [R_0402NEW]  245.08 100.46 90 top
R992  -  [R_0402NEW]  244.19 100.46 90 top
R993  -  [R_0402NEW]  66.14 81.21 270 top
R994  -  [R_0402NEW]  67.15 76.43 90 top
R995  -  [R_0402NEW]  201.47 128.1 180 top
R996  -  [R_0402NEW]  203.75 129.87 180 top
R997  -  [R_0402NEW]  66.26 76.43 90 top
R998  -  [R_0402NEW]  203.75 128.98 180 top
R999  -  [R_0402NEW]  248.38 108.46 90 top
R1000  -  [R_0402NEW]  245.84 108.84 90 bottom
R1001  -  [R_0402NEW]  300.96 75.47 270 top
R1002  -  [R_0402NEW]  245.66 116.03 180 top
R1003  -  [R_0402NEW]  204.69 129.75 0 bottom
R1004  -  [R_0402NEW]  206.47 129.77 90 bottom
R1006  -  [R_0402NEW]  290.93 72.16 270 top
R1007  -  [R_0402NEW]  290.93 73.94 270 top
R1008  -  [R_0603NEW]  209.46 157.43 0 top
R1009  -  [R_0402NEW]  209.9 155.63 270 top
R1010  -  [R_0402NEW]  210.48 151.59 180 top
R1011  -  [R_0805NEW]  218.03 155.57 90 top
R1012  -  [R_0603NEW]  292.89 171.53 180 top
R1013  -  [R_0402NEW]  291.99 174.2 0 top
R1014  -  [R_0402NEW]  296.01 172.6 90 top
R1015  -  [R_0402NEW]  237.79 128.4 180 top
R1016  -  [R_0402NEW]  68.04 76.43 90 top
R1017  -  [R_0402NEW]  67.91 81.21 270 top
R1018  -  [R_0402NEW]  67.03 81.21 270 top
R1019  -  [R_0402NEW]  230.35 126.77 270 bottom
R1020  -  [R_0402NEW]  233.01 126.77 270 bottom
R1021  -  [R_0402NEW]  264.13 144.11 270 top
R1022  -  [R_0402NEW]  262.14 141.88 90 top
R1023  -  [R_0402NEW]  262.17 144.66 90 top
R1024  -  [R_0402NEW]  273.53 149.23 90 top
R1025  -  [R_0402NEW]  274.42 150.14 270 top
R1026  -  [R_0402NEW]  275.31 150.14 270 top
R2010  -  [R_0402NEW]  44.72 79.45 0 bottom
R2011  -  [R_0402NEW]  56.48 92.84 90 top
R2012  -  [R_0402NEW]  54.71 92.84 90 top
R2013  -  [R_0402NEW]  53.82 92.84 90 top
R2014  -  [R_0402NEW]  55.6 92.84 90 top
R2015  -  [R_0402NEW]  51.28 83.09 270 top
R2017  -  [R_0402NEW]  51.28 96.9 90 top
R2018  -  [R_0402NEW]  52.17 96.9 90 top
R2019  -  [R_0402NEW]  53.06 96.9 90 top
R2020  -  [R_0402NEW]  51.96 99.9 0 top
R2023  -  [R_0402NEW]  58.14 92.84 90 top
R2024  -  [R_0402NEW]  62.5 94.69 0 top
R2025  -  [R_0402NEW]  46.53 92.15 180 top
R2026  -  [R_0402NEW]  52.93 92.84 90 top
R2027  -  [R_0402NEW]  59.58 89.61 0 bottom
R2028  -  [R_0402NEW]  55.16 95.84 180 top
R2029  -  [R_0402NEW]  54.48 81.56 90 top
R2030  -  [R_0402NEW]  27.86 87.96 180 top
R2031  -  [R_0402NEW]  56.03 95.84 0 top
R2032  -  [R_0402NEW]  50.9 91.06 90 top
R2033  -  [R_0402NEW]  26.94 87.07 0 top
R2034  -  [R_0402NEW]  49.17 93.17 0 top
R2035  -  [R_0402NEW]  50.21 88.98 180 top
R2036  -  [R_0402NEW]  49.17 94.06 0 top
R2037  -  [R_0402NEW]  52.04 92.84 90 top
R2038  -  [R_0402NEW]  54.71 92.84 90 bottom
R2039  -  [R_0402NEW]  25.19 87.07 180 top
R2040  -  [R_0402NEW]  25.19 87.96 180 top
R2041  -  [R_0402NEW]  62.5 93.81 0 top
R2042  -  [R_0402NEW]  62.5 92.92 0 top
R2043  -  [R_0402NEW]  44.29 88.42 270 top
R2044  -  [R_0402NEW]  46.07 89.44 270 top
R2045  -  [R_0402NEW]  44.04 91.6 270 top
R2046  -  [R_0402NEW]  48.61 81.05 270 top
R2047  -  [R_0402NEW]  47.72 80.14 90 top
R2048  -  [R_0402NEW]  46.65 90.38 180 top
R2049  -  [R_0402NEW]  50.01 91.06 90 top
R2050  -  [R_0402NEW]  47.16 94.44 180 top
R2051  -  [R_0402NEW]  43.15 90.68 90 top
R2052  -  [R_0402NEW]  43.99 88.73 180 bottom
R2053  -  [R_0402NEW]  54.71 95.89 90 bottom
R2054  -  [R_0402NEW]  55.65 88.34 0 top
R2055  -  [R_0603NEW]  38.26 89.23 0 bottom
R2056  -  [R_0603NEW]  59.34 95.46 180 top
R2057  -  [R_0402NEW]  58.69 92.28 0 bottom
R2058  -  [R_0402NEW]  39.59 70.62 90 top
R2059  -  [R_0402NEW]  38.7 70.62 90 top
R2060  -  [R_0402NEW]  37.18 69.22 90 bottom
R2062  -  [R_0402NEW]  36.16 76.08 90 top
R2063  -  [R_0402NEW]  39.03 76.53 180 bottom
R2064  -  [R_0402NEW]  32.99 68.33 90 bottom
R2065  -  [R_0402NEW]  34.51 81.18 270 bottom
R2066  -  [R_0402NEW]  59.58 91.39 0 bottom
R2067  -  [R_0402NEW]  60.5 90.5 180 bottom
R2068  -  [R_0402NEW]  34.21 72.8 270 top
R2069  -  [R_0402NEW]  29.41 68.41 90 top
R2070  -  [R_0402NEW]  35.07 72.8 270 top
R2071  -  [R_0402NEW]  25.01 69.02 90 bottom
R2072  -  [R_0402NEW]  25.88 68.33 90 bottom
R2075  -  [R_0402NEW]  26.77 68.33 90 bottom
R2076  -  [R_0402NEW]  27.66 68.33 90 bottom
R2077  -  [R_0402NEW]  33.09 79.66 180 top
R2078  -  [R_0402NEW]  33.09 78.77 180 top
R2079  -  [R_0402NEW]  31.21 69.24 270 bottom
R2080  -  [R_0402NEW]  30.3 69.32 270 top
R2082  -  [R_0402NEW]  62.5 91.14 0 top
R2083  -  [R_0402NEW]  55.14 89.61 0 top
R2084  -  [R_0402NEW]  33.12 81.18 270 bottom
R2085  -  [R_0402NEW]  32.15 77.17 0 top
R2086  -  [R_0402NEW]  36.16 74.3 90 top
R2087  -  [R_0402NEW]  26.05 72.34 0 bottom
R2088  -  [R_0402NEW]  26.05 71.45 0 bottom
R2089  -  [R_0402NEW]  29 75.52 180 top
R2090  -  [R_0402NEW]  28.09 74.63 0 top
R2091  -  [R_0402NEW]  31.34 71.91 270 top
R2092  -  [R_0402NEW]  29.81 71.91 270 top
R2093  -  [R_0402NEW]  32.18 81.41 0 top
R2094  -  [R_0402NEW]  58.77 91.21 270 top
R2096  -  [R_0402NEW]  31.29 79.84 180 top
R2097  -  [R_0402NEW]  28.54 80.67 270 top
R2098  -  [R_0402NEW]  37.26 70.18 180 top
R2099  -  [R_0402NEW]  32.18 80.52 0 top
R2101  -  [R_0402NEW]  62.5 92.03 0 top
R2103  -  [R_0402NEW]  35.4 81.18 270 bottom
R2104  -  [R_0402NEW]  73.38 66.7 270 bottom
R2105  -  [R_0402NEW]  62.58 56.42 270 bottom
R2106  -  [R_0402NEW]  277.9 65.23 0 bottom
R2107  -  [R_0402NEW]  286.02 64.98 0 bottom
R2108  -  [R_0402NEW]  70.45 84.1 270 bottom
R2109  -  [R_0402NEW]  69.44 84.1 270 bottom
R2110  -  [R_0402NEW]  277.9 63.2 0 bottom
R2112  -  [R_0402NEW]  286.02 65.87 0 top
R2113  -  [R_0402NEW]  286.02 64.98 0 top
R2115  -  [R_0402NEW]  286.02 63.2 0 top
R2118  -  [R_0402NEW]  60.55 92.97 90 top
R2119  -  [R_0402NEW]  60.5 89.61 180 top
R2120  -  [R_0402NEW]  59.02 93.75 270 top
R2121  -  [R_0402NEW]  46.25 93.55 0 top
R2122  -  [R_0402NEW]  80.21 78.49 90 bottom
R2123  -  [R_0402NEW]  85.64 88.98 180 bottom
R2125  -  [R_0402NEW]  82.27 91.47 270 bottom
R2126  -  [R_0402NEW]  83.15 91.47 270 bottom
R2130  -  [R_0402NEW]  81.12 80.27 90 top
R2131  -  [R_0402NEW]  80.13 79.33 180 top
R2137  -  [R_0603NEW]  84.93 81.8 270 top
R2138  -  [R_0402NEW]  85.64 89.87 180 bottom
R2139  -  [R_0402NEW]  79.6 91.47 270 bottom
R2140  -  [R_0402NEW]  77.24 89.61 0 bottom
R2141  -  [R_0402NEW]  80.49 91.47 270 bottom
R2142  -  [R_0402NEW]  81.38 91.47 270 bottom
R2143  -  [R_0402NEW]  79.29 79.28 270 bottom
R2144  -  [R_0402NEW]  66.01 84.1 270 bottom
R2145  -  [R_0402NEW]  9.37 121.57 270 bottom
R2146  -  [R_0402NEW]  5.68 120.78 90 bottom
R2147  -  [R_0603NEW]  219.04 122.83 270 bottom
R2150  -  [R_0402NEW]  239.29 108.41 0 top
R2151  -  [R_0402NEW]  239.29 109.3 0 top
R2152  -  [R_0402NEW]  242.11 108.41 180 top
R2153  -  [R_0402NEW]  242.11 109.3 180 top
R2154  -  [R_0402NEW]  239.29 107.52 0 top
R2155  -  [R_0402NEW]  241.22 105.87 180 top
R2156  -  [R_0402NEW]  220.11 113.11 0 top
R2157  -  [R_0402NEW]  220.11 114 0 top
R2158  -  [R_0402NEW]  220.11 115.27 0 top
R2159  -  [R_0402NEW]  220.11 116.16 0 top
R2160  -  [R_0402NEW]  220.11 117.05 0 top
R2161  -  [R_0402NEW]  220.11 117.94 0 top
R2162  -  [R_0402NEW]  223.44 113.11 180 top
R2163  -  [R_0402NEW]  223.44 114 180 top
R2164  -  [R_0402NEW]  223.44 115.27 180 top
R2165  -  [R_0402NEW]  223.44 116.16 180 top
R2166  -  [R_0402NEW]  223.44 117.43 180 top
R2167  -  [R_0402NEW]  223.44 118.32 180 top
R2168  -  [R_0402NEW]  281.73 84.79 180 bottom
R2169  -  [R_0402NEW]  226.71 120.07 180 top
R2170  -  [R_0402NEW]  226.71 120.96 180 top
R2171  -  [R_0402NEW]  300.2 72.16 270 top
R2172  -  [R_0402NEW]  301.09 71.25 90 top
R2183  -  [R_0402NEW]  276.37 73.36 0 top
R2184  -  [R_0402NEW]  290.62 174.2 180 top
R2185  -  [R_0402NEW]  285.64 173.31 0 top
R2186  -  [R_0402NEW]  285.64 175.09 0 top
R2187  -  [R_0402NEW]  299.87 76.79 0 top
R2188  -  [R_0402NEW]  304.85 78.18 180 top
R2189  -  [R_0402NEW]  299.87 78.57 0 top
R2193  -  [R_0402NEW]  233.48 169.91 0 top
R2194  -  [R_0402NEW]  292.96 146.31 90 top
R2195  -  [R_0402NEW]  263.19 172.61 90 top
R2196  -  [R_0402NEW]  268.54 169.96 0 top
R2197  -  [R_0402NEW]  233.6 171.58 90 top
R2198  -  [R_0402NEW]  294.91 144.45 0 top
R2199  -  [R_0402NEW]  266.8 170.32 270 top
R2200  -  [R_0402NEW]  261.45 169.91 180 top
R2201  -  [R_0402NEW]  244.24 92.66 0 top
R2202  -  [R_0402NEW]  295.04 109.4 0 top
R2203  -  [R_0402NEW]  293.67 141.18 180 top
R2204  -  [R_0402NEW]  242.54 90.71 270 top
R2205  -  [R_0402NEW]  274.29 91.09 270 top
R2206  -  [R_0402NEW]  293.09 111.26 90 top
R2207  -  [R_0402NEW]  292.99 139.31 270 top
R2208  -  [R_0402NEW]  239.36 120.4 90 top
R2209  -  [R_0402NEW]  279.37 84.71 90 bottom
R2211  -  [R_0402NEW]  248.99 170.96 0 top
R2212  -  [R_0402NEW]  248.13 171.1 270 bottom
R2213  -  [R_0402NEW]  247.11 172.22 90 bottom
R2215  -  [R_0402NEW]  246.97 169.03 180 top
R2216  -  [R_0402NEW]  231.57 172.11 270 top
R2217  -  [R_0402NEW]  248 173.13 270 bottom
R2218  -  [R_0402NEW]  246.97 168.01 180 top
R2219  -  [R_0402NEW]  247.97 169.03 0 top
R2220  -  [R_0402NEW]  282.4 168.31 180 top
R2221  -  [R_0402NEW]  292.07 159.92 270 top
R2222  -  [R_0402NEW]  266.8 172.24 270 top
R2223  -  [R_0402NEW]  291.05 159.92 270 top
R2224  -  [R_0402NEW]  295.17 125.56 0 bottom
R2226  -  [R_0402NEW]  291.18 124.84 270 top
R2227  -  [R_0402NEW]  292.2 124.84 270 top
R2228  -  [R_0402NEW]  274.29 92.99 270 top
R2229  -  [R_0402NEW]  277.9 66.25 0 bottom
R2230  -  [R_0402NEW]  286.02 64.09 0 bottom
R2231  -  [R_0402NEW]  286.02 63.2 0 bottom
R2232  -  [R_0402NEW]  286.02 65.87 0 bottom
R2233  -  [R_0402NEW]  277.9 64.21 0 bottom
R2234  -  [R_0402NEW]  286.02 64.09 0 top
R2236  -  [R_0402NEW]  85.52 81.49 180 bottom
R2237  -  [R_0402NEW]  85.52 80.6 180 bottom
R2238  -  [R_0402NEW]  76.98 81.49 0 bottom
R2239  -  [R_0402NEW]  76.98 80.6 0 bottom
R2240  -  [R_0402NEW]  81 78.36 90 top
R2241  -  [R_0402NEW]  81.88 78.36 90 top
R2242  -  [R_0402NEW]  69.44 83.19 90 top
R2243  -  [R_0402NEW]  70.45 83.19 90 top
R2244  -  [R_0402NEW]  300.53 67.9 180 top
R2251  -  [R_0402NEW]  223.16 117.43 0 bottom
R2252  -  [R_0402NEW]  226.61 117.3 180 bottom
R2253  -  [R_0402NEW]  236.9 117 180 top
R2254  -  [R_0402NEW]  232.13 125.86 90 bottom
R2255  -  [R_0402NEW]  231.24 125.86 90 bottom
R2256  -  [R_0402NEW]  228.57 125.86 90 bottom
R2257  -  [R_0402NEW]  229.46 126.77 270 bottom
R2259  -  [R_0402NEW]  299.94 83.72 270 top
R2260  -  [R_0402NEW]  304.85 82.88 180 top
R2261  -  [R_0402NEW]  294.81 77.04 180 top
R2262  -  [R_0402NEW]  293.34 77.98 90 top
R2263  -  [R_0402NEW]  289.66 74.93 90 top
R2264  -  [R_0402NEW]  206.65 126.44 0 top
R2265  -  [R_0402NEW]  203.55 126.01 270 top
R2266  -  [R_0402NEW]  207.61 124.59 90 top
R2267  -  [R_0402NEW]  287.67 169.88 0 top
R2268  -  [R_0402NEW]  289.66 170.95 90 top
R2269  -  [R_0402NEW]  285.72 170.95 90 top
R2270  -  [R_0603NEW]  301.4 81.11 180 top
R2271  -  [R_0402NEW]  206.39 196.04 0 bottom
R2272  -  [R_0402NEW]  13.56 130.43 180 top
R2273  -  [R_0402NEW]  13.56 131.32 180 top
R2274  -  [R_0402NEW]  13.56 128.65 180 top
R2275  -  [R_0402NEW]  13.56 129.54 180 top
R2276  -  [R_0402NEW]  13.56 126.88 180 top
R2277  -  [R_0402NEW]  13.56 127.77 180 top
R2278  -  [R_0402NEW]  13.56 132.21 180 top
R2279  -  [R_0402NEW]  13.56 133.1 180 top
R2280  -  [R_0402NEW]  77.13 76.03 180 top
R2281  -  [R_0402NEW]  68.04 67.69 90 bottom
R2282  -  [R_0402NEW]  61.44 93.6 90 top
R2283  -  [R_0402NEW]  58.19 93.17 0 bottom
R2284  -  [R_0402NEW]  58.19 94.06 0 bottom
R2286  -  [R_0402NEW]  246.93 50.63 180 top
R2287  -  [R_0402NEW]  39.54 70.82 180 bottom
R2288  -  [R_0402NEW]  39.54 71.71 180 bottom
R2289  -  [R_0402NEW]  39.54 72.6 180 bottom
R2290  -  [R_0402NEW]  39.54 69.27 180 bottom
R2291  -  [R_0402]  191.61 150.37 90 top
R2292  -  [R_0402]  186.58 149.05 0 top
R2294  -  [R_0402NEW]  234.87 116.97 180 top
R2295  -  [R_0402NEW]  234.87 117.86 180 top
R2296  -  [R_0402NEW]  225.01 119.41 270 bottom
R2297  -  [R_0402NEW]  225.9 119.41 270 bottom
R2298  -  [R_0402NEW]  241.14 117.2 270 top
R2299  -  [R_0402NEW]  242.84 117.68 0 top
R2300  -  [R_0402NEW]  206.8 197.18 180 top
R2302  -  [R_0402NEW]  205.48 193.91 0 top
R2304  -  [R_0402NEW]  209.72 166.2 180 top
R2305  -  [R_0402NEW]  204.9 196.04 180 top
R2306  -  [R_0402NEW]  211.09 199.72 0 top
R2307  -  [R_0402NEW]  207.03 162.77 0 top
R2311  -  [R_0402]  11.58 146.89 0 top
R2312  -  [R_0402NEW]  12.49 146 180 top
R2313  -  [R_0402NEW]  16.3 144.86 180 top
R2314  -  [R_0402NEW]  68.42 83.19 90 bottom
R2315  -  [R_0402NEW]  74.26 87.76 90 bottom
R2327  -  [R_0402NEW]  84.73 73.49 0 top
R2328  -  [R_0402NEW]  87.42 73.49 180 top
R2330  -  [R_0805NEW]  216.25 155.57 90 top
R2331  -  [R_0805NEW]  214.47 155.57 90 top
R2332  -  [R_0805NEW]  212.69 155.57 90 top
R2333  -  [R_0402]  82.57 76.15 0 top
R2334  -  [R_0402NEW]  299.56 66.04 90 top
R2335  -  [R_0805NEW]  296.77 164.84 90 top
R2336  -  [R_0805NEW]  294.86 164.84 90 top
R2337  -  [R_0805NEW]  292.96 164.84 90 top
R2338  -  [R_0805NEW]  291.05 164.84 90 top
R2339  -  [R_0402NEW]  85.9 79.71 180 bottom
R2340  -  [R_0402NEW]  85.06 77.85 90 bottom
R2341  -  [R_0402NEW]  62.61 5.57 270 bottom
R2342  -  [R_0402NEW]  63.49 5.57 270 bottom
RP1  -  [RP_0804_8P4R]  223.43 62.07 180 top
RP2  -  [RP_0804_8P4R]  235.41 46.75 90 bottom
RP4  -  [RP_0804_8P4R]  32.67 40.48 0 bottom
SWPWR2  -  [SW-SKSHAAE010-4P]  106.01 1.98 180 bottom
TL1  -  [TRF24P-1-15_1X7_5-4MM]  26.77 96.98 270 bottom
TP1  -  [TPC12]  193.01 155.15 180 bottom
TP2  -  [TPC12]  153 151.97 0 top
TP3  -  [TPC12]  146.65 152.1 180 bottom
TP4  -  [TPC12]  152.12 153.11 0 top
TP5  -  [TPC12]  193.77 129.75 180 bottom
TP6  -  [TPC12]  150.34 154.13 0 top
TP7  -  [TPC12]  195.42 131.27 180 bottom
TP8  -  [TPC12]  152.37 154.38 0 top
TP9  -  [TPC12]  193.26 131.65 180 bottom
TP10  -  [TPC12]  191.87 130.76 180 bottom
TP11  -  [TPC12]  147.16 129.49 180 bottom
TP12  -  [TPC12]  146.78 131.02 180 bottom
TP13  -  [TPC12]  154.02 139.65 0 top
TP14  -  [TPC12]  154.73 140.36 0 top
TP15  -  [TPC40]  219.55 53.17 180 bottom
TP16  -  [TPC40]  219.55 56.34 180 bottom
TP17  -  [TPC40]  219.55 54.82 180 bottom
TP18  -  [TPC40]  219.55 60.15 180 bottom
TP19  -  [TPC40]  219.55 58.45 180 bottom
TP20  -  [TPC12]  154.5 141.48 0 top
TP21  -  [TPC12]  146.02 156.92 180 bottom
TP22  -  [TPC12]  154.15 140.16 0 top
TP23  -  [TPC12]  148.94 147.78 0 top
TP24  -  [TPC12]  141.7 141.68 180 bottom
TP25  -  [TPC12]  154.15 148.57 0 top
TP26  -  [TPC12]  149.32 150.45 0 top
TP27  -  [TPC12]  155.85 146.21 0 top
TP28  -  [TPC12]  151.86 147.53 0 top
TP29  -  [TPC12]  152.24 150.83 0 top
TP30  -  [TPC12]  144.88 145.49 180 bottom
TP31  -  [TPC12]  141.7 139.78 180 bottom
TP32  -  [TPC12]  144.88 143.59 180 bottom
TP33  -  [TPC12]  144.88 141.68 180 bottom
TP34  -  [TPC12]  149.07 146.38 0 top
TP35  -  [TPC12]  153.51 153.24 0 top
TP36  -  [TPC12]  147.04 146.26 180 bottom
TP37  -  [TPC12]  154.15 151.97 0 top
TP38  -  [TPC12]  147.04 145.75 180 bottom
TP39  -  [TPC12]  147.04 147.27 180 bottom
TP40  -  [TPC12]  146.53 137.37 180 bottom
TP41  -  [TPC12]  141.7 137.87 180 bottom
TP42  -  [TPC12]  144.88 139.78 180 bottom
TP43  -  [TPC12]  143.61 136.6 180 bottom
TP44  -  [TPC12]  141.7 143.59 180 bottom
TP45  -  [TPC12]  151.48 146.26 0 top
TP46  -  [TPC12]  147.04 146.76 180 bottom
TP47  -  [TPC12]  141.7 145.49 180 bottom
TP48  -  [TPC12]  146.02 148.67 180 bottom
TP49  -  [TPC12]  146.65 149.94 180 bottom
TP50  -  [TPC12]  149.58 153.24 0 top
TP51  -  [TPC12]  253.46 53.67 0 top
TP52  -  [TPC12]  147.54 151.08 180 bottom
TP54  -  [TPC12]  253.79 68.86 180 bottom
TP55  -  [TPC12]  253.79 69.6 180 bottom
TP56  -  [TPC12]  148.94 149.18 0 top
TP57  -  [TPC12]  253.46 52.15 0 top
TP58  -  [TPC12]  26.89 56.85 270 top
TP59  -  [TPC12]  233.01 45.04 180 bottom
TP60  -  [TPC12]  212.57 51.01 0 top
TP61  -  [TPC12]  250.29 54.05 0 top
TP62  -  [TPC12]  147.42 148.67 180 bottom
TP63  -  [TPC12]  194.41 56.59 180 bottom
TP64  -  [TPC12]  191.99 57.99 180 bottom
TP71  -  [TPC12]  241.4 55.32 0 top
TP72  -  [TPC12]  239.34 49.43 180 bottom
TP73  -  [TPC12]  239.31 48.92 180 bottom
TP74  -  [TPC12]  242.41 53.04 0 top
TP76  -  [TPC12]  236.32 57.1 0 top
TP77  -  [TPC40]  307 59.5 180 bottom
TP78  -  [TPC40]  305 59.5 180 bottom
TP79  -  [TPC12]  250.03 56.09 0 top
TP90  -  [TPC12]  46.71 58.25 270 top
TP91  -  [TPC12]  288.39 39.32 270 top
TP92  -  [TPC12]  288.39 39.96 270 top
TP93  -  [TPC12]  282.8 35.51 270 top
TP94  -  [TPC12]  282.8 34.88 270 top
TP95  -  [TPC12]  283.1 33.35 270 top
TP96  -  [TPC12]  65.63 85.8 270 bottom
TP97  -  [TPC12]  71.72 76.66 270 bottom
TP99  -  [TPC12]  96.06 43.08 0 top
TP100  -  [TPC12]  100.88 67.67 0 top
TP102  -  [TPC12]  164.89 63.78 180 bottom
TP103  -  [TPC12]  282.93 36.4 0 top
TP113  -  [TPC12]  234.28 128.98 90 bottom
TP114  -  [TPC12]  229.46 127.71 90 bottom
TP115  -  [TPC12]  147.29 153.5 180 bottom
TP116  -  [TPC12]  232.25 127.71 90 bottom
TP117  -  [TPC12]  234.03 127.11 90 bottom
TP118  -  [TPC12]  262.22 143.59 90 top
TP122  -  [TPC12]  223.24 67.14 180 bottom
TP124  -  [TPC12]  150.97 138.51 270 top
TP126  -  [TPC12]  165.83 76.91 270 bottom
TP127  -  [TPC12]  164.56 89.61 270 top
TP128  -  [TPC12]  164.43 76.91 270 top
TP130  -  [TPC12]  62.45 10.75 270 bottom
TP132  -  [TPC12]  56.87 43.51 180 bottom
TP133  -  [TPC12]  56.87 44.4 90 bottom
TP134  -  [TPC12]  66.64 9.99 0 top
TP135  -  [TPC12]  66.03 10.49 0 top
TP136  -  [TPC12]  66.64 10.49 0 top
TP137  -  [TPC12]  70.2 5.41 0 top
TP138  -  [TPC12]  53.06 38.81 180 bottom
TP139  -  [TPC12]  70.2 4.78 0 top
TP142  -  [TPC12]  73.25 5.34 0 top
TP143  -  [TPC12]  69.44 21.29 0 top
TP144  -  [TPC12]  56.1 44.4 90 bottom
TP145  -  [TPC40]  69.95 24.64 180 bottom
TP146  -  [TPC40]  59.79 8.72 180 bottom
