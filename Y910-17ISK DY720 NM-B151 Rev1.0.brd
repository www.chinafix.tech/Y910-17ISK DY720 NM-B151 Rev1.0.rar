# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
DDR-80888-100-260P
  round 1.6 hole 1.6 unplated: (-34.4,0)
  round 1.092 hole 1.092 unplated: (34.4,0)
  rect 0.305x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
DFN3X3A_8L_EP1_P
  rect 0.356x0.508 smd: 1(-0.975,-1.4) 2(-0.325,-1.4) 3(0.325,-1.4) 4(0.975,-1.4)
  custom 0.57x0.57 smd: 5(0,0)
DFN6P-0_4-1_6X1-0_6MM
  rect 0.203x0.991 smd: 1(-0.6,-0.6) 2(-0.2,-0.6) 5(-0.2,0.6) 6(-0.6,0.6)
  rect 0.61x0.991 smd: 3(0.4,-0.6) 4(0.4,0.6)
DFN10P-0_5-3X3-0_8MM
  rect 0.305x0.838 smd: 1(-1,-1.475) 2(-0.5,-1.475) 3(0,-1.475) 4(0.5,-1.475) 5(1,-1.475) 6(1,1.475) 7(0.5,1.475) 8(0,1.475) 9(-0.5,1.475) 10(-1,1.475)
  rect 2.489x1.499 smd: 11(0,0)
DMG1012T-7_SOT523-3
  rect 0.406x0.61 smd: 1(0,0.65) 2(-0.5,-0.65) 3(0.5,-0.65)
DOCK-12502HB012M200ZL-12P-L
  rect 0.787x1.295 smd: 1(-6.875,2.85) 2(-5.625,2.85) 3(-4.375,2.85) 4(-3.125,2.85) 5(-1.875,2.85) 6(-0.625,2.85) 7(0.625,2.85) 8(1.875,2.85) 9(3.125,2.85) 10(4.375,2.85) 11(5.625,2.85) 12(6.875,2.85)
  oval 1.041x1.651 hole 0.66x1.245: 13(8.625,0) 14(8.625,-3.475) 15(-8.625,0) 16(-8.625,-3.475)
DP-DRA45-00-00-20P-R
  round 1.397 hole 1.397 unplated: (0,-0.9)
  rect 0.279x2.388 smd: 1(5.5,9.38) 2(5,9.38) 3(4.5,9.38) 4(4,9.38) 5(3.5,9.38) 6(3,9.38) 7(2.5,9.38) 8(2,9.38) 9(1.5,9.38) 10(1,9.38) 11(0.5,9.38) 12(0,9.38) 13(-0.5,9.38) 14(-1,9.38) 15(-1.5,9.38) 16(-2,9.38) 17(-2.5,9.38) 18(-3,9.38) 19(-3.5,9.38) 20(-4,9.38)
  oval 1.194x2.794 hole 0.61x2.21: 21(8.25,6.78) 22(-8.25,6.78)
  oval 1.194x2.311 hole 0.61x1.702: 23(8.25,0) 24(-8.25,0)
ESD101_0201-2
  rect 0.203x0.33 smd: 1(-0.19,0) 2(0.19,0)
F3_2X1_6-2_95
  rect 1.448x1.803 smd: 1(-1.475,0) 2(1.475,0)
FC1AF061-1201H-6P
  rect 0.61x1.295 smd: 1(-2.5,3.05) 2(-1.5,3.05) 3(-0.5,3.05) 4(0.5,3.05) 5(1.5,3.05) 6(2.5,3.05)
  rect 2.159x2.21 smd: 7(-5.325,0) 8(5.325,0)
FDMS7678_POWER56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,2.67)
HDMI-2HE3Y36-000111F-19P
  round 1.092 hole 1.092 unplated: (-2.5,0) (2.5,0)
  rect 0.279x2.591 smd: 1(4.5,2.4) 2(4,2.4) 3(3.5,2.4) 4(3,2.4) 5(2.5,2.4) 6(2,2.4) 7(1.5,2.4) 8(1,2.4) 9(0.5,2.4) 10(0,2.4) 11(-0.5,2.4) 12(-1,2.4) 13(-1.5,2.4) 14(-2,2.4) 15(-2.5,2.4) 16(-3,2.4) 17(-3.5,2.4) 18(-4,2.4) 19(-4.5,2.4)
  oval 1.499x3.404 hole 0.889x2.794: 20(7.25,1.65) 21(-7.25,1.65)
  oval 1.499x2.692 hole 0.889x2.108: 22(7.25,-4.3) 23(-7.25,-4.3)
HOLE197_118
  round 5.004 hole 2.997: 1(0,0)
HOLE217_98
  round 5.512 hole 2.489: 1(0,0)
HOLE240_126
  round 6.096 hole 3.2: 1(0,0)
HOLE276_98
  round 5.512 hole 2.489: 1(0,0)
HOLE335_118
  round 8.509 hole 2.997: 1(0,0)
HOLE394_118
  round 10.008 hole 2.997: 1(0,0)
HOLEOB297X197_197X118
  oval 7.544x5.004 hole 5.004x2.997: 1(0,0)
HOLET275B197_166
  round 6.985 hole 4.216: 1(0,0)
ISL95520HRTZ_TQFN32_4X4
  oval 0.305x0.711 smd: 1(0,0) 2(-0.4,0) 3(-0.8,0) 4(-1.2,0) 5(-1.6,0) 6(-2,0) 7(-2.4,0) 8(-2.8,0) 17(-2.8,-3.8) 18(-2.4,-3.8) 19(-2,-3.8) 20(-1.6,-3.8) 21(-1.2,-3.8) 22(-0.8,-3.8) 23(-0.4,-3.8) 24(0,-3.8)
  oval 0.711x0.305 smd: 9(-3.3,-0.5) 10(-3.3,-0.9) 11(-3.3,-1.3) 12(-3.3,-1.7) 13(-3.3,-2.1) 14(-3.3,-2.5) 15(-3.3,-2.9) 16(-3.3,-3.3) 25(0.5,-3.3) 26(0.5,-2.9) 27(0.5,-2.5) 28(0.5,-2.1) 29(0.5,-1.7) 30(0.5,-1.3) 31(0.5,-0.9) 32(0.5,-0.5)
  rect 2.642x2.642 smd: 33(-1.4,-1.9)
IT8586VG-AX_VFBGA_128P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) A12(5.501,0) A13(6.002,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) B12(5.501,-0.5) B13(6.002,-0.5) C1(0,-1) C2(0.5,-1) C12(5.501,-1) C13(6.002,-1) D1(0,-1.5) D2(0.5,-1.5) D4(1.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D9(4.001,-1.5) D10(4.501,-1.5) D12(5.501,-1.5) D13(6.002,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E9(4.001,-2.001) E10(4.501,-2.001) E12(5.501,-2.001) E13(6.002,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F9(4.001,-2.501) F10(4.501,-2.501) F12(5.501,-2.501) F13(6.002,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G9(4.001,-3.001) G10(4.501,-3.001) G12(5.501,-3.001) G13(6.002,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H9(4.001,-3.501) H10(4.501,-3.501) H12(5.501,-3.501) H13(6.002,-3.501) J1(0,-4.001) J2(0.5,-4.001) J4(1.5,-4.001) J5(2.001,-4.001) J6(2.501,-4.001) J7(3.001,-4.001) J8(3.501,-4.001) J9(4.001,-4.001) J10(4.501,-4.001) J12(5.501,-4.001) J13(6.002,-4.001) K1(0,-4.501) K2(0.5,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K12(5.501,-4.501) K13(6.002,-4.501) L1(0,-5.001) L2(0.5,-5.001) L12(5.501,-5.001) L13(6.002,-5.001) M1(0,-5.501) M2(0.5,-5.501) M3(1,-5.501) M4(1.5,-5.501) M5(2.001,-5.501) M6(2.501,-5.501) M7(3.001,-5.501) M8(3.501,-5.501) M9(4.001,-5.501) M10(4.501,-5.501) M11(5.001,-5.501) M12(5.501,-5.501) M13(6.002,-5.501) N1(0,-6.002) N2(0.5,-6.002) N3(1,-6.002) N4(1.5,-6.002) N5(2.001,-6.002) N6(2.501,-6.002) N7(3.001,-6.002) N8(3.501,-6.002) N9(4.001,-6.002) N10(4.501,-6.002) N11(5.001,-6.002) N12(5.501,-6.002) N13(6.002,-6.002)
J_0202
  rect 1.016x0.508 smd: 1(0,0) 2(0.889,0)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X79_7
  rect 0.483x2.007 smd: 1(-0.33,0) 2(0.33,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
KRYO_046299626120846_26P-T
  rect 0.305x0.813 smd: 1(-6.25,1.25) 2(-5.75,1.25) 3(-5.25,1.25) 4(-4.75,1.25) 5(-4.25,1.25) 6(-3.75,1.25) 7(-3.25,1.25) 8(-2.75,1.25) 9(-2.25,1.25) 10(-1.75,1.25) 11(-1.25,1.25) 12(-0.75,1.25) 13(-0.25,1.25) 14(0.25,1.25) 15(0.75,1.25) 16(1.25,1.25) 17(1.75,1.25) 18(2.25,1.25) 19(2.75,1.25) 20(3.25,1.25) 21(3.75,1.25) 22(4.25,1.25) 23(4.75,1.25) 24(5.25,1.25) 25(5.75,1.25) 26(6.25,1.25)
  rect 0.406x0.813 smd: 27(-7.75,-1.25) 28(7.75,-1.25)
KRYO_046809605020846_5P-T
  rect 0.305x0.813 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0)
  rect 0.584x1.219 smd: 6(-1.087,-2.7) 7(3.088,-2.7)
L1_6X0_8
  rect 0.61x0.787 smd: 1(-0.7,0) 2(0.7,0)
L1_6X0_8-T0_8MM
  rect 0.61x0.61 smd: 1(-0.711,0) 2(0.711,0)
L4X4-1_2H
  rect 1.194x3.708 smd: 1(-1.4,0) 2(1.4,0)
L11_15X10-3_8H
  rect 4.089x4.089 smd: 1(-4.75,0) 2(4.75,0)
LED-FSL-2408035WA-3P
  rect 0.356x0.61 smd: 1(1.125,-0.35) 3(-1.125,-0.35)
  rect 0.508x0.61 smd: 2(0,-0.35)
LP2301ALT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MAGLA_SPS-04AEN2R2M-M1_2P
  rect 1.651x2.311 smd: 1(0,0) 2(3.3,0)
MINIPCI-80152-001-75P
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
MMBT3904WH_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
MMBT3906_PNP_SOT23-3
  rect 0.813x0.914 smd: 1(-0.95,-1) 2(0.95,-1) 3(0,1)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15BD221SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX121SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_DLW21HN900HQ2L_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_LQM18PN1R0M_2P
  rect 0.61x0.711 smd: 1(-0.65,0) 2(0.65,0)
NCP81382MNTXG_QFN39-31_6X4
  oval 0.711x0.305 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2)
  oval 0.305x0.711 smd: 7(0.65,-2.85) 8(1.05,-2.85) 9(1.45,-2.85) 10(1.85,-2.85) 11(2.25,-2.85) 12(2.65,-2.85) 13(3.05,-2.85) 14(3.45,-2.85) 15(3.85,-2.85) 16(4.25,-2.85) 17(4.65,-2.85) 18(5.05,-2.85) 20(5.05,0.85) 21(4.65,0.85) 22(4.25,0.85) 23(3.85,0.85) 24(3.45,0.85) 25(3.05,0.85) 26(2.65,0.85) 27(2.25,0.85) 28(1.85,0.85) 29(1.45,0.85) 30(1.05,0.85) 31(0.65,0.85)
  custom 0.665x0.665 smd: 19(3.24,-1.04)
NGFF-NFSM0-S6710-TP50-75P-KM
  round 1.092 hole 1.092 unplated: (-10,0)
  round 1.6 hole 1.6 unplated: (10,0)
  rect 0.305x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
QFN17P-0_65-4X4-1MM
  rect 0.381x1.143 smd: 1(-0.975,-2.025) 2(-0.325,-2.025) 3(0.325,-2.025) 4(0.975,-2.025) 9(0.975,2.025) 10(0.325,2.025) 11(-0.325,2.025) 12(-0.975,2.025)
  rect 1.143x0.381 smd: 5(2.025,-0.975) 6(2.025,-0.325) 7(2.025,0.325) 8(2.025,0.975) 13(-2.025,0.975) 14(-2.025,0.325) 15(-2.025,-0.325) 16(-2.025,-0.975)
  rect 2.108x2.108 smd: 17(0,0)
QFN20-0_4-3X3X1MM
  oval 0.889x0.254 smd: 1(-1.5,0.8) 2(-1.5,0.4) 3(-1.5,0) 4(-1.5,-0.4) 5(-1.5,-0.8) 11(1.5,-0.8) 12(1.5,-0.4) 13(1.5,0) 14(1.5,0.4) 15(1.5,0.8)
  oval 0.254x0.889 smd: 6(-0.8,-1.5) 7(-0.4,-1.5) 8(0,-1.5) 9(0.4,-1.5) 10(0.8,-1.5) 16(0.8,1.5) 17(0.4,1.5) 18(0,1.5) 19(-0.4,1.5) 20(-0.8,1.5)
  rect 1.778x1.778 smd: 21(0,0)
QFN20P-0_4-3X2-0_6MM
  rect 0.203x0.914 smd: 1(-1.2,-1.137) 2(-0.8,-1.137) 6(0.8,-1.137) 7(1.2,-1.137) 11(1.2,1.137) 12(0.8,1.137) 16(-0.8,1.137) 17(-1.2,1.137)
  rect 0.203x1.397 smd: 3(-0.4,-0.9)
  rect 0.203x1.194 smd: 4(0,-1) 5(0.4,-1) 13(0.4,1) 14(0,1) 15(-0.4,1)
  rect 1.194x0.203 smd: 8(1.5,-0.4) 9(1.5,0) 10(1.5,0.4) 18(-1.5,0.4) 19(-1.5,0) 20(-1.5,-0.4)
QFN21P-0_5-4X4-0_75MM
  oval 0.305x0.94 smd: 1(-1,-1.925) 2(-0.5,-1.925) 3(0,-1.925) 4(0.5,-1.925) 5(1,-1.925) 11(1,1.925) 12(0.5,1.925) 13(0,1.925) 14(-0.5,1.925) 15(-1,1.925)
  oval 0.94x0.305 smd: 6(1.925,-1) 7(1.925,-0.5) 8(1.925,0) 9(1.925,0.5) 10(1.925,1) 16(-1.925,1) 17(-1.925,0.5) 18(-1.925,0) 19(-1.925,-0.5) 20(-1.925,-1)
  rect 2.108x2.108 smd: 21(0,0)
QFN36-4X7-5-37P
  rect 0.305x1.041 smd: 1(-1.25,-3.555) 2(-0.75,-3.555) 3(-0.25,-3.555) 4(0.25,-3.555) 5(0.75,-3.555) 6(1.25,-3.555) 19(1.25,3.555) 20(0.75,3.555) 21(0.25,3.555) 22(-0.25,3.555) 23(-0.75,3.555) 24(-1.25,3.555)
  rect 1.041x0.305 smd: 7(2.055,-2.75) 8(2.055,-2.25) 9(2.055,-1.75) 10(2.055,-1.25) 11(2.055,-0.75) 12(2.055,-0.25) 13(2.055,0.25) 14(2.055,0.75) 15(2.055,1.25) 16(2.055,1.75) 17(2.055,2.25) 18(2.055,2.75) 25(-2.055,2.75) 26(-2.055,2.25) 27(-2.055,1.75) 28(-2.055,1.25) 29(-2.055,0.75) 30(-2.055,0.25) 31(-2.055,-0.25) 32(-2.055,-0.75) 33(-2.055,-1.25) 34(-2.055,-1.75) 35(-2.055,-2.25) 36(-2.055,-2.75)
  rect 2.489x5.41 smd: 37(0,0)
QFN40-0_4-5X5X1MM
  oval 0.254x1.016 smd: 1(-1.8,-2.475) 2(-1.4,-2.475) 3(-1,-2.475) 4(-0.6,-2.475) 5(-0.2,-2.475) 6(0.2,-2.475) 7(0.6,-2.475) 8(1,-2.475) 9(1.4,-2.475) 10(1.8,-2.475) 21(1.8,2.475) 22(1.4,2.475) 23(1,2.475) 24(0.6,2.475) 25(0.2,2.475) 26(-0.2,2.475) 27(-0.6,2.475) 28(-1,2.475) 29(-1.4,2.475) 30(-1.8,2.475)
  oval 1.016x0.254 smd: 11(2.475,-1.8) 12(2.475,-1.4) 13(2.475,-1) 14(2.475,-0.6) 15(2.475,-0.2) 16(2.475,0.2) 17(2.475,0.6) 18(2.475,1) 19(2.475,1.4) 20(2.475,1.8) 31(-2.475,1.8) 32(-2.475,1.4) 33(-2.475,1) 34(-2.475,0.6) 35(-2.475,0.2) 36(-2.475,-0.2) 37(-2.475,-0.6) 38(-2.475,-1) 39(-2.475,-1.4) 40(-2.475,-1.8)
  rect 3.556x3.556 smd: 41(0,0)
QFN41P-0_4-5X5X0_9MM
  oval 0.203x0.965 smd: 1(-1.8,-2.62) 2(-1.4,-2.62) 3(-1,-2.62) 4(-0.6,-2.62) 5(-0.2,-2.62) 6(0.2,-2.62) 7(0.6,-2.62) 8(1,-2.62) 9(1.4,-2.62) 10(1.8,-2.62) 21(1.8,2.62) 22(1.4,2.62) 23(1,2.62) 24(0.6,2.62) 25(0.2,2.62) 26(-0.2,2.62) 27(-0.6,2.62) 28(-1,2.62) 29(-1.4,2.62) 30(-1.8,2.62)
  oval 0.965x0.203 smd: 11(2.62,-1.8) 12(2.62,-1.4) 13(2.62,-1) 14(2.62,-0.6) 15(2.62,-0.2) 16(2.62,0.2) 17(2.62,0.6) 18(2.62,1) 19(2.62,1.4) 20(2.62,1.8) 31(-2.62,1.8) 32(-2.62,1.4) 33(-2.62,1) 34(-2.62,0.6) 35(-2.62,0.2) 36(-2.62,-0.2) 37(-2.62,-0.6) 38(-2.62,-1) 39(-2.62,-1.4) 40(-2.62,-1.8)
  rect 3.505x3.505 smd: 41(0,0)
QFN48P-0_5-7X7X0_85MM
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 25(5.5,6.95) 26(5,6.95) 27(4.5,6.95) 28(4,6.95) 29(3.5,6.95) 30(3,6.95) 31(2.5,6.95) 32(2,6.95) 33(1.5,6.95) 34(1,6.95) 35(0.5,6.95) 36(0,6.95)
  oval 1.041x0.254 smd: 13(6.225,0.725) 14(6.225,1.225) 15(6.225,1.725) 16(6.225,2.225) 17(6.225,2.725) 18(6.225,3.225) 19(6.225,3.725) 20(6.225,4.225) 21(6.225,4.725) 22(6.225,5.225) 23(6.225,5.725) 24(6.225,6.225) 37(-0.725,6.225) 38(-0.725,5.725) 39(-0.725,5.225) 40(-0.725,4.725) 41(-0.725,4.225) 42(-0.725,3.725) 43(-0.725,3.225) 44(-0.725,2.725) 45(-0.725,2.225) 46(-0.725,1.725) 47(-0.725,1.225) 48(-0.725,0.725)
  rect 3.708x3.708 smd: 49(2.75,3.475)
QFN52-0_4-6X6X1MM
  oval 0.203x0.991 smd: 1(-2.4,-3.1) 2(-2,-3.1) 3(-1.6,-3.1) 4(-1.2,-3.1) 5(-0.8,-3.1) 6(-0.4,-3.1) 7(0,-3.1) 8(0.4,-3.1) 9(0.8,-3.1) 10(1.2,-3.1) 11(1.6,-3.1) 12(2,-3.1) 13(2.4,-3.1) 27(2.4,3.1) 28(2,3.1) 29(1.6,3.1) 30(1.2,3.1) 31(0.8,3.1) 32(0.4,3.1) 33(0,3.1) 34(-0.4,3.1) 35(-0.8,3.1) 36(-1.2,3.1) 37(-1.6,3.1) 38(-2,3.1) 39(-2.4,3.1)
  oval 0.991x0.203 smd: 14(3.1,-2.4) 15(3.1,-2) 16(3.1,-1.6) 17(3.1,-1.2) 18(3.1,-0.8) 19(3.1,-0.4) 20(3.1,0) 21(3.1,0.4) 22(3.1,0.8) 23(3.1,1.2) 24(3.1,1.6) 25(3.1,2) 26(3.1,2.4) 40(-3.1,2.4) 41(-3.1,2) 42(-3.1,1.6) 43(-3.1,1.2) 44(-3.1,0.8) 45(-3.1,0.4) 46(-3.1,0) 47(-3.1,-0.4) 48(-3.1,-0.8) 49(-3.1,-1.2) 50(-3.1,-1.6) 51(-3.1,-2) 52(-3.1,-2.4)
  rect 4.775x4.775 smd: 53(0,0)
R0402_SHORT
  rect 0.737x0.559 smd: 1(0,0) 2(0.914,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0402NEW
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0603NEW
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0805NEW
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206NEW
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1632NEW
  rect 4.064x1.016 smd: 1(0,0.902) 2(0,-0.902)
R_1632NEW_4P
  rect 1.016x3.048 smd: 1(-0.902,-0.584) 2(0.902,-0.584)
  rect 1.016x1.016 smd: 3(0.902,1.6) 4(-0.902,1.6)
RB751V-40_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
RJ45-JM3611-RS800003-7H-8P
  round 1.219 hole 0.914: 1(-3.57,8.4) 2(-2.55,9.5) 3(-1.53,8.4) 4(-0.51,9.5) 5(0.51,8.4) 6(1.53,9.5) 7(2.55,8.4) 8(3.57,9.5)
  oval 1.016x2.946 hole 0.711x2.642: 9(9.325,0) 10(-9.325,0)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8231AGQW_WQFN20_3X3
  oval 0.914x0.305 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 11(2.95,-1.6) 12(2.95,-1.2) 13(2.95,-0.8) 14(2.95,-0.4) 15(2.95,0)
  oval 0.305x0.94 smd: 6(0.675,-2.275) 7(1.075,-2.275) 8(1.475,-2.275) 9(1.875,-2.275) 10(2.275,-2.275) 16(2.275,0.675) 17(1.875,0.675) 18(1.475,0.675) 19(1.075,0.675) 20(0.675,0.675)
  rect 1.702x1.702 smd: 21(1.475,-0.8)
SC59-1_9-3X1_6-1_4MM
  rect 0.813x0.991 smd: 1(-0.95,-1.2) 2(0.95,-1.2) 3(0,1.2)
SDM10U45LP-7_DFN1006-2-2
  rect 0.406x0.711 smd: 1(0,0) 2(0.7,0)
SLG5NT1533VTR_STDFN8-6_1X1P6
  rect 0.889x0.279 smd: 1(0,0) 2(0,-0.4) 5(1,-0.4) 6(1,0)
  rect 0.787x0.584 smd: 3(0,-1) 4(1,-1)
SLG59M301VTR_FC-TDFN8-6_1P5X2
  rect 0.254x0.61 smd: 1(0,0) 2(0.5,0) 5(0.5,1.2) 6(0,1.2)
  rect 0.762x0.762 smd: 3(1.25,0.083) 4(1.25,1.118)
SON8-5X6-1_27-8P
  rect 1.93x0.838 smd: 1(-1.27,-2.695)
  rect 0.66x0.838 smd: 3(0.635,-2.695) 4(1.905,-2.695) 5(1.905,2.695) 6(0.635,2.695) 7(-0.635,2.695) 8(-1.905,2.695)
  custom 0.87x0.87 smd: 9(0,0)
SOP8-1_27-5X4X1_75MM
  rect 1.778x0.508 smd: 1(-2.6,1.905) 2(-2.6,0.635) 3(-2.6,-0.635) 4(-2.6,-1.905) 5(2.6,-1.905) 6(2.6,-0.635) 7(2.6,0.635) 8(2.6,1.905)
SOT23-8P-0_65-2_9X1_6-1_45MM
  rect 0.457x1.219 smd: 1(-0.975,-1.31) 2(-0.325,-1.31) 3(0.325,-1.31) 4(0.975,-1.31) 5(0.975,1.31) 6(0.325,1.31) 7(-0.325,1.31) 8(-0.975,1.31)
SOT323-3P-1_3-2_15X1_3-1MM
  rect 0.889x0.711 smd: 1(0.95,0.65) 2(0.95,-0.65) 3(-0.95,0)
SOT353-0_65-1_35X2_25X1_1MM
  rect 0.305x0.711 smd: 1(-0.65,-0.775) 2(0,-0.775) 3(0.65,-0.775) 4(0.65,0.775) 5(-0.65,0.775)
SOT-2_8-1_9-3P
  rect 0.787x0.991 smd: 1(-0.95,-1.2) 2(0.95,-1.2) 3(0,1.2)
SPT_H_BOP_23X23MM
  round 0.305 smd: A2(10.46,-10.814) A3(9.959,-10.814) A4(9.459,-10.814) A42(-9.459,-10.814) A43(-9.959,-10.814) A44(-10.46,-10.814) AA17(3.099,-0.775) AA18(2.324,-0.775) AA20(1.549,-0.775) AA21(0.775,-0.775) AA23(0,-0.775) AA25(-0.775,-0.775) AA26(-1.549,-0.775) AA28(-2.324,-0.775) AA29(-3.099,-0.775) AB7(8.175,-0.667) AB8(7.413,-0.667) AB10(6.651,-0.667) AB11(5.889,-0.667) AB13(5.127,-0.667) AB14(4.365,-0.667) AB15(3.807,-0.667) AB31(-3.807,-0.667) AB32(-4.365,-0.667) AB33(-5.127,-0.667) AB35(-5.889,-0.667) AB36(-6.651,-0.667) AB38(-7.413,-0.667) AB39(-8.175,-0.667) AC17(3.099,0) AC18(2.324,0) AC20(1.549,0) AC21(0.775,0) AC23(0,0) AC25(-0.775,0) AC26(-1.549,0) AC28(-2.324,0) AC29(-3.099,0) AD7(8.175,0.667) AD8(7.413,0.667) AD10(6.651,0.667) AD11(5.889,0.667) AD13(5.127,0.667) AD14(4.365,0.667) AD15(3.807,0.667) AD31(-3.807,0.667) AD32(-4.365,0.667) AD33(-5.127,0.667) AD35(-5.889,0.667) AD36(-6.651,0.667) AD38(-7.413,0.667) AD39(-8.175,0.667) AE17(3.099,0.775) AE18(2.324,0.775) AE20(1.549,0.775) AE21(0.775,0.775) AE23(0,0.775) AE25(-0.775,0.775) AE26(-1.549,0.775) AE28(-2.324,0.775) AE29(-3.099,0.775) AF17(3.099,1.549) AF18(2.324,1.549) AF20(1.549,1.549) AF21(0.775,1.549) AF23(0,1.549) AF25(-0.775,1.549) AF26(-1.549,1.549) AF28(-2.324,1.549) AF29(-3.099,1.549) AG7(8.175,1.772) AG8(7.413,1.772) AG10(6.651,1.772) AG11(5.889,1.772) AG13(5.127,1.772) AG14(4.365,1.772) AG15(3.807,1.772) AG31(-3.807,1.772) AG32(-4.365,1.772) AG33(-5.127,1.772) AG35(-5.889,1.772) AG36(-6.651,1.772) AG38(-7.413,1.772) AG39(-8.175,1.772) AH17(3.099,2.324) AH18(2.324,2.324) AH20(1.549,2.324) AH21(0.775,2.324) AH23(0,2.324) AH25(-0.775,2.324) AH26(-1.549,2.324) AH28(-2.324,2.324) AH29(-3.099,2.324) AJ7(8.074,2.953) AJ8(7.312,2.953) AJ10(6.55,2.953) AJ11(5.788,2.953) AJ13(5.026,2.953) AJ14(4.315,2.953) AJ15(3.807,2.953) AJ17(3.099,3.099) AJ18(2.324,3.099) AJ20(1.549,3.099) AJ21(0.775,3.099) AJ23(0,3.099) AJ25(-0.775,3.099) AJ26(-1.549,3.099) AJ28(-2.324,3.099) AJ29(-3.099,3.099) AJ31(-3.807,2.953) AJ32(-4.365,2.953) AJ33(-5.127,2.953) AJ35(-5.889,2.953) AJ36(-6.651,2.953) AJ38(-7.413,2.953) AJ39(-8.175,2.953) AL7(8.074,4.071) AL8(7.312,4.071) AL10(6.55,4.071) AL11(5.788,4.071) AL13(5.026,4.071) AL17(2.953,3.807) AL19(1.772,3.807) AL22(0.667,3.807) AL24(-0.667,3.807) AL27(-1.772,3.807) AL29(-2.953,3.807) AL32(-4.34,4.096) AL33(-5.102,4.096) AL35(-5.864,4.096) AL36(-6.626,4.096) AL38(-7.388,4.096) AL39(-8.15,4.096) AM15(4.096,4.34) AM17(2.953,4.365) AM19(1.772,4.365) AM22(0.667,4.365) AM24(-0.667,4.365) AM27(-1.772,4.365) AM29(-2.953,4.315) AN7(8.023,5.036) AN8(7.261,4.985) AN10(6.499,4.985) AN11(5.753,5.026) AN15(4.096,5.102) AN17(2.953,5.127) AN19(1.772,5.127) AN22(0.667,5.127) AN24(-0.667,5.127) AN27(-1.772,5.127) AN29(-2.953,5.026) AN31(-4.071,5.026) AN36(-6.47,5.087) AN38(-7.232,5.087) AN39(-7.994,5.087) AP11(6.04,5.551) AR7(7.999,6.037) AR9(7.084,6.077) AR15(4.096,5.864) AR17(2.953,5.889) AR19(1.772,5.889) AR22(0.667,5.889) AR24(-0.667,5.889) AR27(-1.772,5.889) AR29(-2.953,5.788) AR31(-4.071,5.788) AR33(-5.026,5.753) AR34(-5.551,6.04) AR38(-7.396,6.068) AR39(-8.158,6.068) AT9(6.938,6.713) AT10(6.311,6.663) AT13(5.087,6.47) AT15(4.096,6.626) AT17(2.953,6.651) AT19(1.772,6.651) AT22(0.667,6.651) AT24(-0.667,6.651) AT27(-1.772,6.651) AT29(-2.953,6.55) AT31(-4.071,6.55) AT33(-4.985,6.499) AT36(-6.663,6.311) AU7(7.936,6.994) AU35(-6.077,7.084) AU36(-6.713,6.938) AU39(-7.991,7.141) AV6(8.237,7.645) AV11(6.068,7.396) AV13(5.087,7.232) AV15(4.096,7.388) AV17(2.953,7.413) AV19(1.772,7.413) AV22(0.667,7.413) AV24(-0.667,7.413) AV27(-1.772,7.413) AV29(-2.953,7.312) AV31(-4.071,7.312) AV33(-4.985,7.261) AW9(7.141,7.991) AW11(6.068,8.158) AW13(5.087,7.994) AW15(4.096,8.15) AW17(2.953,8.175) AW19(1.772,8.175) AW22(0.667,8.175) AW24(-0.667,8.175) AW27(-1.772,8.175) AW29(-2.953,8.074) AW31(-4.071,8.074) AW33(-5.036,8.023) AW35(-6.037,7.999) AW37(-6.994,7.936) AY5(8.764,8.585) AY38(-7.645,8.237) B1(10.814,-10.46) B2(10.33,-10.33) B3(9.824,-10.326) B43(-9.8,-10.304) B44(-10.33,-10.33) B45(-10.814,-10.46) BA40(-8.585,8.764) BB1(10.814,9.459) BB45(-10.814,9.459) BC1(10.814,9.959) BC2(10.326,9.824) BC44(-10.304,9.8) BC45(-10.814,9.959) BD1(10.814,10.46) BD2(10.33,10.33) BD3(9.8,10.304) BD43(-9.824,10.326) BD44(-10.33,10.33) BD45(-10.814,10.46) BE2(10.46,10.814) BE3(9.959,10.814) BE4(9.459,10.814) BE42(-9.459,10.814) BE43(-9.959,10.814) BE44(-10.46,10.814) C1(10.814,-9.959) C2(10.304,-9.8) C42(-9.288,-9.86) C44(-10.326,-9.824) C45(-10.814,-9.959) D1(10.814,-9.459) D45(-10.814,-9.459) F8(7.645,-8.237) G9(6.994,-7.936) G11(6.037,-7.999) G13(5.036,-8.023) G15(4.071,-8.074) G17(2.953,-8.074) G19(1.772,-8.175) G22(0.667,-8.175) G24(-0.667,-8.175) G27(-1.772,-8.175) G29(-2.953,-8.175) G31(-4.096,-8.15) G33(-5.087,-7.994) G35(-6.068,-8.158) G37(-7.141,-7.991) H13(4.985,-7.261) H15(4.071,-7.312) H17(2.953,-7.312) H19(1.772,-7.413) H22(0.667,-7.413) H24(-0.667,-7.413) H27(-1.772,-7.413) H29(-2.953,-7.413) H31(-4.096,-7.388) H33(-5.087,-7.232) H35(-6.068,-7.396) J7(7.991,-7.141) J10(6.713,-6.938) J11(6.077,-7.084) J39(-7.936,-6.994) K10(6.663,-6.311) K13(4.985,-6.499) K15(4.071,-6.55) K17(2.953,-6.55) K19(1.772,-6.651) K22(0.667,-6.651) K24(-0.667,-6.651) K27(-1.772,-6.651) K29(-2.953,-6.651) K31(-4.096,-6.626) K33(-5.087,-6.47) K36(-6.311,-6.663) K37(-6.938,-6.713) L7(8.158,-6.068) L8(7.396,-6.068) L12(5.551,-6.04) L13(5.026,-5.753) L15(4.071,-5.788) L17(2.953,-5.788) L19(1.772,-5.889) L22(0.667,-5.889) L24(-0.667,-5.889) L27(-1.772,-5.889) L29(-2.953,-5.889) L31(-4.096,-5.864) L37(-7.084,-6.077) L39(-7.999,-6.037) M35(-6.04,-5.551) N7(7.994,-5.087) N8(7.232,-5.087) N10(6.47,-5.087) N15(4.071,-5.026) N17(2.953,-5.026) N19(1.772,-5.127) N22(0.667,-5.127) N24(-0.667,-5.127) N27(-1.772,-5.127) N29(-2.953,-5.127) N31(-4.096,-5.102) N35(-5.753,-5.026) N36(-6.499,-4.985) N38(-7.261,-4.985) N39(-8.023,-5.036) P17(2.953,-4.315) P19(1.772,-4.365) P22(0.667,-4.365) P24(-0.667,-4.365) P27(-1.772,-4.365) P29(-2.953,-4.365) P31(-4.096,-4.34) R7(8.15,-4.096) R8(7.388,-4.096) R10(6.626,-4.096) R11(5.864,-4.096) R13(5.102,-4.096) R14(4.34,-4.096) R17(2.953,-3.807) R19(1.772,-3.807) R22(0.667,-3.807) R24(-0.667,-3.807) R27(-1.772,-3.807) R29(-2.953,-3.807) R33(-5.026,-4.071) R35(-5.788,-4.071) R36(-6.55,-4.071) R38(-7.312,-4.071) R39(-8.074,-4.071) U7(8.175,-2.953) U8(7.413,-2.953) U10(6.651,-2.953) U11(5.889,-2.953) U13(5.127,-2.953) U14(4.365,-2.953) U15(3.807,-2.953) U17(3.099,-3.099) U18(2.324,-3.099) U20(1.549,-3.099) U21(0.775,-3.099) U23(0,-3.099) U25(-0.775,-3.099) U26(-1.549,-3.099) U28(-2.324,-3.099) U29(-3.099,-3.099) U31(-3.807,-2.953) U32(-4.315,-2.953) U33(-5.026,-2.953) U35(-5.788,-2.953) U36(-6.55,-2.953) U38(-7.312,-2.953) U39(-8.074,-2.953) V17(3.099,-2.324) V18(2.324,-2.324) V20(1.549,-2.324) V21(0.775,-2.324) V23(0,-2.324) V25(-0.775,-2.324) V26(-1.549,-2.324) V28(-2.324,-2.324) V29(-3.099,-2.324) W7(8.175,-1.772) W8(7.413,-1.772) W10(6.651,-1.772) W11(5.889,-1.772) W13(5.127,-1.772) W14(4.365,-1.772) W15(3.807,-1.772) W31(-3.807,-1.772) W32(-4.365,-1.772) W33(-5.127,-1.772) W35(-5.889,-1.772) W36(-6.651,-1.772) W38(-7.413,-1.772) W39(-8.175,-1.772) Y17(3.099,-1.549) Y18(2.324,-1.549) Y20(1.549,-1.549) Y21(0.775,-1.549) Y23(0,-1.549) Y25(-0.775,-1.549) Y26(-1.549,-1.549) Y28(-2.324,-1.549) Y29(-3.099,-1.549)
  round 0.279 smd: A5(8.959,-10.814) A41(-8.959,-10.814) BA1(10.814,8.959) BA45(-10.814,8.959) BE5(8.959,10.814) BE41(-8.959,10.814) E1(10.814,-8.959) E45(-10.814,-8.959)
  round 0.254 smd: A6(8.458,-10.814) A25(-1.225,-10.814) A40(-8.458,-10.814) AB3(9.888,-0.609) AB4(9.403,-0.482) AB5(8.937,-0.667) AB41(-8.937,-0.667) AB42(-9.421,-0.509) AC3(9.727,-0.096) AD3(9.929,0.484) AD4(9.421,0.509) AD5(8.937,0.667) AD41(-8.937,0.667) AD42(-9.403,0.482) AF3(9.888,1.664) AF5(8.885,1.721) AF41(-8.887,1.721) AG3(9.727,2.178) AG4(9.403,1.791) AG42(-9.421,1.764) AJ4(9.421,2.783) AJ5(8.836,2.953) AJ41(-8.937,2.953) AJ42(-9.403,2.756) AL3(9.888,3.937) AL4(9.403,4.064) AL5(8.836,4.071) AL41(-8.887,4.096) AL42(-9.421,4.037) AM3(9.727,4.451) AN3(9.929,5.03) AN4(9.421,5.056) AN5(8.785,5.163) AN41(-8.756,5.087) AN42(-9.403,5.029) AR5(8.886,6.182) AR41(-8.92,6.068) AT4(9.403,6.338) AT42(-9.421,6.311) AU41(-9.038,7.09) AU43(-9.727,6.915) AV3(9.929,7.355) AV4(9.229,7.321) AV43(-9.888,7.391) AW4(9.434,8.204) AW42(-9.24,7.816) AY1(10.814,8.458) AY45(-10.814,8.458) B6(8.45,-10.296) B10(6.724,-10.235) B25(-1.225,-10.306) B40(-8.701,-10.355) BA4(9.602,9.12) BA5(8.767,9.095) BA9(7.09,9.038) BA11(6.068,8.92) BA13(5.087,8.756) BA15(4.096,8.887) BA17(2.953,8.937) BA20(1.721,8.887) BA22(0.667,8.937) BA24(-0.667,8.937) BA26(-1.721,8.885) BA29(-2.953,8.836) BA31(-4.071,8.836) BA33(-5.163,8.785) BA35(-6.182,8.886) BA41(-9.095,8.767) BB3(10.162,9.344) BB7(7.816,9.24) BB10(6.311,9.421) BB13(5.029,9.403) BB15(4.037,9.421) BB17(2.756,9.403) BB19(1.764,9.421) BB22(0.482,9.403) BB24(-0.509,9.421) BB27(-1.791,9.403) BB29(-2.783,9.421) BB31(-4.064,9.403) BB33(-5.056,9.421) BB36(-6.338,9.403) BB38(-7.321,9.229) BB39(-8.204,9.434) BB41(-9.12,9.602) BB43(-9.86,9.288) BC4(9.288,9.86) BC9(6.915,9.727) BC42(-9.344,10.162) BE6(8.458,10.814) BE40(-8.458,10.814) C8(7.355,-9.929) C10(6.724,-9.727) C11(6.211,-9.888) C14(4.451,-9.727) C15(3.937,-9.888) C17(2.757,-9.929) C19(2.178,-9.727) C20(1.664,-9.888) C23(-0.096,-9.727) C24(-0.609,-9.888) C27(-1.789,-9.929) C28(-2.369,-9.727) C29(-2.883,-9.888) C31(-4.063,-9.929) C32(-4.642,-9.727) C33(-5.156,-9.888) C36(-6.336,-9.929) C37(-6.915,-9.727) C38(-7.391,-9.888) D3(9.86,-9.288) D5(9.12,-9.602) D7(8.204,-9.434) D8(7.321,-9.229) D10(6.338,-9.403) D13(5.056,-9.421) D15(4.064,-9.403) D17(2.783,-9.421) D19(1.791,-9.403) D22(0.509,-9.421) D24(-0.482,-9.403) D27(-1.764,-9.421) D29(-2.756,-9.403) D31(-4.037,-9.421) D33(-5.029,-9.403) D36(-6.311,-9.421) D39(-7.816,-9.24) D43(-10.162,-9.344) E5(9.095,-8.767) E6(8.585,-8.764) E11(6.182,-8.886) E13(5.163,-8.785) E15(4.071,-8.836) E17(2.953,-8.836) E20(1.721,-8.885) E22(0.667,-8.937) E24(-0.667,-8.937) E26(-1.721,-8.887) E29(-2.953,-8.937) E31(-4.096,-8.887) E33(-5.087,-8.756) E35(-6.068,-8.92) E37(-7.09,-9.038) E41(-8.767,-9.095) E42(-9.602,-9.12) F1(10.814,-8.458) F41(-8.764,-8.585) F44(-10.296,-8.45) F45(-10.814,-8.458) G4(9.24,-7.816) G42(-9.434,-8.204) H2(10.396,-7.391) H3(9.888,-7.391) H40(-8.237,-7.645) H42(-9.229,-7.321) H43(-9.929,-7.355) J2(10.235,-6.915) J3(9.727,-6.915) J5(9.038,-7.09) K2(10.428,-6.432) K3(9.929,-6.336) K4(9.421,-6.311) K42(-9.403,-6.338) K43(-9.727,-6.724) L5(8.92,-6.068) L41(-8.886,-6.182) L43(-9.888,-6.211) N3(9.888,-5.156) N4(9.403,-5.029) N5(8.756,-5.087) N41(-8.785,-5.163) N42(-9.421,-5.056) P3(9.727,-4.642) R4(9.421,-4.037) R5(8.887,-4.096) R41(-8.836,-4.071) R42(-9.403,-4.064) U3(9.888,-2.883) U4(9.403,-2.756) U5(8.937,-2.953) U41(-8.836,-2.953) U42(-9.421,-2.783) V3(9.727,-2.369) W3(9.929,-1.789) W4(9.421,-1.764) W42(-9.403,-1.791) Y5(8.887,-1.721) Y41(-8.885,-1.721)
  oval 0.203x0.254 smd: A7(7.893,-10.814) A9(6.852,-10.814) A37(-6.839,-10.814) A39(-7.893,-10.814) B7(7.944,-10.306) B39(-7.944,-10.306) BC8(7.391,9.888) BD6(8.701,10.355) BD7(7.944,10.306) BD36(-6.724,10.235) BD39(-7.944,10.306) BE7(7.893,10.814) BE9(6.839,10.814) BE37(-6.852,10.814) BE39(-7.893,10.814)
  oval 0.152x0.254 smd: A12(5.595,-10.814) A14(4.553,-10.814) A16(3.321,-10.814) A18(2.28,-10.814) A21(1.048,-10.814) A23(0.007,-10.814) A28(-2.267,-10.814) A32(-4.54,-10.814) B8(7.258,-10.428) B11(6.211,-10.396) B13(4.934,-10.428) B15(3.937,-10.396) B18(2.661,-10.428) B19(2.178,-10.235) B20(1.664,-10.396) B22(0.388,-10.428) B24(-0.609,-10.396) B27(-1.886,-10.428) B33(-5.156,-10.396) B36(-6.432,-10.428) BD10(6.432,10.428) BD13(5.156,10.396) BD14(4.642,10.235) BD15(4.159,10.428) BD17(2.883,10.396) BD18(2.369,10.235) BD19(1.886,10.428) BD22(0.609,10.396) BD23(0.096,10.235) BD24(-0.388,10.428) BD26(-1.664,10.396) BD27(-2.178,10.235) BD28(-2.661,10.428) BD31(-3.937,10.396) BD32(-4.451,10.235) BD33(-4.934,10.428) BD35(-6.211,10.396) BD38(-7.258,10.428) BE11(5.772,10.814) BE14(4.54,10.814) BE16(3.499,10.814) BE18(2.267,10.814) BE21(1.225,10.814) BE23(-0.007,10.814) BE25(-1.048,10.814) BE28(-2.28,10.814) BE30(-3.321,10.814) BE32(-4.553,10.814) BE34(-5.595,10.814)
  custom 0.051x0.051 smd: A30(-3.499,-10.814) A35(-5.772,-10.814) AA2(10.306,-1.225) AA44(-10.306,-1.048) AB43(-9.929,-0.484) AD43(-9.888,0.609) AE2(10.306,1.048) AE44(-10.306,1.225) AG43(-9.929,1.789) AJ3(9.929,2.757) AJ43(-9.888,2.883) AK2(10.306,3.321) AK44(-10.306,3.499) AL43(-9.929,4.063) AM2(10.235,4.451) AN43(-9.888,5.156) AP2(10.306,5.595) AR3(9.888,6.211) AR44(-10.306,5.772) AT43(-9.929,6.336) AU44(-10.235,6.915) AV44(-10.396,7.391) B12(5.595,-10.306) B14(4.451,-10.235) B16(3.321,-10.306) B21(1.048,-10.306) B23(-0.096,-10.235) B29(-2.883,-10.396) B30(-3.499,-10.306) B31(-4.159,-10.428) B32(-4.642,-10.235) B35(-5.772,-10.306) B37(-6.915,-10.235) B38(-7.391,-10.396) BC10(6.336,9.929) BC13(5.156,9.888) BC15(4.063,9.929) BC17(2.883,9.888) BC19(1.789,9.929) BC22(0.609,9.888) BC24(-0.484,9.929) BC26(-1.664,9.888) BC29(-2.757,9.929) BC31(-3.937,9.888) BC33(-5.03,9.929) BC35(-6.211,9.888) BC38(-7.355,9.929) BD8(7.391,10.396) BD9(6.915,10.235) BD11(5.772,10.306) BD16(3.499,10.306) BD21(1.225,10.306) BD25(-1.048,10.306) BD30(-3.321,10.306) BD34(-5.595,10.306) C13(5.03,-9.929) C22(0.484,-9.929) L2(10.306,-5.772) M44(-10.306,-5.595) N43(-9.929,-5.03) P2(10.235,-4.642) R2(10.428,-4.159) R3(9.929,-4.063) R43(-9.888,-3.937) T1(10.814,-3.499) T2(10.306,-3.499) T44(-10.306,-3.321) U2(10.396,-2.883) U43(-9.929,-2.757) V2(10.235,-2.369) Y43(-9.888,-1.664)
  oval 0.254x0.152 smd: AA1(10.814,-1.225) AA45(-10.814,-1.048) AB2(10.396,-0.609) AB44(-10.428,-0.388) AC1(10.814,0.007) AC2(10.235,-0.096) AC44(-10.235,0.096) AC45(-10.814,-0.007) AD2(10.428,0.388) AD44(-10.396,0.609) AE1(10.814,1.048) AE45(-10.814,1.225) AF2(10.396,1.664) AG2(10.235,2.178) AG44(-10.428,1.886) AH1(10.814,2.28) AH2(10.428,2.661) AH44(-10.235,2.369) AH45(-10.814,2.267) AJ44(-10.396,2.883) AK1(10.814,3.321) AK45(-10.814,3.499) AL2(10.396,3.937) AL44(-10.428,4.159) AM1(10.814,4.553) AM44(-10.235,4.642) AM45(-10.814,4.54) AN2(10.428,4.934) AN44(-10.396,5.156) AP1(10.814,5.595) AR2(10.396,6.211) AR45(-10.814,5.772) AT44(-10.428,6.432) AV2(10.428,7.258) L1(10.814,-5.772) L44(-10.396,-6.211) M45(-10.814,-5.595) N2(10.396,-5.156) N44(-10.428,-4.934) P1(10.814,-4.54) P44(-10.235,-4.451) P45(-10.814,-4.553) R44(-10.396,-3.937) T45(-10.814,-3.321) V1(10.814,-2.267) V44(-10.428,-2.661) V45(-10.814,-2.28) W2(10.428,-1.886) W44(-10.235,-2.178) Y44(-10.396,-1.664)
  round 0.368 smd: AA4(9.326,-1.225) AA42(-9.324,-1.048) AE4(9.324,1.048) AE42(-9.326,1.225) AK4(9.324,3.321) AK42(-9.326,3.499) AP4(9.324,5.595) AR42(-9.326,5.772) AY2(10.296,8.45) BB11(5.772,9.326) BB16(3.499,9.326) BB21(1.225,9.326) BB25(-1.048,9.324) BB30(-3.321,9.324) BB34(-5.595,9.324) BD40(-8.45,10.296) C4(9.344,-10.162) D12(5.595,-9.324) D16(3.321,-9.324) D21(1.048,-9.324) D25(-1.225,-9.326) D30(-3.499,-9.326) D35(-5.772,-9.326) L4(9.326,-5.772) M42(-9.324,-5.595) T4(9.326,-3.499) T42(-9.324,-3.321)
  custom 0.057x0.057 smd: AC43(-9.727,0.096) AH43(-9.727,2.369) AM43(-9.727,4.642) AT3(9.727,6.724) B28(-2.369,-10.235) BC14(4.642,9.727) BC18(2.369,9.727) BC23(0.096,9.727) BC27(-2.178,9.727) BC32(-4.451,9.727) BC36(-6.724,9.727) P43(-9.727,-4.451) W43(-9.727,-2.178)
  oval 0.254x0.203 smd: AT2(10.235,6.724) AU1(10.814,6.852) AU45(-10.814,6.839) AW1(10.814,7.893) AW2(10.306,7.944) AW44(-10.306,7.944) AW45(-10.814,7.893) AY44(-10.355,8.701) F2(10.355,-8.701) G1(10.814,-7.893) G2(10.306,-7.944) G44(-10.306,-7.944) G45(-10.814,-7.893) H44(-10.428,-7.258) J1(10.814,-6.839) J45(-10.814,-6.852) K44(-10.235,-6.724)
SSOP29P-0_65-9_7X4_4X1_2MM
  oval 0.305x1.6 smd: 1(-4.225,-2.8) 2(-3.575,-2.8) 3(-2.925,-2.8) 4(-2.275,-2.8) 5(-1.625,-2.8) 6(-0.975,-2.8) 7(-0.325,-2.8) 8(0.325,-2.8) 9(0.975,-2.8) 10(1.625,-2.8) 11(2.275,-2.8) 12(2.925,-2.8) 13(3.575,-2.8) 14(4.225,-2.8) 15(4.225,2.8) 16(3.575,2.8) 17(2.925,2.8) 18(2.275,2.8) 19(1.625,2.8) 20(0.975,2.8) 21(0.325,2.8) 22(-0.325,2.8) 23(-0.975,2.8) 24(-1.625,2.8) 25(-2.275,2.8) 26(-2.925,2.8) 27(-3.575,2.8) 28(-4.225,2.8)
  rect 6.172x2.388 smd: 29(0,0)
SW-SKSHAAE010-4P
  rect 0.508x0.559 smd: 1(-1.55,1.075) 2(-1.55,-1.075) 3(1.55,1.075) 4(1.55,-1.075)
SYX198DQNC_QFN10_3X3
  oval 0.254x0.61 smd: 1(0,0) 2(0.45,0) 3(0.9,0) 4(1.35,0) 5(1.8,0) 6(2.25,0)
  rect 1.168x0.254 smd: 7(2.19,-0.675)
  rect 0.914x2.007 smd: 8(2.065,-2)
  custom 0.482x0.482 smd: 9(1.125,-1.775)
  rect 0.787x1.143 smd: 10(0.113,-1.6)
TAI-T_C8BBPH403025-1TAPING_2P
  rect 2.997x1.803 smd: 1(0,0) 2(4,0)
TOKO_FDUE0640J-H_4P
  custom 0.686x0.686 smd: 1(0,0) 4(9.271,0)
  rect 2.362x0.508 smd: 2(1.448,0) 3(7.823,0)
TPC12
  round 0.305 smd: 1(0,0)
TPC40
  round 1.118 smd: 1(0,0)
TPD4EUSB30DQAR_SON10
  oval 0.254x0.559 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.77) 7(1.5,0.77) 9(0.5,0.77) 10(0,0.77)
  oval 0.356x0.559 smd: 3(1,0) 8(1,0.77)
TPS2546RTER_QFN16_4X4
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.702x1.702 smd: 17(0.75,1.55)
TPS2553DRV_SON6_2X2
  rect 0.813x0.406 smd: 1(-1.15,0.65) 2(-1.15,0) 3(-1.15,-0.65) 4(1.15,-0.65) 5(1.15,0) 6(1.15,0.65)
  rect 1.016x1.676 smd: 7(0,0)
TPS22913_4P
  round 0.305 smd: A1(-0.25,0.25) A2(0.25,0.25) B1(-0.25,-0.25) B2(0.25,-0.25)
TPS51225CRUKR_QFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
TPS51362RVER_QFN28_3P5X4P5
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 15(3.2,3.6) 16(2.8,3.6) 17(2.4,3.6) 18(2,3.6) 19(1.6,3.6) 20(1.2,3.6) 21(0.8,3.6) 22(0.4,3.6) 23(0,3.6)
  oval 0.889x0.203 smd: 10(3.9,1) 11(3.9,1.4) 12(3.9,1.8) 13(3.9,2.2) 14(3.9,2.6) 24(-0.7,2.6) 25(-0.7,2.2) 26(-0.7,1.8) 27(-0.7,1.4) 28(-0.7,1)
  rect 3.099x2.108 smd: 29(1.6,1.8)
TQFN10P-0_4-1_6X1_3X0_75MM
  oval 0.762x0.203 smd: 1(-0.525,0.2) 2(-0.525,-0.2) 6(0.525,-0.2) 7(0.525,0.2)
  oval 0.203x0.559 smd: 3(-0.4,-0.775) 4(0,-0.775) 5(0.4,-0.775) 8(0.4,0.775) 9(0,0.775) 10(-0.4,0.775)
TQFN42P-0_5-9X3_5X0_8MM
  oval 0.66x0.305 smd: 1(-1.59,4) 2(-1.59,3.5) 3(-1.59,3) 4(-1.59,2.5) 5(-1.59,2) 6(-1.59,1.5) 7(-1.59,1) 8(-1.59,0.5) 9(-1.59,0) 10(-1.59,-0.5) 11(-1.59,-1) 12(-1.59,-1.5) 13(-1.59,-2) 14(-1.59,-2.5) 15(-1.59,-3) 16(-1.59,-3.5) 17(-1.59,-4) 22(1.59,-4) 23(1.59,-3.5) 24(1.59,-3) 25(1.59,-2.5) 26(1.59,-2) 27(1.59,-1.5) 28(1.59,-1) 29(1.59,-0.5) 30(1.59,0) 31(1.59,0.5) 32(1.59,1) 33(1.59,1.5) 34(1.59,2) 35(1.59,2.5) 36(1.59,3) 37(1.59,3.5) 38(1.59,4)
  oval 0.305x0.66 smd: 18(-0.75,-4.34) 19(-0.25,-4.34) 20(0.25,-4.34) 21(0.75,-4.34) 39(0.75,4.34) 40(0.25,4.34) 41(-0.25,4.34) 42(-0.75,4.34)
  rect 1.524x6.096 smd: 43(0,0)
TQFN42P-0_5-9X3_5X0_84MM
  oval 0.66x0.305 smd: 1(-1.59,4) 2(-1.59,3.5) 3(-1.59,3) 4(-1.59,2.5) 5(-1.59,2) 6(-1.59,1.5) 7(-1.59,1) 8(-1.59,0.5) 9(-1.59,0) 10(-1.59,-0.5) 11(-1.59,-1) 12(-1.59,-1.5) 13(-1.59,-2) 14(-1.59,-2.5) 15(-1.59,-3) 16(-1.59,-3.5) 17(-1.59,-4) 22(1.59,-4) 23(1.59,-3.5) 24(1.59,-3) 25(1.59,-2.5) 26(1.59,-2) 27(1.59,-1.5) 28(1.59,-1) 29(1.59,-0.5) 30(1.59,0) 31(1.59,0.5) 32(1.59,1) 33(1.59,1.5) 34(1.59,2) 35(1.59,2.5) 36(1.59,3) 37(1.59,3.5) 38(1.59,4)
  oval 0.305x0.66 smd: 18(-0.75,-4.34) 19(-0.25,-4.34) 20(0.25,-4.34) 21(0.75,-4.34) 39(0.75,4.34) 40(0.25,4.34) 41(-0.25,4.34) 42(-0.75,4.34)
  rect 1.524x6.096 smd: 43(0,0)
TRF24P-1-15_1X7_5-4MM
  rect 0.61x1.346 smd: 1(-5.5,-4.675) 2(-4.5,-4.675) 3(-3.5,-4.675) 4(-2.5,-4.675) 5(-1.5,-4.675) 6(-0.5,-4.675) 7(0.5,-4.675) 8(1.5,-4.675) 9(2.5,-4.675) 10(3.5,-4.675) 11(4.5,-4.675) 12(5.5,-4.675) 13(5.5,4.675) 14(4.5,4.675) 15(3.5,4.675) 16(2.5,4.675) 17(1.5,4.675) 18(0.5,4.675) 19(-0.5,4.675) 20(-1.5,4.675) 21(-2.5,4.675) 22(-3.5,4.675) 23(-4.5,4.675) 24(-5.5,4.675)
TSOP49P-0_5-12_5X6_1-1_2MM
  rect 0.279x1.524 smd: 1(-5.75,-3.887) 2(-5.25,-3.887) 3(-4.75,-3.887) 4(-4.25,-3.887) 5(-3.75,-3.887) 6(-3.25,-3.887) 7(-2.75,-3.887) 8(-2.25,-3.887) 9(-1.75,-3.887) 10(-1.25,-3.887) 11(-0.75,-3.887) 12(-0.25,-3.887) 13(0.25,-3.887) 14(0.75,-3.887) 15(1.25,-3.887) 16(1.75,-3.887) 17(2.25,-3.887) 18(2.75,-3.887) 19(3.25,-3.887) 20(3.75,-3.887) 21(4.25,-3.887) 22(4.75,-3.887) 23(5.25,-3.887) 24(5.75,-3.887) 25(5.75,3.887) 26(5.25,3.887) 27(4.75,3.887) 28(4.25,3.887) 29(3.75,3.887) 30(3.25,3.887) 31(2.75,3.887) 32(2.25,3.887) 33(1.75,3.887) 34(1.25,3.887) 35(0.75,3.887) 36(0.25,3.887) 37(-0.25,3.887) 38(-0.75,3.887) 39(-1.25,3.887) 40(-1.75,3.887) 41(-2.25,3.887) 42(-2.75,3.887) 43(-3.25,3.887) 44(-3.75,3.887) 45(-4.25,3.887) 46(-4.75,3.887) 47(-5.25,3.887) 48(-5.75,3.887)
  rect 8.382x3.302 smd: 49(0,0)
TSSOP10P-0_5-3X3-1_1MM
  rect 0.279x1.499 smd: 1(-1,-2.3) 2(-0.5,-2.3) 3(0,-2.3) 4(0.5,-2.3) 5(1,-2.3) 6(1,2.3) 7(0.5,2.3) 8(0,2.3) 9(-0.5,2.3) 10(-1,2.3)
UB3-UEA1111-R36AM1-7H-9P
  round 1.321 hole 0.711: 1(-3.5,6.1) 2(-1,6.1) 3(1,6.1) 4(3.5,6.1) 5(4,7.6) 6(2,7.6) 7(0,7.6) 8(-2,7.6) 9(-4,7.6)
  oval 1.422x2.489 hole 0.813x1.88: 10(6.4,6.6) 11(-6.4,6.6)
  oval 1.422x2.032 hole 0.813x1.422: 12(-6.4,0) 13(6.4,0)
unnamed
  round 1.016 smd: 1(0,0)
USB-UAA111C-441R1-7H-9P
  round 1.118 hole 0.711: 1(-3.5,2) 2(-1,2) 3(1,2) 4(3.5,2) 5(4,3.5) 6(2,3.5) 7(0,3.5) 8(-2,3.5) 9(-4,3.5)
  oval 1.727x3.327 hole 0.711x2.311: 10(-6.4,0) 11(6.4,0)
  oval 2.718x1.905 hole 1.702x0.889: 12(-5.7,5.7) 13(5.7,5.7)
USB-UT11111-13401-7H-24P
  round 0.66 hole 0.66 unplated: (-3.6,0)
  oval 0.94x0.66 hole 0.94x0.66 unplated: (3.6,0)
  rect 0.508x0.305 smd: 1(-3.37,1.55) 2(-1.25,1.55) 3(1.25,1.55) 4(3.38,1.55)
  oval 1.524x2.413 hole 0.508x1.397: 5(-4.6,-1.25) 6(4.6,-1.25)
  oval 1.524x2.616 hole 0.508x1.6: 7(-4.6,-5.25) 8(4.6,-5.25)
  rect 0.305x0.889 smd: A1(-2.75,0.56) A2(-2.25,0.56) A3(-1.75,0.56) A4(-1.25,0.56) A5(-0.75,0.56) A6(-0.25,0.56) A7(0.25,0.56) A8(0.75,0.56) A9(1.25,0.56) A10(1.75,0.56) A11(2.25,0.56) A12(2.75,0.56)
  round 0.61 hole 0.406: B1(2.8,-0.65) B2(2.4,-1.35) B3(1.6,-1.35) B4(1.2,-0.65) B5(0.8,-1.35) B6(0.4,-0.65) B7(-0.4,-0.65) B8(-0.8,-1.35) B9(-1.2,-0.65) B10(-1.6,-1.35) B11(-2.4,-1.35) B12(-2.8,-0.65)
W25Q64FVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
WDFN-10L_0_5-3X3X0_8MM
  rect 1.016x0.305 smd: 1(-1.558,1) 2(-1.558,0.5) 3(-1.558,0) 4(-1.558,-0.5) 5(-1.558,-1) 6(1.558,-1) 7(1.558,-0.5) 8(1.558,0) 9(1.558,0.5) 10(1.558,1)
  rect 1.524x2.54 smd: 11(0,0)
WS33041-S0351-HF-4P
  rect 0.787x1.6 smd: 1(-1.875,2.9) 2(-0.625,2.9) 3(0.625,2.9) 4(1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
WSON7P-0_65-3X3-0_8MM
  oval 0.356x0.991 smd: 1(-0.975,-1.6) 2(-0.325,-1.6) 3(0.325,-1.6) 4(0.975,-1.6) 5(0.975,1.6)
  custom 0.25x0.25 smd: 8(-0.975,1.6)
  rect 2.388x1.6 smd: 9(0,0)
Y_7V27000011_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_CM8V-T1A_2P
  rect 0.8x1.5 smd: 1(-0.75,0) 2(0.75,0)
Y_EXS00A-CS07257_4P
  rect 0.75x0.65 smd: 1(-0.525,-0.389) 2(0.525,-0.389) 3(0.525,0.389) 4(-0.525,0.389)

## Nets
1.0VALW_PWRGD: PR509.2 PU501.2
1.0VG_BS: PR714.1 PU702.6
1.0VG_EN: PC717.1 PR715.1 PR718.1 PU702.1
1.0VG_ILIM: PR723.2 PR724.1 PU702.3
1.2V_B+: PC402.1 PC404.1 PC405.1 PC417.1 PC418.1 PJ401.2 PQ401.1 PR412.1
1.2V_SN: PC412.1 PR403.2
1.05VP_BS: PR502.1 PU501.6
1.05VP_EN: PC511.1 PR505.2 PR507.1 PU501.1
1.05VP_FB: PC515.2 PR508.2 PR511.2 PU501.4
1.05VP_ILIM: PR501.1 PR503.2 PU501.3
1.05VP_LX: PC504.2 PL501.1 PR504.1 PU501.10
1.8V_EN: PC3541.1 PR3465.2 PU1309.1
1.8V_MAIN_EN: PR30.2 PR38.1 R976.2 R2186.1 R2269.1
1.8V_MAIN_EN_LS: D2020.1 PD801.2 PR801.1 PR803.1 PR804.2 Q85.3 R1013.1 R2185.2
1.8V_MAIN_EN_LS_N: Q90.5 Q90.6 R1014.2
1.8V_MAIN_EN_N: Q101.5 Q101.6 R2268.2
1.8V_MAIN_EN_R: G2.BE1 R975.2 R976.1
1.8VP_BS: PR3462.1 PU1309.6
1.8VP_FB: PC3528.2 PR3457.2 PR3458.1 PU1309.4
1.8VP_ILIM: PR3461.1 PR3463.2 PU1309.3
1.8VP_LX: PC3533.2 PL1807.1 PR3460.1 PU1309.10
1.55V_PWR_EN: D51.1 D2012.1 D2017.1 PR3567.2 R809.1 R813.1
1.55V_PWR_EN_N: Q91.6 Q105.4 R810.2
2.5V_MEM_EN: PC421.1 PR425.1 PU403.1
2.5V_MEM_PWRGD: PR423.2 PR451.1 PU403.2
2.5VP_BS: PR428.1 PU403.6
2.5VP_FB: PC435.2 PR438.1 PR439.2 PU403.4
2.5VP_ILIM: PR427.2 PR431.1 PU403.3
2.5VP_LX: PC424.2 PL410.1 PR418.1 PU403.10
3V5V_EN: PC317.1 PR313.2 PR314.1 PU301.6 PU301.20
3VLDO_1.0VG: PC718.1 PU702.5
3VLDO_1.05VP: PC512.1 PU501.5
3VLDO_1.8VP: PC3532.1 PU1309.5
3VLDO_2.5VP: PC437.1 PU403.5
5VALW_PG: PR355.1 PU301.7 R791.1
12V_SN: PC416.1 PR417.2
+0.6V_VTT: C65.1 C66.1 C67.1 C98.1 C99.1 C100.1 C131.1 C132.1 C133.1 C164.1 C165.1 C166.1 JDIMM1.258 JDIMM2.258 JDIMM3.258 JDIMM4.258 PJ404.2 PR1404.2
+0.6VSP: PC406.1 PC407.1 PJ404.1 PU401.2 PU401.20
+1.0V_VCCSFR: C946.2 R54.1 U1.H28 U1.J28
+1.0V_VCCST: C945.2 PC1157.2 PR1234.2 PR1235.1 R7.1 R8.2 R14.2 R15.2 R24.2 R25.2 R53.1 U1.H30
+1.0V_VCCST_VCCSFR: PR1318.2 PR1321.1 R53.2 R54.2
+1.0V_VCCSTG: C944.2 C947.2 C948.2 PJ1253.1 PR317.1 R11.2 R60.2 U1.G30 U1.H29
+1.0V_VCCSTG_RC: C248.2 R60.1 R836.2 U59.2
+1.0VALW: C601.2 PC1253.1 PC1264.1 PC1265.1 PC1315.1 PJ16.2 PJ17.2 PJ502.1 PJ1252.2 PR1403.2 PU1252.3 PU1308.3 R205.2 R596.1 U59.5
+1.0VALW_PCH: C545.2 C2693.2 L39.1 PJ17.1 R204.1 R207.2 R209.2 R212.2 R214.2 R217.1 R221.1 R223.1 R305.1
+1.0VG: PC713.1 PC714.1 PC715.1 PC716.1 PJ703.2 PL702.2 PR717.1 PR719.2
+1.0VP: PC505.1 PC506.1 PC507.1 PC508.1 PC510.1 PJ502.2 PL501.2 PR506.1 PR508.1
+1.2V_BST: PR401.1 PU401.18
+1.2V_CPU_VDDQ: C915.1 C916.1 C917.1 C918.1 C919.1 C920.1 C921.1 C922.1 C923.1 C924.1 C925.1 C926.1 C927.1 C928.1 PJ15.2 PR1257.1 R52.1 U1.AA6 U1.AE12 U1.AF5 U1.AF6 U1.AG5 U1.AG9 U1.AJ12 U1.AL11 U1.AP6 U1.AP7 U1.AR6 U1.AR12 U1.AT12 U1.AW6 U1.AY6 U1.J5 U1.J6 U1.K6 U1.K12 U1.L6 U1.L12 U1.R6 U1.T6 U1.W6
+1.2V_FB: PC413.2 PR408.2 PR410.2 PR413.1 PU401.6
+1.2V_LG: PQ401.5 PU401.15
+1.2V_TON: PR412.2 PU401.9
+1.2V_UG: PR402.2 PU401.17
+1.2V_UGR: PQ401.3 PR402.1
+1.2V_VDDQ: C39.1 C40.1 C41.1 C42.1 C43.1 C44.1 C45.1 C46.1 C47.1 C48.1 C49.1 C55.1 C56.1 C57.1 C58.1 C59.1 C60.1 C61.1 C62.1 C63.1 C64.1 C72.1 C73.1 C74.1 C75.1 C76.1 C77.1 C78.1 C79.1 C80.1 C81.1 C82.1 C88.1 C89.1 C90.1 C91.1 C92.1 C93.1 C94.1 C95.1 C96.1 C97.1 C105.1 C106.1 C107.1 C108.1 C109.1 C110.1 C111.1 C112.1 C113.1 C114.1 C115.1 C121.1 C122.1 C123.1 C124.1 C125.1 C126.1 C127.1 C128.1 C129.1 C130.1 C138.1 C139.1 C140.1 C141.1 C142.1 C143.1 C144.1 C145.1 C146.1 C147.1 C148.1 C154.1 C155.1 C156.1 C157.1 C158.1 C159.1 C160.1 C161.1 C162.1 C163.1 C171.2 C174.2 C426.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 JDIMM3.12 JDIMM3.33 JDIMM3.54 JDIMM3.75 JDIMM3.96 JDIMM3.111 JDIMM3.112 JDIMM3.117 JDIMM3.118 JDIMM3.123 JDIMM3.124 JDIMM3.129 JDIMM3.130 JDIMM3.135 JDIMM3.136 JDIMM3.141 JDIMM3.142 JDIMM3.147 JDIMM3.148 JDIMM3.153 JDIMM3.154 JDIMM3.159 JDIMM3.160 JDIMM3.163 JDIMM3.178 JDIMM3.199 JDIMM3.220 JDIMM3.241 JDIMM4.12 JDIMM4.33 JDIMM4.54 JDIMM4.75 JDIMM4.96 JDIMM4.111 JDIMM4.112 JDIMM4.117 JDIMM4.118 JDIMM4.123 JDIMM4.124 JDIMM4.129 JDIMM4.130 JDIMM4.135 JDIMM4.136 JDIMM4.141 JDIMM4.142 JDIMM4.147 JDIMM4.148 JDIMM4.153 JDIMM4.154 JDIMM4.159 JDIMM4.160 JDIMM4.163 JDIMM4.178 JDIMM4.199 JDIMM4.220 JDIMM4.241 PC820.1 PC1258.1 PJ15.1 PJ402.1 PJ403.1 PR440.2 PR1407.2 PU1254.3 R84.2 R89.2 R93.2 U56.5
+1.2VDDQ: PC403.2 PC408.1 PC409.1 PJ402.2 PJ403.2 PL401.2 PR441.2 PU401.5 PU401.19
