# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
B+_2.5VP:
  vias: v1(214.6,117.86) v1(215.23,117.86) v2(217.01,115.78)
B+_GPU_ALL: length 6.5
  IN08 w2.54: 308.07,126.32 308.07,119.84
  vias: v1(172.69,204.04) v1(172.69,203.28) v1(172.69,202.52) v1(172.69,201.5) v1(173.32,204.04) v1(173.32,203.28) v1(173.32,202.52) v1(173.32,201.5) v1(173.96,204.04) v1(173.96,203.28) v1(173.96,202.52) v1(173.96,201.5) v1(174.59,204.04) v1(174.59,203.28) v1(174.59,202.52) v1(174.59,201.5) v1(197.58,205.18) v1(197.84,204.55) v1(198.34,205.18) v1(198.47,204.55) v1(199.11,205.18) v1(199.11,204.42) v1(199.11,203.66) v1(199.87,205.18) v1(199.87,204.42) v1(199.87,203.66) v1(200.63,205.18) v1(200.63,204.42) v1(200.63,203.66) v1(201.39,205.18) v1(201.39,204.42) v1(201.39,203.66) v1(230.32,81.49) v1(230.96,81.49) v1(231.62,81.46) v1(232.25,81.46) v1(232.89,81.46) v1(233.52,81.46) v1(254.1,80.09) v1(254.73,80.09) v1(255.37,80.09) v1(256,80.09) v1(256.64,80.09) v1(257.27,80.09) v1(297.28,97.87) v1(297.28,97.11) v1(297.28,96.35) v1(297.53,106.89) v1(297.53,106.25) v1(297.53,105.62) v1(297.53,104.98) v1(298.04,98.63) v1(298.04,97.87) v1(298.04,97.11) v1(298.04,96.35) v1(298.17,106.89) v1(298.17,106.25) v1(298.17,105.62) v1(298.17,104.98) v1(305.53,168.35) v1(305.53,167.47) v1(305.53,166.58) v1(305.53,165.69) v2(299.18,103.2)
B+_GPU_ALLN: length 151.7
  TOP w0.254: PR701.4 171.69,199.86 v1(171.17,199.34)
  IN05 w0.254: v1(296.13,198.8) 295.84,199.09 292.32,199.09 286.74,193.5 274.67,193.5 271.37,196.8 271.37,204.93 271.75,205.31 272.38,205.31 v1(272.51,205.44)
  IN08 w0.254: v1(171.17,199.34) 170.91,199.09 170.91,197.47 171.32,197.06 177.39,197.06 177.77,196.68 184.3,196.68 187.04,199.41 187.04,201.5 188.31,202.77 196.82,202.77 197.45,202.14 201.9,202.14 203.04,203.28 210.12,203.28 211.14,204.3 213.2,204.3 213.84,204.93 220.7,204.93 221.33,204.3 225.9,204.3 226.66,205.06 233.9,205.06 234.67,204.3 237.84,204.3 238.6,205.06 246.35,205.06 247.11,204.3 249.65,204.3 250.41,205.06 258.54,205.06 259.3,204.3 262.61,204.3 263.37,205.06 269.34,205.06 269.72,205.44 v1(272.51,205.44)
  BOTTOM w0.254: PR26.1 v1(296.13,198.8)
B+_GPU_ALLP: length 151.2
  TOP w0.254: v1(170.15,199.34) 169.88,199.61 PR701.3
  IN05 w0.254: v1(296.13,199.69) 295.9,199.47 292.17,199.47 286.58,193.88 274.83,193.88 271.75,196.96 271.75,204.76 271.92,204.93 272.26,204.93 v1(272.51,204.68)
  IN08 w0.254: v1(272.51,204.68) 272.13,205.06 269.97,205.06 269.59,204.68 263.52,204.68 262.76,203.91 259.15,203.91 258.38,204.68 250.67,204.68 249.91,203.91 246.86,203.91 246.1,204.68 238.76,204.68 238,203.91 234.41,203.91 233.65,204.68 226.92,204.68 226.16,203.91 221.17,203.91 220.54,204.55 214,204.55 213.36,203.91 211.3,203.91 210.28,202.9 203.3,202.9 202.15,201.76 197.2,201.76 196.57,202.39 188.56,202.39 187.55,201.37 187.55,199.38 184.46,196.29 177.52,196.29 177.13,196.68 171.17,196.68 170.53,197.31 170.53,198.96 v1(170.15,199.34)
  BOTTOM w0.254: PR29.1 v1(296.13,199.69)
B+_GPU_COREN: length 110.8
  TOP w0.254: v1(203.8,200.74) 203.55,200.99 203.55,201.41 PR901.4
  IN05 w0.254: v1(273.02,202.64) 273.4,202.26 273.4,200.61 273.52,199.4 273.74,198.81 274.21,197.53 274.29,197.36 274.86,196.61 276.83,194.64 285.59,194.64 293.97,203.03 298.54,203.03 v1(298.8,202.77)
  IN08 w0.254: v1(203.8,200.74) 203.68,200.87 203.68,201.37 203.93,201.63 210.66,201.63 211.93,202.9 214.22,202.9 214.73,203.41 219.78,203.41 220.28,202.9 226.82,202.9 227.46,203.53 232.76,203.53 233.4,202.9 238.51,202.9 239.14,203.53 244.95,203.53 245.59,202.9 250.7,202.9 251.33,203.53 257.88,203.53 258.51,202.9 263.78,202.9 264.41,203.53 269.56,203.53 270.19,202.9 272.8,202.9 273.02,202.68 v1(273.02,202.64)
  BOTTOM w0.254: PR36.1 v1(298.8,202.77)
B+_GPU_COREP: length 111.5
  TOP w0.254: v1(203.04,200.74) 203.17,200.87 203.17,201.54 PR901.3
  IN05 w0.254: v1(273.02,203.41) 273.78,202.64 273.78,200.74 273.87,199.77 274.04,199.14 274.63,197.7 275.45,196.56 276.99,195.02 285.43,195.02 293.82,203.41 298.55,203.41 v1(298.8,203.65)
  IN08 w0.254: v1(203.04,200.74) 203.3,200.99 203.3,201.53 203.77,202.01 210.5,202.01 211.77,203.28 213.96,203.28 214.47,203.79 219.93,203.79 220.44,203.28 226.66,203.28 227.3,203.91 233.01,203.91 233.65,203.28 238.35,203.28 238.98,203.91 245.21,203.91 245.84,203.28 250.54,203.28 251.18,203.91 258.03,203.91 258.67,203.28 263.62,203.28 264.26,203.91 269.72,203.91 270.35,203.28 272.89,203.28 v1(273.02,203.41)
  BOTTOM w0.254: PR24.1 v1(298.8,203.65)
B+_NVVDDSN: length 218
  IN05 w0.254: v1(309.72,200.58) 309.49,200.36 308.8,200.36 308.33,199.88 308.33,185.28 304.39,181.34 304.39,175.31 308.2,171.5 308.2,121.24 307.31,120.35 307.31,112.73 308.58,111.46 308.58,103.71 308.96,103.33 308.96,95.71 309.47,95.2 309.47,81.74 308.07,80.34 305.53,80.34 304.9,79.71 304.9,78.82 305.28,78.44 306.04,78.44 v1(306.17,78.31)
  IN10 w0.254: v1(306.17,78.31) 306.04,78.44 296.51,78.44 295.88,77.8 286.61,77.8 285.34,79.07 282.42,79.07 281.66,78.31 262.35,78.31 261.97,77.93 250.29,77.93 248.64,79.58 239.36,79.58 236.25,82.7 228.75,82.7 227.93,83.52 227.93,84.53 v1(227.81,84.66)
  BOTTOM w0.254: PR3552.4 228.58,85.56 227.81,84.79 v1(227.81,84.66) ; PR3569.1 v1(309.72,200.58)
B+_NVVDDSP: length 215.2
  IN05 w0.254: v1(309.72,199.69) 309.43,199.98 308.96,199.98 308.79,199.8 308.79,185.2 304.77,181.18 304.77,175.47 308.58,171.66 308.58,120.86 307.69,119.97 307.69,112.98 308.96,111.71 308.96,103.87 309.34,103.49 309.34,96.09 309.85,95.58 309.85,81.58 308.23,79.96 305.79,79.96 305.28,79.45 305.28,79.07 305.53,78.82 306.04,78.82 v1(306.17,78.95)
  IN10 w0.254: v1(228.44,84.66) 228.32,84.53 228.32,83.77 228.95,83.14 236.44,83.14 239.62,79.96 248.79,79.96 250.44,78.31 261.72,78.31 262.1,78.69 281.5,78.69 282.26,79.45 285.59,79.45 286.86,78.18 295.63,78.18 296.26,78.82 306.04,78.82 v1(306.17,78.95)
  BOTTOM w0.254: PR3552.3 229.34,83.76 v1(228.44,84.66) ; PR3568.1 v1(309.72,199.69)
BAT_R:
  vias: v2(94.58,17.68) v2(95.22,23.07) v2(97.12,22.94)
BATT_LOW_LED_A: length 314.2
  IN05 w0.091: v1(257.2,43.11) 257.8,43.11 258.72,44.02 263.73,44.02 263.98,43.77 264.66,43.77 265.17,44.28 267.56,44.28 270.1,41.74 273.65,41.74 275.43,43.51 276.83,43.51 278.61,41.74 286.99,41.74 287.7,41.02 293.28,41.02 295.75,38.56 297.02,38.56 300.07,35.51 300.07,32.46 300.45,32.08 v1(302.1,32.08) ; v1(115.03,39.58) 114.93,39.68 113.81,39.68 110.44,36.32 102.06,36.32 98.39,39.98 98.39,46.26 97.84,46.82 96.36,46.82 96.06,46.52 90.31,46.52 89.65,47.18 73.27,47.18 72.11,48.34 69.06,48.34 68.42,48.97 60.42,48.97 55.98,53.42 55.98,56.59 53.33,59.24 46.18,59.24 45.05,58.12 43.15,58.12 38.58,62.69 35.91,62.69 v1(35.4,62.18)
  IN08 w0.091: v1(115.03,39.58) 115.03,42.73 119.47,47.17 168.66,47.17 170.66,45.16 190.09,45.16 192.76,42.5 199.99,42.5 202.81,45.32 212.69,45.32 215.81,42.2 235.05,42.2 235.35,42.5 252.55,42.5 252.9,42.85 254.48,42.85 254.86,42.47 256.56,42.47 v1(257.2,43.11)
  BOTTOM w0.097: v1(35.4,62.18) 34.77,61.55 34.26,61.55 33.73,61.02 33.73,58.39 34.27,57.85 U5.N5 ; v1(302.1,32.08) 302.06,32.12 JIO1.53
BATT_SMB_CLK: length 3
  BOTTOM w0.097: JBAT1.5 96.97,16.05 96.49,15.57 v2(95.98,15.57) 95.93,15.62 PR101.2
BATT_SMB_DAT: length 3.1
  BOTTOM w0.097: JBAT1.6 97.44,14.8 96.95,14.3 v2(95.93,14.3) 95.47,13.85 PR102.2
BGATE: length 18.1
  TOP w0.254: v1(87.22,11.89) 86.84,11.89 86.59,11.64 PU201.25
  TOP w0.356: PR231.1 99.87,20.65 v1(99.77,20.76)
  IN03 w0.508: v1(99.77,20.76) 95.98,16.97 94.97,16.97 89.89,11.89 v1(87.22,11.89)
BIOS_ONEKEY_N: length 62.4
  IN05 w0.091: v1(41.5,35.39) 42.9,33.99 45.56,33.99 54.45,25.1 54.45,21.67 55.98,20.15 63.85,20.15 64.61,20.91 68.68,20.91 v3(69.57,20.02)
  IN08 w0.089: 35.72,46.69 v2(35.72,50.88)
  IN08 w0.091: v1(41.5,35.39) 38.7,35.39 37.56,36.53 37.56,38.18 36.29,39.45 36.29,41.99 35.4,42.88 35.4,44.46 35.72,44.78 35.72,46.69
  BOTTOM w0.089: U5.D8 35.78,50.93 v2(35.72,50.88)
  BOTTOM w0.097: JKB1.45 69.59,16.07 69.43,16.24 69.41,16.97 R268.2 69.13,17.66 68.93,17.86 68.93,19.19 69.57,19.83 v3(69.57,20.02)
BMON: length 101.4
  TOP w0.097: v3(78.63,5.03) 78.2,5.46 78.2,7.18 78.37,7.34 79.06,7.34 PC219.2 PR215.1
  IN03 w0.089: 41.5,52.4 40.23,52.4 39.98,52.15 v2(37.43,52.15)
  IN03 w0.091: 41.5,52.4 41.75,52.4 42.13,52.78 49.12,52.78 51.4,50.5 52.17,50.5 52.85,51.18 55.26,51.18 55.72,51.64 58.26,51.64 63.72,57.1 71.34,57.1 v1(71.47,57.23)
  IN08 w0.091: v3(78.63,5.03) 79.09,5.49 79.09,6.43 80.61,7.95 80.61,15.83 78.2,18.24 78.2,20.4 78.69,20.89 78.69,30.22 79.39,30.91 79.39,33.31 75.92,36.78 75.92,45.16 73.88,47.2 73.88,52.78 72.36,54.31 72.36,56.34 v1(71.47,57.23)
  BOTTOM w0.089: v2(37.43,52.15) 37.05,52.15 36.79,52.41 U5.F10
BOARD_ID0: length 7.3
  BOTTOM w0.097: R186.1 R188.2 224.17,59.41 224.17,58.8 v2(224.43,58.55) 224.86,58.55 225.34,59.03 225.98,59.03 226.69,59.74 226.69,59.92 226.82,60.05 227.22,60.05 227.27,60.1 227.47,60.1 U2.AG42
BOARD_ID1: length 5.7
  TOP w0.097: v3(224,60.4) 224.17,60.23 R187.2 R185.1
  BOTTOM w0.097: U2.AG43 227.11,60.56 226.64,60.56 226.44,60.35 225.47,60.35 225.01,59.9 v2(224.58,59.9) 224.51,59.9 v3(224,60.4)
BOARD_ID2: length 2.6
  TOP w0.097: v3(225.98,60.73) R855.2 R856.1
  BOTTOM w0.097: v3(225.98,60.73) 226.2,60.96 U2.AE45
BST_3V: length 2.1
  TOP w0.203: PU301.9 46.98,14.45 47.09,14.56
  TOP w0.508: 47.09,14.56 47.59,15.07 PR309.2
BST_5V: length 1.8
  TOP w0.203: 41.99,14.45 PU301.17
  TOP w0.508: PR308.1 41.57,14.45 41.99,14.45
CAM_PWR_EN: length 283.5
  TOP w0.097: R103.1 228.92,68.46 230.12,67.26 230.6,67.26 v3(231.11,66.75)
  IN03 w0.091: v1(164.56,195.02) 164.05,194.52 158.59,194.52 157.7,195.41 149.45,195.41 v1(148.56,196.29)
  IN08 w0.091: v1(164.56,195.02) 164.94,195.41 169.26,195.41 170.4,194.26 176.88,194.26 178.94,192.21 195.7,192.21 198.34,189.56 198.34,184.64 196.95,183.25 196.95,163.27 198.72,161.5 198.72,156.29 197.58,155.15 197.58,150.19 195.93,148.54 195.93,132.03 195.42,131.52 195.42,128.48 172.05,105.11 172.05,73.61 172.56,73.1 172.56,62.44 174.34,60.66 174.34,59.52 175.23,58.63 176.25,58.63 v1(176.75,59.13)
  IN10 w0.091: v3(231.11,66.75) 230.6,67.26 230.09,67.26 227.93,69.42 222.6,69.42 216.38,63.2 213.08,63.2 210.28,65.99 210.28,72.98 209.52,73.74 204.31,73.74 203.4,72.83 203.4,70.67 199.61,66.88 178.79,66.88 177.08,65.18 177.08,63.02 176.75,62.69 v1(176.75,59.13)
  BOTTOM w0.097: U2.R36 231.11,66.71 v3(231.11,66.75) ; v1(148.56,196.29) 148.5,196.36 PR1305.2
CFG0: length 18.8
  TOP w0.097: v1(151.59,148.68) 151.53,148.75 R10.2
  IN05 w0.091: v1(142.97,141.68) 141.83,142.83 141.83,146.26 142.83,147.25 148.57,147.25 148.81,147.5 151.09,147.5 151.59,148.01 v1(151.59,148.68)
  BOTTOM w0.097: U1.BN25 151.27,148.36 v1(151.59,148.68) ; v1(142.97,141.68) TP24.1
CFG1: length 2.6
  TOP w0.097: v3(150.94,149.47) 150.55,149.86 149.91,149.86 v2(149.32,150.45)
  BOTTOM w0.097: v3(150.94,149.47) 151.27,149.8 U1.BN27
CFG2: length 2.8
  TOP w0.097: R12.2 150.88,148.75 v3(150.94,148.68) 150.96,148.68 v2(151.61,148.03) 151.86,147.78 TP28.1
  BOTTOM w0.097: v3(150.94,148.68) 151.27,149.01 U1.BN26
CFG3: length 7.5
  TOP w0.097: TP29.1 152.16,150.83 v1(151.59,150.26)
  BOTTOM w0.076: v1(151.59,150.26) 151.27,150.58 U1.BN28
  BOTTOM w0.097: U1.BN28 151.02,150.65 150.55,151.13 148.89,151.13 148.43,151.59 147.42,151.59 146.91,151.08 146.53,151.08 146.02,150.57 R269.1
CFG4: length 7.7
  TOP w0.097: R23.2 149.98,144.32 v3(149.63,143.97)
  BOTTOM w0.097: TP30.1 146.15,145.49 147.29,144.35 148.56,144.35 148.94,144.73 149.45,144.73 149.83,144.35 U1.BR20 149.97,144.31 v3(149.63,143.97)
CFG5: length 13.2
  TOP w0.097: v1(151.59,143.96) 152.22,143.34 R28.2
  IN05 w0.091: v1(142.97,139.78) 146.15,142.95 147.54,142.95 148.18,143.59 151.22,143.59 v1(151.59,143.96)
  BOTTOM w0.097: v1(151.59,143.96) 151.92,144.28 U1.BM20 ; v1(142.97,139.78) TP31.1
CFG6: length 7.7
  TOP w0.097: v3(148.98,143.97) 148.81,143.97 v2(148.31,143.46) 148.31,142.9 R26.2
  BOTTOM w0.097: TP33.1 146.65,141.68 148.94,143.97 v3(148.98,143.97) 149.32,144.31 U1.BT20
CFG7: length 7.4
  TOP w0.097: v3(150.28,143.97) 150.28,143.85 R32.2
  IN05 w0.091: v3(150.28,143.97) 149.9,144.35 146.91,144.35 v1(146.15,143.59)
  BOTTOM w0.097: v3(150.28,143.97) 150.62,144.31 U1.BP20 ; TP32.1 v1(146.15,143.59)
CFG8: length 1.5
  TOP w0.097: v2(149.07,146.38) 149.07,146.53 v3(149.65,147.11)
  BOTTOM w0.097: v3(149.65,147.11) 149.97,146.78 U1.BR23
CFG9: length 3.1
  BOTTOM w0.097: U1.BR22 149.69,146.2 147.09,146.2 TP36.1
CFG10: length 2.5
  BOTTOM w0.097: U1.BT23 148.76,147.27 TP39.1
CFG11: length 2.4
  BOTTOM w0.097: TP38.1 147.24,145.95 149.29,145.95 U1.BT22
CFG12: length 10.5
  IN05 w0.091: v3(151.58,143.18) 150.97,142.57 150.97,141.56 150.46,141.05 149.32,141.05 148.05,139.78 148.05,139.53 145.89,137.37 v1(145.64,137.37)
  BOTTOM w0.097: U1.BM19 151.92,143.52 v3(151.58,143.18) ; TP40.1 v1(145.64,137.37)
CFG13: length 11
  IN05 w0.091: v1(142.97,137.87) 144.75,139.65 144.75,140.29 146.78,142.32 148.61,142.32 149.48,143.18 v3(149.63,143.18)
  BOTTOM w0.097: v3(149.63,143.18) 149.97,143.52 U1.BR19 ; v1(142.97,137.87) TP41.1
CFG14: length 10.1
  IN05 w0.091: v3(150.28,143.18) 149.93,142.83 149.45,142.83 146.53,139.91 146.53,139.53 v1(146.15,139.14)
  BOTTOM w0.097: U1.BP19 150.62,143.52 v3(150.28,143.18) ; TP43.1 v1(146.15,139.14)
CFG15: length 6
  BOTTOM w0.097: TP42.1 145.53,139.78 U1.BT19
CFG16: length 12.8
  IN05 w0.091: v1(142.97,143.59) 142.34,144.22 142.34,145.88 142.97,146.51 149.7,146.51 v3(150.3,147.11)
  BOTTOM w0.097: v3(150.3,147.11) 150.62,146.78 U1.BP23 ; v1(142.97,143.59) TP44.1
CFG17: length 1.6
  TOP w0.097: v3(150.95,147.11) 151.48,146.57 v2(151.48,146.26)
  BOTTOM w0.097: U1.BN23 151.27,146.78 v3(150.95,147.11)
CFG18: length 10.2
  IN05 w0.091: v3(150.93,145.55) 150.47,146 143.48,146 v1(142.97,145.49)
  BOTTOM w0.097: v3(150.93,145.55) 151.27,145.88 U1.BN22 ; v1(142.97,145.49) TP47.1
CFG19: length 3.9
  BOTTOM w0.097: TP46.1 147.42,146.38 150.16,146.38 U1.BP22
CFG_RCOMP: length 3.5
  BOTTOM w0.254: R22.2 148.68,147.91 149.07,148.29 U1.BT25
CHASSIS1_GND: length 1.9
  TOP w0.457: C279.2 13.81,114
  TOP w0.508: C278.2 4.67,113.87
  vias: v1(1.62,113.49) v1(1.62,112.73) v1(2.38,112.86) v1(7.08,113.36) v1(9.24,113.62) v1(13.18,113.49) v1(20.11,101.63) v1(20.14,100.26) v1(20.14,98.76) v1(20.14,97.21) v1(20.06,95.66) v1(20.09,94.26) v1(20.06,92.64) v1(20.06,91.37) v2(10.26,113.74)
CHG_DH: length 2.2
  TOP w0.254: PU201.23 87.84,10.6 88.23,11
  TOP w0.356: PR209.2 88.55,11 88.23,11
CHG_DH_R: length 7.2
  TOP w0.508: PQ204.3 95.85,9.22 v2(94.85,10.23) 94.21,10.23 93.06,11.38 PR209.1
CHG_DL: length 17.4
  TOP w0.254: 88.92,9.99 88.74,9.8 PU201.21
  TOP w0.508: v1(92.55,10.49) v2(91.54,10.49) 91.16,10.49 90.77,10.11 89.05,10.11 88.92,9.99 ; PQ204.5 v1(101.98,7.09)
  IN08 w0.508: v1(101.98,7.09) 98.11,7.09 94.71,10.49 v1(92.55,10.49)
CHG_PAHSE: length 1.7
  TOP w0.097: v2(105,4.27) 105.13,4.4 105.13,5.92
CHG_PROCHOT_N: length 4
  TOP w0.097: PU201.5 82.14,9.4 81.96,9.22 80.06,9.22 PR229.2
CHG_PROCHOT_N_R: length 88.4
  TOP w0.097: v3(78.33,10.87) 78.63,10.57 PR229.1
  IN05 w0.089: 41.5,47.96 v3(40.36,47.96)
  IN05 w0.091: v1(78.96,32.46) 78.33,33.1 76.42,33.1 75.92,32.59 73.13,32.59 70.34,29.8 68.8,29.8 66.39,32.21 58.15,32.21 53.46,36.9 53.46,41.2 48.07,46.59 47.18,46.59 46.71,47.07 44.29,47.07 43.4,47.96 41.5,47.96
  IN08 w0.091: v1(78.96,32.46) 78.84,32.59 77.19,32.59 76.69,32.09 76.69,19.37 77.06,19 77.06,16.72 78.2,15.57 79.09,15.57 79.51,15.16 79.51,13.83 78.33,12.65 v3(78.33,10.87)
  BOTTOM w0.097: U5.C13 38.48,50.91 39.72,49.67 39.72,48.59 v3(40.36,47.96) R247.2 41.8,47.65 42.01,47.45 43.28,47.45 43.4,47.32 45.28,47.32 D2016.1 46.62,47.61 R435.1
CHG_SMB_CLK: length 2
  TOP w0.097: PR228.2 81.91,9.73 81.99,9.8 v2(82.29,9.8) PU201.4
CHG_SMB_DAT: length 2.1
  TOP w0.097: PR227.2 81.74,10.2 PU201.3
CHG_TGR: length 21.9
  TOP w0.254: v1(88.36,10.37) 88.2,10.2 PU201.22
  TOP w0.508: v1(93.19,13.16) 92.68,12.65 PC212.2 ; v1(94.97,8.33) 95.35,7.95 PQ204.4
  IN03 w0.508: v1(93.19,13.16) 93.82,13.8 95.35,13.8 96.74,12.4 96.74,9.1 95.85,8.21 95.09,8.21 v1(94.97,8.33)
  IN08 w0.508: v1(88.36,10.37) 91.03,10.37 93.44,7.95 94.58,7.95 v1(94.97,8.33)
CK_CPU_24M_N: length 139.5
  IN03 w0.114: v3(254.1,73.23) 253.89,73.43 253.72,73.43 253.6,73.32 253.6,73.12 253.49,73 253.26,73 253.12,73.14 253.12,75.73 248.89,79.96 242.92,79.96 239.22,83.66 214.71,83.66 212.31,86.06 212.31,90.12 209.77,92.66 209.77,94.19 209.15,94.81 209.15,100.93 209.77,101.55 209.77,107.01 210.17,107.41 210.17,114.49 209.9,114.76 209.9,115.6 211.42,117.12 211.42,124.15 210.77,124.81 209.84,124.81 208.77,125.87 208.77,126.81 207.28,128.3 206.62,128.3 205.07,129.84 205.07,135.46 193.34,147.2 193.34,151.65 192.87,152.11 188.42,152.11 188.09,152.44 188.09,152.75 188.21,152.86 v3(188.34,152.86)
  BOTTOM w0.104: U2.F1 248.17,70.49 248.56,70.49 250.11,72.04 252.16,72.04 253.15,73.03 253.89,73.03 253.96,73.1 v3(254.1,73.23) ; U1.D31 188,153.2 v3(188.34,152.86)
CK_CPU_24M_P: length 139.5
  IN03 w0.114: v3(187.68,152.84) 187.83,152.68 187.83,152.33 188.31,151.84 192.76,151.84 193.07,151.53 193.07,147.09 204.81,135.35 204.81,129.73 206.51,128.03 207.17,128.03 208.5,126.7 208.5,125.76 209.73,124.54 210.66,124.54 211.16,124.04 211.16,117.23 209.63,115.71 209.63,114.65 209.9,114.38 209.9,107.52 209.51,107.12 209.51,101.66 208.88,101.04 208.88,94.7 209.51,94.08 209.51,92.55 212.05,90.01 212.05,85.95 214.6,83.39 239.11,83.39 242.81,79.7 248.77,79.7 252.85,75.62 252.85,73.03 253.16,72.72 253.97,72.72 v3(254.1,72.6)
  BOTTOM w0.104: v3(254.1,72.6) 253.92,72.77 253.26,72.77 v1(252.95,72.47) 252.26,71.78 250.21,71.78 248.66,70.23 248.17,70.23 U2.G1 ; v3(187.68,152.84) 187.35,153.16 U1.E31
CK_CPU_BCLK_N: length 144
  IN03 w0.114: v3(255.62,72.6) 255.67,72.65 256.13,72.65 256.46,72.98 256.46,74.17 255.81,74.82 255.55,74.82 249.51,80.86 243.4,80.86 237.7,86.57 216.25,86.57 213.58,89.23 213.58,94.82 210.79,97.62 210.79,101.81 213.7,104.72 214.46,104.72 216.38,106.63 216.38,111.59 215.79,112.18 215.79,115.6 213.58,117.8 213.58,123.27 213.72,123.41 213.72,125.34 212.24,126.83 210.15,126.83 207.87,129.11 207.87,129.62 207.64,129.85 207.64,135.06 194.23,148.47 194.23,152.02 193.19,153.06 191.56,153.06 191.21,153.42 v1(191.21,153.52)
  BOTTOM w0.076: 248.51,69.62 248.5,69.62 248.45,69.68 247.7,69.68 U2.H2
  BOTTOM w0.104: 248.51,69.62 249.33,69.62 250.75,71.05 254.2,71.05 v1(254.54,71.39) 255.06,71.91 255.06,72.87 255.17,72.98 255.29,72.98 255.62,72.65 v3(255.62,72.6) ; U1.A32 190.19,153.93 190.8,153.93 v1(191.21,153.52)
CK_CPU_BCLK_P: length 143.9
  IN03 w0.114: v1(190.57,153.52) 191.02,153.08 191.17,153.08 191.45,152.8 193.08,152.8 193.96,151.91 193.96,148.35 207.37,134.95 207.37,129.74 207.6,129.51 207.6,129 210.04,126.56 212.13,126.56 213.46,125.23 213.46,123.52 213.32,123.38 213.32,117.69 215.52,115.49 215.52,112.07 216.11,111.48 216.11,106.74 214.35,104.98 213.59,104.98 210.52,101.92 210.52,97.51 213.32,94.71 213.32,89.12 216.14,86.3 237.59,86.3 243.29,80.6 249.4,80.6 255.44,74.55 255.7,74.55 256.19,74.06 256.19,73.09 256.02,72.91 255.89,72.91 255.62,73.18 v3(255.62,73.23)
  BOTTOM w0.076: 248.51,69.88 248.49,69.88 248.44,69.83 247.81,69.83 U2.G2
  BOTTOM w0.104: U1.B31 189.3,153.31 189.38,153.39 190.09,153.39 190.32,153.62 190.47,153.62 v1(190.57,153.52) ; 248.51,69.88 249.22,69.88 v1(250.16,70.82) 250.64,71.3 254.09,71.3 254.81,72.02 254.81,72.98 255.06,73.23 v3(255.62,73.23)
CK_CPU_PCIBCLK_N: length 151.2
  IN03 w0.114: v3(257.27,72.6) 257.4,72.73 257.4,72.73 257.64,72.97 257.79,72.97 258.05,73.22 258.05,74.1 255.91,76.24 255.4,76.24 249.19,82.45 243.1,82.45 238.09,87.46 218.05,87.46 216.27,89.23 216.27,94.29 215.23,95.33 214.34,95.33 211.93,97.74 211.93,101.07 212.87,102.01 215.65,102.01 218.17,104.53 218.17,111.32 216.68,112.8 216.68,117.76 214.85,119.59 214.85,125.5 212.64,127.71 210.66,127.71 209.01,129.37 209.01,136.09 195.39,149.72 195.39,152.16 192.8,154.75 188.87,154.75 188.7,154.92 188.7,155.38 188.83,155.51 v1(188.83,155.51)
  BOTTOM w0.104: U1.C36 188.56,155.78 v1(188.83,155.51) ; v3(257.27,72.6) 257.27,72.67 257.05,72.89 256.83,72.89 256.59,72.64 v1(256.59,72.22) 256.59,71.68 256.59,71.59 256.59,71.59 256.59,71.51 256.29,71.21 256.21,71.21 256.21,71.21 256.12,71.21 255.83,70.92 255.83,70.83 255.83,70.75 255.53,70.45 255.45,70.45 255.36,70.45 255.2,70.29 254.29,70.29 254.16,70.16 253.74,70.16 253.62,70.29 252.4,70.29 252.26,70.15 251.85,70.15 251.71,70.29 251.41,70.29 250.17,69.04 249.16,69.04 249.01,68.89 248.59,68.89 248.45,69.04 248.04,69.04 U2.J1
CK_CPU_PCIBCLK_P: length 151.2
  IN03 w0.114: v1(187.83,155.92) 187.83,155.92 188.44,155.31 188.44,154.81 188.76,154.49 192.69,154.49 195.12,152.05 195.12,149.61 208.74,135.98 208.74,129.26 210.55,127.45 212.53,127.45 214.59,125.39 214.59,119.48 216.42,117.65 216.42,112.69 217.9,111.21 217.9,104.64 215.54,102.27 212.76,102.27 211.67,101.18 211.67,97.63 214.23,95.06 215.12,95.06 216,94.18 216,89.12 217.94,87.19 237.98,87.19 242.99,82.18 249.08,82.18 255.29,75.97 255.8,75.97 257.78,73.99 257.78,73.33 257.68,73.23 v3(257.27,73.23)
  BOTTOM w0.104: v3(257.27,73.23) 257.18,73.14 256.72,73.14 256.33,72.75 256.33,71.78 255.09,70.54 v1(251.81,70.54) 251.32,70.54 250.47,69.69 250.06,69.29 247.64,69.29 U2.J2 ; U1.D35 188.09,155.62 187.83,155.88 v1(187.83,155.92)
CK_CR_N: length 84
  IN10 w0.114: v3(246.85,70.95) 246.94,70.86 248.15,70.86 248.43,70.58 257.89,70.58 258.27,70.2 263.51,70.2 265.4,72.09 274.92,72.09 275.42,71.59 284.22,71.59 284.97,72.34 286.23,72.34 286.99,71.58 286.99,70.81 287.38,70.42 287.38,67.03 286.86,66.5 286.86,62.94 287.88,61.93 289.02,61.93 294.48,56.47 294.48,53.67 296.26,51.89 296.26,47.58 298.67,45.16 302.21,45.16 302.88,44.5 302.88,42.83 302.47,42.42 302.03,42.42 v1(301.85,42.24)
  BOTTOM w0.104: U2.E5 v3(246.85,70.95) ; JIO1.27 301.02,42.52 301.09,42.6 301.5,42.6 v1(301.85,42.24)
CK_CR_P: length 83.9
  IN10 w0.114: v1(301.85,43.13) 301.72,43.13 301.6,43.02 301.6,42.81 301.72,42.69 302.36,42.69 302.61,42.94 302.61,44.39 302.1,44.9 298.56,44.9 295.99,47.47 295.99,51.78 294.22,53.56 294.22,56.36 288.91,61.66 287.77,61.66 286.6,62.83 286.6,66.62 287.12,67.14 287.12,70.31 286.72,70.7 286.72,71.47 286.12,72.08 285.08,72.08 284.33,71.33 275.31,71.33 274.81,71.82 265.51,71.82 263.62,69.93 258.16,69.93 257.78,70.31 248.32,70.31 248.04,70.59 247.02,70.59 246.86,70.43 v3(246.86,70.31)
  BOTTOM w0.104: JIO1.26 301.02,42.92 301.09,42.85 301.57,42.85 v1(301.85,43.13) ; U2.G4 246.54,70 v3(246.86,70.31)
CK_LAN_N: length 240.9
  TOP w0.104: v1(76.7,57.48) 76.52,57.3 76.52,56.82 75.53,55.83 73.38,55.83 70.2,52.66 61.06,52.66 58.39,55.32 58.39,60.4 57.35,61.45 54.68,61.45 53.75,60.52 52.99,60.52 R278.1
  IN05 w0.114: v3(245.08,71.96) 244.95,71.96 244.83,72.09 244.83,72.24 244.95,72.37 245.36,72.37 245.97,72.98 245.97,74.12 245.07,75.02 245.07,77.3 245.32,77.55 245.32,79.51 237.9,86.94 213.98,86.94 212.68,88.23 212.68,89.63 210.79,91.52 205.2,91.52 204.57,92.15 199.11,92.15 198.17,93.09 196.24,93.09 193.52,90.38 178.03,90.38 177.4,91 174.07,91 173.45,90.38 146.02,90.38 145.51,89.87 145.51,88.6 144.88,87.96 143.48,87.96 141.76,86.24 136.17,86.24 135.1,85.17 135.1,81.61 133.49,80.01 129.73,80.01 124.35,74.63 114.14,74.63 113.76,74.25 110.21,74.25 109.32,73.36 106.04,73.36 105.4,72.72 104.36,72.72 99.71,68.08 99.71,66.81 98.8,65.89 98.8,65.1 97.58,63.88 96.41,63.88 96.03,63.5 96.03,62.49 95.45,61.9 95.45,61.17 92.53,58.25 89.89,58.25 88.36,56.72 85.32,56.72 83.59,58.45 76.75,58.45 76.27,57.97 76.27,57.69 76.47,57.48 v1(76.7,57.48)
  BOTTOM w0.104: U2.D8 244.53,71.41 v3(245.08,71.96)
CK_LAN_P: length 240.9
  TOP w0.104: v1(75.87,57.48) 76.09,57.48 76.27,57.31 76.27,56.93 75.43,56.09 73.27,56.09 70.09,52.91 61.16,52.91 58.65,55.43 v1(58.65,58.5) 58.65,60.51 57.45,61.7 54.57,61.7 53.65,60.77 52.88,60.77 52.75,60.9 R279.1
  IN05 w0.114: v1(75.87,57.48) 75.97,57.57 76,57.61 76,58.08 76.64,58.72 83.7,58.72 85.43,56.99 88.25,56.99 89.77,58.51 92.42,58.51 95.18,61.28 95.18,62.01 95.77,62.6 95.77,63.61 96.3,64.15 97.47,64.15 98.53,65.21 98.53,66 99.45,66.92 99.45,68.19 104.25,72.99 105.29,72.99 105.93,73.63 109.21,73.63 110.09,74.51 113.65,74.51 114.03,74.9 124.24,74.9 129.62,80.28 133.38,80.28 134.83,81.72 134.83,85.28 136.06,86.51 141.65,86.51 143.37,88.23 144.77,88.23 145.24,88.71 145.24,89.98 145.91,90.64 173.34,90.64 173.96,91.27 177.52,91.27 178.14,90.64 193.41,90.64 196.12,93.36 198.28,93.36 199.22,92.42 204.68,92.42 205.31,91.79 210.9,91.79 212.95,89.74 212.95,88.34 214.09,87.2 238.01,87.2 245.59,79.62 245.59,77.44 245.33,77.19 245.33,75.13 246.23,74.23 246.23,72.87 245.7,72.33 245.7,72.1 v3(245.84,71.96)
  BOTTOM w0.104: v3(245.84,71.96) 245.84,71.69 245.7,71.56 245.47,71.56 U2.D7
CK_LPC1: length 1.4
  TOP w0.097: v2(238.98,55.07) 239.36,55.07 v3(239.62,54.82)
  BOTTOM w0.091: U2.AV19 239.57,54.77 v3(239.62,54.82)
CK_LPC/ESPI_CLK: length 249.5
  IN03 w0.091: v1(239.24,46.69) 239.36,46.56 239.36,44.53 236.85,42.02 216.32,42.02 210.41,47.93 202.18,47.93 201.23,48.88 175.77,48.88 175.17,49.48 160.7,49.48 154.98,55.2 126.99,55.2 125.47,56.72 106.3,56.72 104.77,55.2 98.78,55.2 97.51,53.93 95.85,53.93 95.47,54.31 89.12,54.31 87.47,52.66 81.63,52.66 81,52.02 80.11,52.02 79.6,52.53 77.06,52.53 76.42,51.9 74.65,51.9 71.61,48.86 63.99,48.86 61.19,46.06 53.66,46.06 52.25,44.66 49.37,44.66 49.16,44.87 46.79,44.87 46.32,44.4 33.55,44.4 32.74,43.59 32.74,40.59 32.05,39.91 30.5,39.91 29.69,40.72 v1(29.69,42.24)
  IN05 w0.089: 29.81,53.8 30.45,53.17 30.45,46.69
  IN05 w0.091: 29.81,53.8 v1(29.31,54.31) ; v1(29.69,42.24) 29.18,42.75 29.18,45.29 29.56,45.67 30.07,45.67 30.45,46.05 30.45,46.69
  BOTTOM w0.076: U5.K2 32.77,54.41 32.51,54.67 31.97,54.67
  BOTTOM w0.089: 31.74,54.67 31.34,55.06 30.06,55.06 29.81,54.82
  BOTTOM w0.097: 29.81,54.82 v1(29.31,54.31) R264.2 ; 31.74,54.67 31.97,54.67 ; v1(239.24,46.69) R183.1
CK_LPC/ESPI_CLK_R: length 4.6
  BOTTOM w0.097: U2.BC17 240.09,52.19 240.38,51.9 240.38,51.26 240.25,51.13 240.25,49.74 v2(240.05,49.53) 239.62,49.1 239.62,48.67 R183.2
CK_PCIE_SSD1_N: length 202.3
  IN03 w0.114: v1(115.67,51.8) 115.85,51.62 116.15,51.62 116.42,51.88 116.42,52.93 117.18,53.7 153.74,53.7 161.13,46.31 209.9,46.31 215.69,40.52 248.66,40.52 254.97,46.82 254.97,56.18 255.75,56.96 255.75,61.17 257.39,62.81 257.39,67.66 257.02,68.02 252.7,68.02 252.45,68.28 250.16,68.28 249.8,67.92 249.8,67 249.94,66.86 250.14,66.86 250.28,67 v3(250.28,67.52)
  BOTTOM w0.076: U2.N3 247.16,67.34 247.42,67.08 248.26,67.08 248.31,67.03 248.33,67.03
  BOTTOM w0.104: JSSD1.53 104.23,54.17 103.7,54.7 103.7,55.64 104.28,56.21 109.17,56.21 113.76,51.63 115.5,51.63 v1(115.67,51.8) ; v3(250.28,67.52) 250.14,67.38 250.14,67.12 249.8,66.78 248.76,66.78 248.5,67.03 248.33,67.03
CK_PCIE_SSD1_P: length 202.3
  IN03 w0.114: v3(249.4,67.52) 249.54,67.66 249.54,68.03 250.05,68.55 252.56,68.55 252.81,68.29 257.13,68.29 257.65,67.77 257.65,62.69 256.01,61.06 256.01,56.85 255.24,56.07 255.24,46.71 248.77,40.25 215.58,40.25 209.79,46.04 161.02,46.04 153.63,53.43 117.3,53.43 116.68,52.82 116.68,51.77 116.26,51.35 115.78,51.35 115.67,51.24 v1(115.67,50.98)
  BOTTOM w0.076: 248.33,67.29 248.31,67.29 248.26,67.24 247.7,67.24 U2.N2
  BOTTOM w0.104: JSSD1.55 105.06,54.67 104.99,54.6 104.99,54.6 104.81,54.43 104.33,54.43 103.96,54.8 103.96,55.53 104.38,55.96 v1(108.55,55.96) 109.06,55.96 113.65,51.37 115.1,51.37 115.21,51.26 115.21,50.75 115.31,50.65 115.56,50.65 115.67,50.75 v1(115.67,50.98) ; 248.33,67.29 248.61,67.29 248.86,67.04 249.7,67.04 249.88,67.22 249.88,67.75 249.76,67.87 249.52,67.87 249.4,67.75 v3(249.4,67.52)
CK_PCIE_SSD2_N: length 181.9
  IN05 w0.114: v1(124.28,55.07) 124.28,55.07 124.44,54.91 124.44,54.33 125.03,53.74 149.85,53.74 153.4,57.29 186.6,57.29 187.93,58.61 194.9,58.61 195.21,58.3 212.26,58.3 220.59,66.63 220.59,72.93 224.05,76.38 230.63,76.38 232.24,74.77 232.24,74.01 233.9,72.34 234.67,72.34 235.35,71.66 235.35,67.47 235.8,67.02 238.59,67.02 239.15,66.46 239.88,66.46 240.57,67.15 241.3,67.15 241.39,67.05 242.15,67.05 242.62,67.53 242.62,68.91 243.5,69.79 245.6,69.79 246.1,70.29 v3(246.1,71.38)
  BOTTOM w0.104: U2.D5 246.37,71.74 246.37,71.47 246.28,71.38 v3(246.1,71.38) ; JSSD2.53 106.75,78.54 106.87,78.66 107.06,78.66 107.67,78.06 109.83,78.06 110.84,77.04 110.84,75.01 115.54,70.31 v1(115.54,70.06) 115.54,63.98 117.34,62.18 118.84,62.18 124.68,56.34 124.68,55.66 124.58,55.55 124.25,55.55 124.12,55.43 124.12,55.22 v1(124.28,55.07)
CK_PCIE_SSD2_P: length 181.9
  IN05 w0.114: v3(245.21,71.07) 245.21,71.2 245.33,71.33 245.59,71.33 245.83,71.09 245.83,70.4 245.49,70.06 243.39,70.06 242.35,69.02 242.35,67.64 242.03,67.32 241.51,67.32 241.41,67.42 240.46,67.42 239.77,66.73 239.26,66.73 238.7,67.29 235.91,67.29 235.62,67.58 235.62,71.77 234.78,72.61 234.01,72.61 232.51,74.12 232.51,74.88 230.74,76.65 223.94,76.65 220.33,73.04 220.33,66.74 212.15,58.57 195.32,58.57 195.01,58.88 187.82,58.88 186.49,57.55 153.29,57.55 149.74,54.01 125.14,54.01 124.71,54.44 124.71,54.97 124.81,55.07 v1(125.09,55.07)
  BOTTOM w0.104: v1(125.09,55.07) 124.94,55.22 124.94,56.45 118.95,62.44 117.44,62.44 115.8,64.09 v1(115.8,68.79) 115.8,70.42 111.1,75.12 111.1,77.15 109.93,78.31 107.77,78.31 107.17,78.92 106.87,78.92 106.75,79.04 JSSD2.55 ; v3(245.21,71.07) 245.66,71.07 U2.E6
CK_PEG1_N: length 89.8
  IN05 w0.114: v3(245.64,66.75) 245.56,66.83 245.41,66.83 245.26,66.68 245.26,66.37 245.53,66.09 246.45,66.09 246.86,66.5 246.86,66.88 246.35,67.39 246.35,68.07 249.51,71.23 249.51,78.96 249.02,79.45 248.14,80.33 245.83,80.33 241.4,84.77 241.4,86.75 240.62,87.52 240.62,103.83 241.98,105.18 242.87,105.18 243.17,105.49 243.17,108.53 243.92,109.28 243.92,112.19 243.62,112.49 243.62,116.3 243.03,116.89 243.03,118.08 242.53,118.59 242.53,119.82 243.75,121.04 243.75,130.7 243.57,130.88 238.62,130.88 238.36,131.13 236.94,131.13 236.29,131.78 235.15,131.78 235.02,131.65 235.02,131.49 235.11,131.4 235.83,131.4 235.94,131.3 235.94,130.97 235.83,130.86 235.53,130.86 v3(235.4,130.99)
  BOTTOM w0.104: v3(235.4,130.99) 236.14,130.99 236.21,131.07 236.21,131.19 236.04,131.37 G2.BM27 ; U2.N7 245.2,67.19 v3(245.64,66.75)
CK_PEG1_P: length 89.9
  IN05 w0.114: v3(234.64,130.97) 234.75,131.08 234.75,131.76 235.04,132.05 236.4,132.05 237.05,131.4 238.48,131.4 238.73,131.14 243.68,131.14 244.01,130.81 244.01,120.93 242.79,119.71 242.79,118.7 243.3,118.19 243.3,117 243.89,116.41 243.89,112.6 244.19,112.3 244.19,109.17 243.44,108.42 243.44,105.38 242.98,104.92 242.09,104.92 240.89,103.72 240.89,87.63 241.66,86.86 241.66,84.88 245.94,80.6 248.25,80.6 249.2,79.64 249.78,79.07 249.78,71.12 246.62,67.96 246.62,67.5 247.12,66.99 247.12,66.39 246.56,65.83 245.42,65.83 244.99,66.26 244.99,66.64 v3(244.88,66.75)
  BOTTOM w0.104: U2.N8 244.44,67.24 244.88,66.81 v3(244.88,66.75) ; G2.BM26 235.8,130.58 235.02,130.58 v3(234.64,130.97)
CK_REQ_CR_N: length 94.2
  IN05 w0.091: v1(257.4,49.36) 257.99,49.95 257.99,55.38 261.94,59.34 264.76,59.34 265.65,58.45 266.11,58.45 266.34,58.22 266.34,55.81 265.4,54.87 265.4,50.12 266.99,48.52 272.71,48.52 274.92,46.31 277.08,46.31 279.62,43.77 282.42,43.77 283.43,44.78 285.34,44.78 285.72,44.4 288.39,44.4 291.31,47.32 293.47,47.32 v1(293.97,46.82)
  IN08 w0.091: v3(235.05,49.1) 235.17,49.1 235.55,48.72 239.75,48.72 240.13,48.34 243.3,48.34 243.68,48.72 243.68,49.1 243.94,49.36 244.44,49.36 244.53,49.27 248,49.27 248.04,49.23 252.7,49.23 252.88,49.05 257.09,49.05 v1(257.4,49.36)
  BOTTOM w0.076: U2.BD25 236.16,51.74 235.81,51.39
  BOTTOM w0.097: JIO1.18 299.49,46.12 298.42,47.2 294.36,47.2 v1(293.97,46.82) ; RP2.5 233.92,48.35 234.67,49.1 v3(235.05,49.1) 235.05,49.61 235.66,50.22 235.66,51.24 235.81,51.39
CK_REQ_LAN_N: length 239.5
  TOP w0.097: R277.1 49.37,69.93 v1(48.1,71.2) 48.38,71.48 50.03,71.48 50.27,71.72 Q35.6
  IN03 w0.091: v1(45.56,51.01) 47.34,49.23 54.83,49.23 56.36,50.75 58.52,50.75 63.98,56.21 73.12,56.21 73.25,56.09 76.8,56.09 77.31,55.58 86.33,55.58 88.82,58.07 103.68,58.07 106.4,60.79 124.43,60.79 125.7,59.52 130.65,59.52 132.3,57.86 156.43,57.86 157.2,57.1 189.2,57.1 191.23,55.07 214.88,55.07 219.46,50.5 220.7,50.5 224,47.2 234.67,47.2 236.32,48.85 236.32,49.36 v3(235.94,49.74)
  IN10 w0.091: v1(48.1,71.2) 47.59,71.71 45.82,71.71 44.29,70.18 44.29,67.01 44.55,66.75 44.55,61.67 45.31,60.91 45.31,52.78 44.8,52.28 44.8,51.77 v1(45.56,51.01)
  BOTTOM w0.097: U2.BE25 236.16,49.96 v3(235.94,49.74) 235.52,49.32 235.52,49.01 235.17,48.67 234.61,48.67 234.42,48.47 RP2.6
CK_REQ_PEG1_N: length 182.2
  IN08 w0.091: v3(236.85,49.86) 237.59,49.86 237.97,50.24 238.6,50.24 239.11,49.74 240.25,49.74 240.56,49.43 243.63,49.43 243.81,49.61 245.56,49.61 245.71,49.46 247.72,49.46 247.74,49.47 253.09,49.47 253.26,49.3 255.06,49.3 255.11,49.36 256.51,49.36 259.18,52.02 259.18,60.91 258.54,61.55 258.54,69.42 257.14,70.82 253.97,70.82 252.19,69.04 252.19,67.52 251.68,67.01 248.76,67.01 247.87,66.12 246.98,66.12 245.97,65.1 241.27,65.1 240.89,65.48 233.9,65.48 233.52,65.1 228.44,65.1 224.76,68.79 222.22,68.79 220.57,70.44 220.57,73.74 218.54,75.77 211.3,75.77 210.28,76.79 207.87,76.79 206.65,78 206.65,92.85 209.11,95.3 209.11,99.37 209.98,100.23 209.98,102.91 213.22,106.15 215.26,106.15 216.12,107.01 216.12,111.84 215.11,112.86 214.54,112.86 212.19,115.21 212.19,115.65 211.42,116.41 211.42,118.19 211.3,118.32 207.87,118.32 205.07,121.11 205.07,124.41 205.58,124.92 205.58,132.67 v1(206.6,133.68)
  BOTTOM w0.076: U2.BC24 236.85,52.25 237.08,52.02 237.08,51.77 237.21,51.64 237.33,51.64 237.47,51.51 237.47,50.5 236.85,49.89 v3(236.85,49.86)
  BOTTOM w0.097: R601.2 207.28,133.38 206.98,133.68 v1(206.6,133.68) 206.21,133.29 Q13.6 ; v3(236.85,49.86) 236.85,49.38 235.86,48.39 235.73,48.39 235.41,48.07 RP2.8
CK_REQ_SSD1_N: length 189.5
  TOP w0.097: R304.2 230.98,50.45 232.63,52.1 v3(232.63,52.91)
  IN03 w0.091: v1(139.16,40.08) 134.31,44.94 121.92,44.94 119.7,42.72 119.7,40.49 117.35,38.13 114.51,38.13 108.46,32.08 98.9,32.08 98.78,31.96 97,31.96 96.87,32.08 v1(96.87,32.46)
  IN10 w0.091: v3(232.63,52.91) 231.49,54.05 230.98,54.05 230.09,54.94 227.3,54.94 226.92,55.32 223.83,55.32 220.91,58.25 218.28,58.25 217.39,57.36 204.44,57.36 203.8,56.72 195.7,56.72 194.99,56.01 187.88,56.01 186.43,54.56 176.18,54.56 175.23,53.61 175.23,53.29 174.59,52.66 170.15,52.66 168.88,51.39 148.87,51.39 139.16,41.68 v1(139.16,40.08) ; v1(96.49,55.12) 96.36,54.99 96.36,40.72 97.29,39.8 97.29,32.88 v1(96.87,32.46)
  BOTTOM w0.097: Q9.6 94.22,54.44 94.71,54.44 94.79,54.51 R479.2 95.27,55.07 95.35,55.15 R512.2 96.46,55.15 v1(96.49,55.12) ; U2.BC32 232.75,52.79 v3(232.63,52.91)
CK_REQ_SSD2_N: length 165.6
  IN03 w0.091: v1(97.25,61.67) 97.51,61.93 111.86,61.93 112.62,61.17 124.56,61.17 125.83,59.9 131.92,59.9 133.7,58.12 156.56,58.12 156.94,57.74 190.22,57.74 192.25,55.71 214.6,55.71 219.55,50.75 220.82,50.75 224.12,47.45 234.54,47.45 235.94,48.85 v3(235.94,49.1)
  IN10 w0.091: v1(97.25,61.67) 96.82,61.67 95.73,60.58 v1(95.73,50.88)
  BOTTOM w0.097: U2.BB24 236.67,52.76 236.44,52.53 236.44,49.61 v3(235.94,49.1) 235.94,49.05 234.91,48.03 RP2.7 ; v1(95.73,50.88) R508.2 R485.2 95.04,52.58 Q9.3
CK_REQ_TBT_N: length 265.4
  IN05 w0.091: v1(114.22,35.51) 112.18,35.51 111.25,34.59 100.33,34.59 96.14,38.78 96.14,39.54 95.09,40.59 87.22,40.59 85.57,38.94 71.09,38.94 67.79,42.24 60.93,42.24 v1(58.9,40.21)
  IN08 w0.091: v1(114.22,35.51) 113.63,36.1 113.63,42.42 119.96,48.75 168.85,48.75 171.55,46.05 190.82,46.05 193.67,43.21 199.54,43.21 202.53,46.21 213.51,46.21 216.78,42.93 222.53,42.93 223.62,44.02 227.71,44.02 230.73,47.04 230.73,47.45 v3(231.36,48.09)
  IN10 w0.091: v1(61.56,90.03) 61.56,90 61.18,89.61 61.18,84.03 59.91,82.76 59.91,74.5 60.29,74.12 60.29,65.01 61.18,64.12 61.18,54.94 62.71,53.42 67.79,53.42 69.44,51.77 69.44,51.12 66.02,47.7 65.25,47.7 64.49,46.94 64.49,46.43 63.09,45.04 62.58,45.04 60.42,42.88 60.42,41.74 v1(58.9,40.21)
  BOTTOM w0.097: U2.BD32 232.75,51.86 232.25,51.36 232.25,50.66 231.36,49.77 v3(231.36,48.09) 231.36,47.91 R309.2 ; R2067.1 61.09,90.5 v1(61.56,90.03)
CK_REQ_TBT_N_R: length 5.8
  BOTTOM w0.076: 56.76,89.28 U2005.AC5
  BOTTOM w0.097: 56.76,89.28 56.84,89.35 58.12,89.35 58.29,89.52 58.29,90.49 v2(58.53,90.72) 58.75,90.5 R2067.2 R2066.1
CK_REQ_WLAN_N: length 78.6
  TOP w0.097: R457.1 266.58,77.29 Q8.6 267.82,77.54 268.21,77.93 269.59,77.93 269.97,77.55 269.97,73.8 272.19,71.58 274.55,71.58 275.81,70.31 275.81,65.48 v1(276.19,65.1) ; R787.2 236.98,56.87 v3(235.94,55.83)
  IN05 w0.091: v1(256.64,58.63) 257.27,59.26 257.43,59.26 258.08,59.92 258.08,61.7 260.59,64.21 275.3,64.21 v1(276.19,65.1)
  IN08 w0.091: v1(256.64,58.63) 257.4,57.86 257.4,53.55 256.89,53.04 256.13,53.04 254.48,54.69 253.59,54.69 252.84,53.94 249.89,53.94 249.27,53.32 249.27,53.29 248.56,52.58 248.18,52.58 247.55,51.95 237.4,51.95 236.44,52.91 236.44,55.32 v3(235.94,55.83)
  BOTTOM w0.097: U2.AT24 236.36,55.53 236.06,55.83 v3(235.94,55.83)
CK_TBT_N: length 263.2
  IN03 w0.114: v3(244.24,64.34) 244.02,64.34 243.79,64.57 243.79,64.73 243.89,64.84 245.11,64.84 245.71,64.23 245.71,62.82 247.23,61.31 247.23,59.66 247.73,59.15 247.73,52.51 247.04,51.82 236.57,51.82 235.22,50.47 231.46,50.47 230.86,49.86 230.86,48.97 230.47,48.59 229.59,48.59 229.06,49.11 224.11,49.11 219.79,53.43 218.27,53.43 214.96,56.73 196.81,56.73 194.91,58.63 157.58,58.63 157.07,59.13 134.59,59.13 132.56,61.17 127.22,61.17 126.07,62.32 113.24,62.32 112.73,62.83 96.02,62.83 92.2,59.01 76.17,59.01 75.66,58.5 70.07,58.5 69.58,58 63.35,58 57.88,52.53 52.75,52.53 52.47,52.25 51.39,52.25 51.25,52.39 51.25,52.57 51.38,52.7 v1(51.67,52.7)
  IN10 w0.114: v1(51.67,52.7) 51.47,52.49 51.47,52.34 51.57,52.24 52.26,52.24 52.41,52.39 52.41,54.18 51.79,54.8 51.79,56.97 52.92,58.1 52.92,61.53 53.96,62.58 56.12,62.58 56.73,63.18 56.73,65.34 56.98,65.6 56.98,66.26 56.6,66.64 56.6,69.69 56.09,70.2 56.09,73.75 52.53,77.31 52.53,82.47 v2(52.52,82.48)
  BOTTOM w0.104: U2.W10 v3(244.24,64.34) ; U2005.T19 52.85,82.81 v2(52.52,82.48)
CK_TBT_P: length 263.2
  IN03 w0.114: v1(51.66,51.77) 51.81,51.92 52.52,51.92 52.86,52.26 57.99,52.26 63.47,57.74 69.69,57.74 70.18,58.23 75.77,58.23 76.28,58.74 92.31,58.74 96.13,62.56 112.62,62.56 113.13,62.06 125.96,62.06 127.11,60.9 132.45,60.9 134.48,58.87 156.96,58.87 157.47,58.36 194.8,58.36 196.7,56.47 214.85,56.47 218.16,53.17 219.68,53.17 224,48.85 228.95,48.85 229.48,48.32 230.58,48.32 231.12,48.86 231.12,49.75 231.58,50.21 235.33,50.21 236.68,51.55 247.15,51.55 248,52.4 248,59.26 247.49,59.77 247.49,61.42 246.18,62.73 245.98,62.93 245.98,64.34 245.22,65.1 243.78,65.1 243.52,64.84 243.52,64.38 v3(243.48,64.34)
  IN10 w0.114: v2(53.18,82.49) 52.8,82.11 52.8,77.42 56.36,73.86 56.36,70.31 56.87,69.8 56.87,66.75 57.25,66.37 57.25,65.48 56.99,65.23 56.99,63.07 56.23,62.31 54.07,62.31 53.18,61.42 53.18,57.99 52.05,56.86 52.05,54.91 52.67,54.29 52.67,52.28 52.37,51.97 51.86,51.97 v1(51.66,51.77)
  BOTTOM w0.104: U2005.V19 v2(53.18,82.49) ; U2.W11 v3(243.48,64.34)
CK_WLAN_N: length 28.9
  IN10 w0.114: v3(246.98,71.96) 247.16,71.79 247.41,71.79 247.59,71.96 250.54,71.96 251.03,71.47 258.27,71.47 258.52,71.21 263,71.21 264.78,72.99 267.63,72.99 268.31,73.68 268.31,73.91 v1(268.1,74.12)
  BOTTOM w0.104: JWLAN1.49 268.75,77.96 268.87,77.84 268.87,77.45 268.32,76.89 268.32,74.33 v1(268.1,74.12) ; v3(246.98,71.96) 247.07,71.88 U2.D3
CK_WLAN_P: length 28.9
  IN10 w0.114: v1(268.79,74.12) 268.58,73.91 268.58,73.57 267.74,72.72 264.89,72.72 263.11,70.95 258.41,70.95 258.16,71.2 250.92,71.2 250.43,71.7 247.7,71.7 247.54,71.54 v3(247.54,71.35)
  BOTTOM w0.104: v1(268.79,74.12) 268.57,74.33 268.57,76.79 269.13,77.34 269.13,77.84 269.25,77.96 JWLAN1.47 ; U2.F2 247.49,70.95 247.49,71.3 v3(247.54,71.35)
CK_XDP_N: length 6.9
  BOTTOM w0.104: TP55.1 253.97,69.42 253.97,69.29 253.87,69.2 252.87,69.2 252.13,68.46 v1(249.47,68.46) 249.21,68.46 248.71,67.95 U2.L1
CK_XDP_P: length 6.9
  BOTTOM w0.104: TP54.1 253.71,68.94 252.98,68.94 252.24,68.2 v1(252.01,68.2) 249.32,68.2 248.82,67.7 247.76,67.7 247.69,67.77 247.69,67.77 U2.L2
CLK_REQ_PEG_N_R: length 34.8
  BOTTOM w0.097: G2.BL26 236.45,130.67 236.04,130.25 224.18,130.25 220.57,133.86 209.13,133.86 208.68,133.41 208.68,132.77 R601.1 208.38,132.11 v2(208.38,131.27) 207.94,130.84 R600.2 206.66,131.53 Q13.1
CLKA0: length 35.4
  TOP w0.127: R774.2 248.88,168.14 249.1,168.37 249.76,168.37 v3(250.06,168.07)
  IN10 w0.127: v3(252.51,170.75) 252.29,170.75 251.89,171.15 251.52,171.15 250.51,170.14 250.51,168.4 250.18,168.07 v3(250.06,168.07) 250.06,168.21 249.84,168.43 249.7,168.43 249.57,168.3 249.57,167.75 250.2,167.13 250.2,161.72 253.34,158.58 253.34,150.06 253.15,149.87 253.15,148.46 253.87,147.75 253.87,144.17 253.58,143.88 253.3,143.88 v3(253.09,143.67)
  BOTTOM w0.127: G2.AG45 253.39,143.83 253.23,143.67 v3(253.09,143.67) ; U48.J12 252.91,170.99 252.67,170.75 v3(252.51,170.75)
CLKA0_N: length 35.4
  TOP w0.127: v3(250.06,168.94) 249.78,168.67 249.1,168.67 248.88,168.89 R2219.2
  IN10 w0.127: v3(253.09,144.37) 253.3,144.16 253.46,144.16 253.59,144.28 253.59,147.63 252.87,148.35 252.87,149.99 253.06,150.17 253.06,158.47 249.92,161.61 249.92,167.01 249.3,167.63 249.3,168.42 249.58,168.71 249.82,168.71 v3(250.06,168.94) 250.23,169.12 250.23,170.26 251.4,171.43 252.01,171.43 252.29,171.14 252.91,171.14 v3(253.31,170.75)
  BOTTOM w0.122: U48.J11 v3(253.31,170.75)
  BOTTOM w0.127: G2.AG46 v3(253.09,144.37)
CLKA1: length 36.3
  TOP w0.127: R2218.2 246.05,168.14 245.84,168.36 245.45,168.36 v3(245.17,168.08)
  IN03 w0.127: v3(250.99,144.37) 251.19,144.37 251.4,144.58 251.4,147.54 251.16,147.78 251.16,157.28 245.79,162.65 245.79,168.34 245.6,168.53 245.37,168.53 245.22,168.38 245.22,168.13 v3(245.17,168.08) 245.07,168.08 244.72,168.44 244.72,170.32 243.89,171.15 243.06,171.15 242.66,170.75 v3(242.47,170.75)
  BOTTOM w0.122: 242.07,170.84 U2022.J12
  BOTTOM w0.127: v3(242.47,170.75) 242.17,170.75 242.07,170.84 ; G2.AK46 251.35,144.73 251.56,144.73 251.66,144.62 251.66,144.36 251.59,144.29 251.07,144.29 v3(250.99,144.37)
CLKA1_N: length 36.3
  TOP w0.127: v3(245.17,168.95) 245.46,168.67 245.83,168.67 246.05,168.89 R2215.2
  IN03 w0.127: v3(241.67,170.75) 242.07,171.15 242.67,171.15 242.95,171.43 244,171.43 245,170.43 245,169.13 v3(245.17,168.95) 245.31,168.81 245.72,168.81 246.07,168.46 246.07,162.77 251.44,157.39 251.44,147.89 251.68,147.66 251.68,144.36 v3(250.99,143.67)
  BOTTOM w0.122: U2022.J11 v3(241.67,170.75)
  BOTTOM w0.127: v3(250.99,143.67) G2.AK45
CLKB0: length 42.3
  TOP w0.127: R2223.2 291.19,159.01 291.41,158.78 291.41,158.58 v3(291.13,158.29)
  IN10 w0.127: v3(266.39,142.17) 266.6,141.96 266.6,141.54 266.92,141.21 267.43,141.21 267.7,141.49 270.48,141.49 271.06,142.07 271.06,142.65 274.58,146.17 275.56,146.17 277.26,147.86 277.26,148.85 287.34,158.93 291.42,158.93 291.54,158.81 291.54,158.42 291.41,158.29 v3(291.13,158.29) 291.85,157.57 293.16,157.57 294.18,156.56 294.18,156.01 293.7,155.53 v3(293.7,155.34)
  BOTTOM w0.122: v3(266.39,142.17) G2.H42 ; v3(293.7,155.34) 293.9,155.34 294.1,155.13 U2023.J12
CLKB0_N: length 42.3
  TOP w0.127: R2221.2 291.94,159.01 291.71,158.78 291.71,158.58 v3(292,158.29)
  IN10 w0.127: v3(293.7,154.54) 294.1,154.94 294.1,155.54 294.46,155.89 294.46,156.67 293.28,157.85 292.44,157.85 v3(292,158.29) 291.82,158.47 291.82,158.93 291.54,159.21 287.22,159.21 276.98,148.96 276.98,147.98 275.45,146.45 274.46,146.45 270.78,142.77 270.78,142.18 270.36,141.77 267.59,141.77 267.31,141.49 267.04,141.49 266.88,141.66 266.88,141.96 v3(267.09,142.17)
  BOTTOM w0.122: U2023.J11 v3(293.7,154.54) ; G2.G42 v3(267.09,142.17)
CLKB1: length 38.9
  TOP w0.127: R2220.2 281.49,168.44 281.26,168.66 280.93,168.66 v3(280.63,168.36)
  IN03 w0.127: v3(277.53,170.75) 277.64,170.64 277.78,170.64 277.91,170.76 277.91,170.89 278.19,171.17 279.01,171.17 280.01,170.18 280.01,168.99 v3(280.63,168.36) 280.63,168.62 280.82,168.81 281.1,168.81 281.21,168.7 281.21,164.89 278.84,162.51 278.84,156.94 272.45,150.56 272.45,147.01 271.4,145.96 269.94,145.96 269.34,145.37 268.68,145.37 v3(268.38,145.07)
  BOTTOM w0.122: v3(268.38,145.07) 268.38,145.26 268.28,145.37 G2.F47 ; U55.J12 277.13,170.91 277.29,170.75 v3(277.53,170.75)
CLKB1_N: length 38.9
  TOP w0.127: v3(280.63,169.23) 280.9,168.96 281.26,168.96 281.49,169.19 R871.2
  IN03 w0.127: v3(276.73,170.75) 277.13,171.15 277.77,171.15 278.08,171.45 279.13,171.45 280.29,170.3 280.29,169.58 v3(280.63,169.23) 281.08,169.23 281.49,168.82 281.49,164.77 279.12,162.4 279.12,156.83 272.73,150.45 272.73,146.9 271.52,145.68 270.05,145.68 269.32,144.94 v3(269.05,144.94)
  BOTTOM w0.122: U55.J11 v3(276.73,170.75) ; v3(269.05,144.94) 269.05,145.1 G2.E47
CLKC0: length 33.3
  TOP w0.127: v3(291.25,123.05) 291.54,123.33 291.54,123.71 291.31,123.93 R2226.2
  IN10 w0.127: v3(293.83,120.28) 293.83,120.47 294.28,120.93 294.28,121.36 293.26,122.39 291.82,122.39 291.25,122.95 v3(291.25,123.05) 291.48,123.05 291.62,123.19 291.62,123.39 291.53,123.49 290.98,123.49 290.33,122.84 286.97,122.84 286.71,122.58 272.68,122.58 272.41,122.85 267.5,122.85 v3(267.09,123.27)
  BOTTOM w0.127: U2025.J12 294.01,119.88 293.83,120.07 v3(293.83,120.28) ; G2.G15 267.24,122.97 267.09,123.13 v3(267.09,123.27)
CLKC0_N: length 33.3
  TOP w0.127: R2227.2 292.06,123.93 291.84,123.71 291.84,123.33 v3(292.12,123.05)
  IN10 w0.127: v3(293.83,119.48) 294.23,119.88 294.23,120.47 294.56,120.81 294.56,121.48 293.37,122.67 292.5,122.67 v3(292.12,123.05) 291.9,123.27 291.9,123.51 291.65,123.77 290.86,123.77 290.22,123.12 286.85,123.12 286.59,122.86 272.79,122.86 272.52,123.13 267.92,123.13 v3(267.64,123.42)
  BOTTOM w0.122: G2.F15 v3(267.64,123.42)
  BOTTOM w0.127: U2025.J11 v3(293.83,119.48)
CLKC1: length 35.5
  TOP w0.127: v3(291.25,127.46) 291.54,127.18 291.54,126.9 291.31,126.67 R903.2
  IN03 w0.127: v3(266.39,127.47) 266.21,127.47 266.07,127.33 266.07,126.99 266.19,126.87 267.15,126.87 267.34,127.05 281.46,127.05 281.52,127 291.47,127 291.64,127.17 291.64,127.29 291.46,127.46 v3(291.25,127.46) 291.88,128.1 293.24,128.1 294.25,129.11 294.25,129.69 293.83,130.12 v3(293.83,130.32)
  BOTTOM w0.122: v3(293.83,130.32) 294.03,130.32 294.23,130.52 U2024.J12 ; v3(266.39,127.47) 266.34,127.42 266.34,126.87 266.42,126.79 266.71,126.79 266.8,126.88 266.8,127.06 G2.H21
CLKC1_N: length 35.2
  TOP w0.127: R901.2 292.06,126.67 291.84,126.9 291.84,127.18 v3(292.12,127.46)
  IN03 w0.127: v3(265.69,127.47) 265.79,127.36 265.79,126.87 266.07,126.59 267.27,126.59 267.46,126.77 281.35,126.77 281.4,126.72 291.59,126.72 291.92,127.05 291.92,127.26 v3(292.12,127.46) 292.47,127.82 293.36,127.82 294.53,129 294.53,129.81 294.23,130.11 294.23,130.72 v3(293.83,131.12)
  BOTTOM w0.122: U2024.J11 v3(293.83,131.12) ; G2.J21 v3(265.69,127.47)
CLKD0: length 35.2
  TOP w0.127: R785.2 256.94,94.44 256.72,94.21 256.43,94.21 v3(256.15,94.49)
  IN03 w0.127: v3(258.59,118.37) 258.35,118.13 258,118.13 257.69,117.82 257.69,116.72 257.6,116.64 257.6,113.7 258.52,112.78 258.52,111.13 258.77,110.88 258.77,103.69 255.99,100.91 255.99,95.42 256.73,94.68 256.73,94.31 256.51,94.09 256.22,94.09 256.15,94.16 v3(256.15,94.49) 255.58,93.92 255.58,92.29 254.76,91.47 253.92,91.47 253.47,91.92 v3(253.27,91.92)
  BOTTOM w0.122: v3(253.27,91.92) 253.27,91.71 253.08,91.52 U2026.J12 ; v3(258.59,118.37) 258.47,118.37 258.29,118.18 G2.Y8
CLKD0_N: length 35.2
  TOP w0.127: R906.2 256.94,93.68 256.72,93.91 256.43,93.91 v3(256.15,93.62)
  IN03 w0.127: v3(258.64,117.69) 258.47,117.85 258.11,117.85 257.97,117.71 257.97,116.61 257.88,116.52 257.88,113.81 258.8,112.9 258.8,111.25 259.05,111 259.05,103.57 256.27,100.8 256.27,95.53 257.01,94.79 257.01,94.19 256.62,93.81 256.33,93.81 v3(256.15,93.62) 255.86,93.33 255.86,92.18 254.87,91.19 253.81,91.19 253.47,91.53 252.86,91.53 v3(252.47,91.92)
  BOTTOM w0.122: v3(258.64,117.69) 258.61,117.69 G2.Y7 ; U2026.J11 v3(252.47,91.92)
CLKD1: length 32.8
  TOP w0.127: v3(260.5,94.49) 260.5,94.44 260.27,94.21 259.98,94.21 259.76,94.44 R916.2
  IN10 w0.127: v3(263.43,91.92) 263.24,91.92 262.84,91.52 262,91.52 261.21,92.31 261.21,93.91 260.62,94.49 v3(260.5,94.49) 260.45,94.55 260.45,95.46 260.64,95.65 260.64,102.77 261.34,103.47 261.34,113.05 261.64,113.35 261.64,115.04 262.07,115.47 262.07,117.78 v3(261.36,118.49)
  BOTTOM w0.122: v3(261.36,118.49) 261.55,118.49 261.79,118.25 G2.R8 ; v3(263.43,91.92) 263.43,91.7 263.61,91.52 U60.J12
CLKD1_N: length 32.8
  TOP w0.127: R914.2 259.76,93.68 259.98,93.91 260.27,93.91 260.5,93.67 v3(260.5,93.62)
  IN10 w0.127: v3(264.23,91.92) 263.83,91.51 263.23,91.51 262.96,91.24 261.88,91.24 260.93,92.19 260.93,93.2 v3(260.5,93.62) 260.07,94.06 260.07,95.47 260.36,95.77 260.36,102.88 261.06,103.58 261.06,113.16 261.36,113.47 261.36,115.16 261.79,115.59 261.79,117.36 v3(261.49,117.67)
  BOTTOM w0.122: G2.R7 v3(261.49,117.67) ; U60.J11 v3(264.23,91.92)
CMDA0: length 32.1
  BOTTOM w0.102: G2.Y51 258.29,148.42 258.59,148.72 258.59,149.04 258.42,149.21 258.42,150.92 258.55,151.05
  BOTTOM w0.122: 258.55,151.05 258.55,153.48 259.66,154.6 262.57,154.6 264.18,156.22 264.18,171.11 262.79,172.5 262.11,172.5 261.96,172.35 260.51,172.35 U48.G3
CMDA1: length 33
  TOP w0.122: R2195.1 261.52,172.61 v2(261.21,172.29) 260.51,171.59 v3(260.51,171.55)
  BOTTOM w0.102: G2.Y52 258.17,148.98 258.17,151.14 258.26,151.24
  BOTTOM w0.122: U48.J3 v3(260.51,171.55) 260.51,171.55 262.26,171.55 262.33,171.62 262.79,171.62 263.68,170.73 263.68,156.43 262.34,155.09 259.76,155.09 258.26,153.59 258.26,151.24
CMDA2: length 30.4
  TOP w0.122: v3(261.31,170.75) 261.45,170.61 R2200.1
  BOTTOM w0.122: U48.J2 v3(261.31,170.75) 261.31,170.75 262.26,170.75 263.18,169.83 263.18,156.67 262.09,155.58 259.86,155.58 257.9,153.62 257.9,147.15 G2.Y49
CMDA3: length 26.5
  BOTTOM w0.122: G2.AA52 257.59,153.68 259.97,156.07 261.77,156.07 262.67,156.98 262.67,169.22 261.95,169.95 260.51,169.95 U48.L3
CMDA4: length 28.2
  BOTTOM w0.102: G2.AA51 257.59,148.4 257.28,148.7 257.28,153.76
  BOTTOM w0.122: 257.28,153.76 260.08,156.56 261.48,156.56 262,157.08 262,163.07 261.12,163.96 258.8,163.96 258.12,164.64 258.12,169.96 U48.K5
CMDA5: length 29.7
  BOTTOM w0.102: 257.02,153.88 257.02,148.55 257.27,148.3 257.27,147.94 257.59,147.63 G2.AA50
  BOTTOM w0.122: 257.02,153.88 260.19,157.05 260.7,157.05 261.5,157.85 261.5,162.86 260.91,163.45 258.92,163.45 257.85,164.52 257.85,170.24 258.36,170.75 258.91,170.75 U48.K4
