# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Nets (continued)
MDD15: G2.AG5 U2026.M13
MDD16: G2.Y6 U2026.A11
MDD17: G2.Y5 U2026.A13
MDD18: G2.V5 U2026.B11
MDD19: G2.Y4 U2026.B13
MDD20: G2.AA6 U2026.E11
MDD21: G2.AA5 U2026.E13
MDD22: G2.AC5 U2026.F11
MDD23: G2.AC4 U2026.F13
MDD24: G2.AD7 U2026.A4
MDD25: G2.AC6 U2026.A2
MDD26: G2.AF6 U2026.B4
MDD27: G2.AD6 U2026.B2
MDD28: G2.AF7 U2026.E4
MDD29: G2.AF8 U2026.E2
MDD30: G2.AF2 U2026.F4
MDD31: G2.AF3 U2026.F2
MDD32: G2.F4 U60.A4
MDD33: G2.E1 U60.A2
MDD34: G2.F3 U60.B4
MDD35: G2.F5 U60.B2
MDD36: G2.D2 U60.E4
MDD37: G2.D1 U60.E2
MDD38: G2.C3 U60.F4
MDD39: G2.C2 U60.F2
MDD40: G2.J5 U60.A11
MDD41: G2.J4 U60.A13
MDD42: G2.L8 U60.B11
MDD43: G2.J2 U60.B13
MDD44: G2.F1 U60.E11
MDD45: G2.F2 U60.E13
MDD46: G2.H4 U60.F11
MDD47: G2.H5 U60.F13
MDD48: G2.V7 U60.U11
MDD49: G2.V8 U60.U13
MDD50: G2.V6 U60.T11
MDD51: G2.V9 U60.T13
MDD52: G2.U4 U60.N11
MDD53: G2.R5 U60.N13
MDD54: G2.R6 U60.M11
MDD55: G2.U8 U60.M13
MDD56: G2.P6 U60.U4
MDD57: G2.R9 U60.U2
MDD58: G2.P4 U60.T4
MDD59: G2.P5 U60.T2
MDD60: G2.L7 U60.N4
MDD61: G2.L6 U60.N2
MDD62: G2.L4 U60.M4
MDD63: G2.L5 U60.M2
MDI_N0: D7.6 TL1.3 U6.12
MDI_N1: D7.3 TL1.6 U6.15
MDI_N2: D6.6 TL1.9 U6.18
MDI_N3: D6.3 TL1.12 U6.21
MDI_P0: D7.1 TL1.2 U6.11
MDI_P1: D7.4 TL1.5 U6.14
MDI_P2: D6.1 TL1.8 U6.17
MDI_P3: D6.4 TL1.11 U6.20
MDO_N0: JRJ1.2 TL1.22
MDO_N1: JRJ1.6 TL1.19
MDO_N2: JRJ1.5 TL1.16
MDO_N3: JRJ1.8 TL1.13
MDO_P0: JRJ1.1 TL1.23
MDO_P1: JRJ1.3 TL1.20
MDO_P2: JRJ1.4 TL1.17
MDO_P3: JRJ1.7 TL1.14
ME_FLASH: R2286.1 U5.A9
MIC1_VREF_L: R846.1 U7.38
MIC1_VREF_R: R845.1 U7.39
MIC1L_RING2: JIO1.67 JIO1.68 JIO1.69 R846.2 U7.36
MIC1R_SLEEVE: JIO1.64 JIO1.65 JIO1.66 R845.2 U7.37
MIC2_VREF: D9.2 D10.2 U7.40
MIC2L: C510.1 U7.35
MIC2L_C: JIO1.74 R848.2 R849.1
MIC2R: C511.1 U7.34
MIC2R_C: JIO1.75 R847.2 R850.1
MIC_JD: JIO1.62 R312.2
MPHY_EXT_PWR_GATE_N: TP76.1(TP-1) U2.AN24
MX0: JEC1.15 U5.J12
MX1: JEC1.26 U5.J13
MX2: JEC1.19 U5.J9
MX3: JEC1.18 U5.H12
MX4: JEC1.22 U5.H9
MX5: JEC1.21 U5.H10
MX6: JEC1.24 TP147.1 U5.H13
MX7: JEC1.25 TP152.1 U5.G9
MXLID_N: C416.2 R369.1 U5.A3
MY0: JEC1.20 U5.M8
MY1: JEC1.16 U5.J7
MY2: JEC1.14 U5.N9
MY3: JEC1.9 U5.M9
MY4: JEC1.13 U5.K8
MY5: JEC1.17 U5.J8
MY6: JEC1.10 U5.N10
MY7: JEC1.12 U5.M10
MY8: JEC1.11 U5.N11
MY9: JEC1.23 U5.K9
MY10: JEC1.4 U5.N12
MY11: JEC1.5 U5.N13
MY12: JEC1.8 U5.M13
MY13: JEC1.7 U5.L12
MY14: JEC1.6 U5.L13
MY15: JEC1.3 U5.K12
NBSWON_N: JIO1.50 R250.2 R854.1 U5.B4
NOVO_BTN_N: JIO1.51 R249.2 R265.2
NOVO_BTN_N_R: R265.1 U5.A5
NVVDD_PSI: G2.BD2 PR820.2 PR3528.1 PR3570.2 R977.2
NVVDD_PWM_VID: G2.BD6 PR1467.1
NVVDDS_B+: PC3511.1 PC3512.1 PC3520.1 PC3521.1 PC3522.1 PC3523.1 PC3524.1 PC3525.1 PC3526.1 PC3527.1 PQ1411.1 PQ1412.1 PR3552.1
NVVDDS_BS1: PR3434.1 PU1604.1
NVVDDS_BS2: PR3445.1 PU1604.15
NVVDDS_COMP: PC3516.1 PR3444.1 PR3446.1 PU1604.12
NVVDDS_EN_R: PC3505.1 PR3550.1 PU1604.3
NVVDDS_FB: PC3516.2 PC3571.2 PR3438.1 PR3441.1 PR3573.2 PR3579.2 PU1604.11
NVVDDS_FBRTN: PC3506.1 PR3436.1 PR3448.1 PU1604.10
NVVDDS_FS: PR3440.2 PU1604.9
NVVDDS_HG1: PR3591.1 PU1604.2
NVVDDS_HG1_R: PQ1411.3 PR3591.2
NVVDDS_HG2: PR3592.1 PU1604.14
NVVDDS_HG2_R: PQ1412.3 PR3592.2
NVVDDS_LG1: PR3593.1 PU1604.19
NVVDDS_LG1_R: PQ1411.5 PR3593.2
NVVDDS_LG2: PR3594.1 PU1604.17
NVVDDS_LG2_R: PQ1412.5 PR3594.2
NVVDDS_PEX_EN: D2009.2 D2010.2 D2020.2 PR715.2 PR3550.2 R1009.1 R2244.2 R2334.2
NVVDDS_PEX_EN_N: Q92.5 Q92.6 Q104.4 R1010.2
NVVDDS_PH1: PL1808.1 PQ1411.6 PQ1411.7 PQ1411.8 PR3447.1
NVVDDS_PH2: PL1809.1 PQ1412.6 PQ1412.7 PQ1412.8 PR3443.1
NVVDDS_PSI: G2.BE5 PR3456.2 R1002.2
NVVDDS_PSI_R: PR3428.2 PR3454.2 PR3456.1 PR3570.1 PU1604.4
NVVDDS_PVCC: PC3509.1 PR3442.2 PU1604.18
NVVDDS_PWM_VID: G2.BE4 PR3439.1
NVVDDS_PWROK: D71.1 D2013.2 D2017.2 PR3426.2 Q97.2 R2263.2
NVVDDS_PWROK_N: Q97.3 Q97.6 Q98.2 R2261.2
NVVDDS_REFIN: PC3570.1 PR3432.1 PR3540.2 PU1604.7
NVVDDS_SN1: PC3508.1 PR3447.2
NVVDDS_SN2: PC3513.1 PR3443.2
NVVDDS_TGR1: PC3515.2 PQ1411.4 PU1604.20
NVVDDS_TGR2: PC3519.2 PQ1412.4 PU1604.16
NVVDDS_VID_R: PC3510.1 PR3439.2 PU1604.5
NVVDDS_VIDBUF: PR3433.2 PU1604.6
NVVDDS_VREF: PC3507.1 PR3431.1 PU1604.8
OC_WARN: G2.BB4 PR31.2 PR35.2 R986.2
PA_USB2_RBIAS: R2046.1 U2005.H19
PB_USB2_RBIAS: R2047.2 U2005.F19
PC_BEEP: C330.1 U7.23
PCH_2_CPU_TRIGGER: R203.1 U1.H23
PCH_2_CPU_TRIGGER_R: R203.2 U2.AL2
PCH_CLKRUN_N: R136.2 U2.AW22
PCH_CS0_N: R937.2 RP4.1 U2.BD31 U3.1
PCH_GPP_B23: R547.2 U2.AT27
PCH_GPP_E8: TP160.1(TP-1) U2.AD44
PCH_GPP_F6: TP170.1(TP-1) U2.AB42
PCH_GPP_F7: TP171.1(TP-1) U2.AB43
PCH_GPP_F8: TP168.1(TP-1) U2.AB36
PCH_GPP_F9: TP169.1(TP-1) U2.AB39
PCH_GPP_G18: R303.1 TP122.1(TP-1) U2.N43
PCH_HOLD_N: R120.1 R126.1 U2.BD30
PCH_HOLD_N_R: R118.1 R120.2 U3.7
PCH_I2C_CLK0: R109.1 R321.1 U2.AR38
PCH_I2C_CLK1: R106.1 R879.2 U2.AR41
PCH_I2C_CLK2: R548.2 U2.AK44 U5.N2
PCH_I2C_DATA0: R111.1 R320.1 U2.AT42
PCH_I2C_DATA1: R107.1 R880.2 U2.AR44
PCH_I2C_DATA2: R549.2 U2.AK45 U5.M3
PCH_INTRUDER_N: R114.2 U2.BE11
PCH_ITP_PMODE: R596.2 TP61.1(TP-1) U2.AT2
PCH_JTAG_TCK: TP79.1(TP-1) U2.AN3
PCH_JTAG_TDI: R306.1 U2.AP2
PCH_JTAG_TDO: R507.1 U2.AP1
PCH_JTAG_TMS: R216.1 U2.AR2
PCH_JTAGX: R220.1 U2.AR3
PCH_LAN_WAKE_N: R288.1 U2.BD11
PCH_PECI: R174.1 U2.AL3
PCH_PLTRST_N: C180.1 R117.1 R835.2 U2.BB27 U4.1 U4.2
PCH_PWRBTN_N: D3.2 R381.2 TP58.1(TP-1) U2.AT13
PCH_PWRBTN_N_R: D3.1 U5.M2
PCH_RTC_X1: C205.2 R192.2 U2.BC9 Y1.1
PCH_RTC_X2: C208.2 R192.1 U2.BD10 Y1.2
PCH_SCK: R122.1 R938.2 U2.BC31
PCH_SCK_R: R122.2 RP4.4 U3.6
PCH_SI: R124.1 R125.1 R593.2 R931.2 U2.BB29
PCH_SI_R: R124.2 RP4.2 U3.5
PCH_SMB_CLK: Q1.1 R81.1 R162.2 R573.1 TP64.1(TP-1)
PCH_SMB_DAT: Q1.4 R82.1 R161.2 R572.1 TP63.1(TP-1)
PCH_SO: R119.2 R936.2 U2.BE30
PCH_SO_R: R119.1 RP4.3 U3.2
PCH_THERMTRIP_N: R287.1 U2.AJ3
PCH_TRST_N: R202.1 U2.AY5
PCH_UART2_CTS_N: R535.2 U2.AN43
PCH_UART2_RTS_N: R536.2 U2.AN44
PCH_UART2_RXD: R266.2 TP17.1 U2.AR45
PCH_UART2_TXD: R534.2 TP16.1 U2.AR39
PCH_VRALERT_N: R137.1 U2.BD23
PCH_WP_N: R116.1 R121.2 R594.2 U2.BC29
PCH_WP_N_R: R121.1 U3.3
PCH_XDP_PRDY_N: R201.1 U2.AT4
PCH_XDP_PREQ_N: R200.1 U2.AT3
PCH_XTAL24_IN: C206.1 R190.2 U2.A6 Y2.1
PCH_XTAL24_OUT: C207.1 R190.1 U2.A5 Y2.3
PCIE1_TBT_RX_DN0: C2030.1 U2.H15
PCIE1_TBT_RX_DP0: C2028.1 U2.G15
PCIE1_TBT_TX_DN0: C2029.2 U2.A16
PCIE1_TBT_TX_DP0: C2027.2 U2.B16
PCIE2_TBT_RX_DN1: C2034.1 U2.E17
PCIE2_TBT_RX_DP1: C2032.1 U2.G17
PCIE2_TBT_TX_DN1: C2033.2 U2.B19
PCIE2_TBT_TX_DP1: C2031.2 U2.C19
PCIE3_TBT_RX_DN2: C2038.1 U2.L17
PCIE3_TBT_RX_DP2: C2036.1 U2.K17
PCIE3_TBT_TX_DN2: C2037.2 U2.B20
PCIE3_TBT_TX_DP2: C2035.2 U2.C20
PCIE4_TBT_RX_DN3: C2042.1 U2.E20
PCIE4_TBT_RX_DP3: C2040.1 U2.G19
PCIE4_TBT_TX_DN3: C2041.2 U2.B21
PCIE4_TBT_TX_DP3: C2039.2 U2.A21
PCIE9_SSD2_RX_DN0: R482.1 U2.G31
PCIE9_SSD2_RX_DP0: R481.1 U2.H31
PCIE9_SSD2_RX_R_DN0: JSSD2.43 R482.2
PCIE9_SSD2_RX_R_DP0: JSSD2.41 R481.2
PCIE9_SSD2_TX_C_DN0: C197.1 JSSD2.47
PCIE9_SSD2_TX_C_DP0: C198.1 JSSD2.49
PCIE9_SSD2_TX_DN0: C197.2 U2.C31
PCIE9_SSD2_TX_DP0: C198.2 U2.B31
PCIE10_SSD2_RX_DN1: JSSD2.29 U2.G29
PCIE10_SSD2_RX_DP1: JSSD2.31 U2.E29
PCIE10_SSD2_TX_C_DN1: C199.1 JSSD2.35
PCIE10_SSD2_TX_C_DP1: C200.1 JSSD2.37
PCIE10_SSD2_TX_DN1: C199.2 U2.C32
PCIE10_SSD2_TX_DP1: C200.2 U2.B32
PCIE11_SSD2_RX_DN2: JSSD2.17 U2.L31
PCIE11_SSD2_RX_DP2: JSSD2.19 U2.K31
PCIE11_SSD2_TX_C_DN2: C201.1 JSSD2.23
PCIE11_SSD2_TX_C_DP2: C202.1 JSSD2.25
PCIE11_SSD2_TX_DN2: C201.2 U2.C33
PCIE11_SSD2_TX_DP2: C202.2 U2.B33
PCIE12_SSD2_RX_DN3: JSSD2.5 U2.G33
PCIE12_SSD2_RX_DP3: JSSD2.7 U2.H33
PCIE12_SSD2_TX_C_DN3: C203.1 JSSD2.11
PCIE12_SSD2_TX_C_DP3: C204.1 JSSD2.13
PCIE12_SSD2_TX_DN3: C203.2 U2.B35
PCIE12_SSD2_TX_DP3: C204.2 U2.A35
PCIE13_SSD1_RX_DN0: JSSD1.41 U2.G35
PCIE13_SSD1_RX_DP0: JSSD1.43 U2.E35
PCIE13_SSD1_TX_C_DN0: C189.1 JSSD1.47
PCIE13_SSD1_TX_C_DP0: C190.1 JSSD1.49
PCIE13_SSD1_TX_DN0: C189.2 U2.C36
PCIE13_SSD1_TX_DP0: C190.2 U2.B36
PCIE14_SSD1_RX_DN1: JSSD1.29 U2.D39
PCIE14_SSD1_RX_DP1: JSSD1.31 U2.E37
PCIE14_SSD1_TX_C_DN1: C191.1 JSSD1.35
PCIE14_SSD1_TX_C_DP1: C192.1 JSSD1.37
PCIE14_SSD1_TX_DN1: C191.2 U2.B38
PCIE14_SSD1_TX_DP1: C192.2 U2.C38
PCIE15_SSD1_RX_DN2: JSSD1.17 U2.F41
PCIE15_SSD1_RX_DP2: JSSD1.19 U2.E41
PCIE15_SSD1_TX_C_DN2: C193.1 JSSD1.23
PCIE15_SSD1_TX_C_DP2: C194.1 JSSD1.25
PCIE15_SSD1_TX_DN2: C193.2 U2.B39
PCIE15_SSD1_TX_DP2: C194.2 U2.A39
PCIE16_SSD1_RX_DN3: JSSD1.5 U2.D43
PCIE16_SSD1_RX_DP3: JSSD1.7 U2.E42
PCIE16_SSD1_TX_C_DN3: C195.1 JSSD1.11
PCIE16_SSD1_TX_C_DP3: C196.1 JSSD1.13
PCIE16_SSD1_TX_DN3: C195.2 U2.A41
PCIE16_SSD1_TX_DP3: C196.2 U2.A40
PCIE_AR_RST_N: R2101.1 U2005.L4
PCIE_CR_RX_DN: JIO1.24 U2.G22
PCIE_CR_RX_DP: JIO1.23 U2.E22
PCIE_CR_TX_C_DN: C181.1 JIO1.21
PCIE_CR_TX_C_DP: C182.1 JIO1.20
PCIE_CR_TX_DN: C181.2 U2.B22
PCIE_CR_TX_DP: C182.2 U2.A23
PCIE_LAN_RX_C_DN: C274.2 U6.29
PCIE_LAN_RX_C_DP: C275.2 U6.30
PCIE_LAN_RX_DN: C274.1 U2.K24
PCIE_LAN_RX_DP: C275.1 U2.L24
PCIE_LAN_TX_C_DN: C185.1 U6.36
PCIE_LAN_TX_C_DP: C186.1 U6.35
PCIE_LAN_TX_DN: C185.2 U2.C24
PCIE_LAN_TX_DP: C186.2 U2.B24
PCIE_RBIAS: R2015.1 U2005.N16
PCIE_RCOMPN: R129.1 U2.B18
PCIE_RCOMPP: R129.2 U2.C17
PCIE_SSD1_CLKREQ_N: JSSD1.52 Q9.1 R512.1
PCIE_SSD1_RST_N: JSSD1.50 R478.1
PCIE_SSD2_CLKREQ_N: JSSD2.52 Q9.4 R508.1
PCIE_SSD2_RST_N: JSSD2.50 R483.1
PCIE_WAKE_N: R138.1 R459.1 R2094.2 U2.BC13
PCIE_WLAN_RX_DN: JWLAN1.43 U2.L22
PCIE_WLAN_RX_DP: JWLAN1.41 U2.K22
PCIE_WLAN_TX_C_DN: C183.1 JWLAN1.37
PCIE_WLAN_TX_C_DP: C184.1 JWLAN1.35
PCIE_WLAN_TX_DN: C183.2 U2.C23
PCIE_WLAN_TX_DP: C184.2 U2.B23
PEG_PRX_C_GTX_N0: C662.1 G2.BH26
PEG_PRX_C_GTX_N1: C664.1 G2.BE26
PEG_PRX_C_GTX_N2: C654.1 G2.BG27
PEG_PRX_C_GTX_N3: C671.1 G2.BH29
PEG_PRX_C_GTX_N4: C673.1 G2.BE29
PEG_PRX_C_GTX_N5: C675.1 G2.BG30
PEG_PRX_C_GTX_N6: C680.1 G2.BH32
PEG_PRX_C_GTX_N7: C682.1 G2.BE32
PEG_PRX_C_GTX_N8: C868.1 G2.BG33
PEG_PRX_C_GTX_N9: C870.1 G2.BH35
PEG_PRX_C_GTX_N10: C875.1 G2.BE35
PEG_PRX_C_GTX_N11: C877.1 G2.BG36
PEG_PRX_C_GTX_N12: C879.1 G2.BH38
PEG_PRX_C_GTX_N13: C881.1 G2.BE38
PEG_PRX_C_GTX_N14: C884.1 G2.BG39
PEG_PRX_C_GTX_N15: C885.1 G2.BG41
PEG_PRX_C_GTX_P0: C650.1 G2.BG26
PEG_PRX_C_GTX_P1: C663.1 G2.BF26
PEG_PRX_C_GTX_P2: C653.1 G2.BF27
PEG_PRX_C_GTX_P3: C670.1 G2.BG29
PEG_PRX_C_GTX_P4: C672.1 G2.BF29
PEG_PRX_C_GTX_P5: C674.1 G2.BF30
PEG_PRX_C_GTX_P6: C679.1 G2.BG32
PEG_PRX_C_GTX_P7: C681.1 G2.BF32
PEG_PRX_C_GTX_P8: C869.1 G2.BF33
PEG_PRX_C_GTX_P9: C874.1 G2.BG35
PEG_PRX_C_GTX_P10: C876.1 G2.BF35
PEG_PRX_C_GTX_P11: C878.1 G2.BF36
PEG_PRX_C_GTX_P12: C880.1 G2.BG38
PEG_PRX_C_GTX_P13: C882.1 G2.BF38
PEG_PRX_C_GTX_P14: C883.1 G2.BF39
PEG_PRX_C_GTX_P15: C886.1 G2.BH41
PEG_PRX_GTX_N0: C662.2 U1.E10
PEG_PRX_GTX_N1: C664.2 U1.E11
PEG_PRX_GTX_N2: C654.2 U1.E12
PEG_PRX_GTX_N3: C671.2 U1.E13
PEG_PRX_GTX_N4: C673.2 U1.E14
PEG_PRX_GTX_N5: C675.2 U1.E15
PEG_PRX_GTX_N6: C680.2 U1.E16
PEG_PRX_GTX_N7: C682.2 U1.E17
PEG_PRX_GTX_N8: C868.2 U1.F18
PEG_PRX_GTX_N9: C870.2 U1.D19
PEG_PRX_GTX_N10: C875.2 U1.F20
PEG_PRX_GTX_N11: C877.2 U1.D21
PEG_PRX_GTX_N12: C879.2 U1.F22
PEG_PRX_GTX_N13: C881.2 U1.D23
PEG_PRX_GTX_N14: C884.2 U1.F24
PEG_PRX_GTX_N15: C885.2 U1.D25
PEG_PRX_GTX_P0: C650.2 U1.F10
PEG_PRX_GTX_P1: C663.2 U1.D11
PEG_PRX_GTX_P2: C653.2 U1.F12
PEG_PRX_GTX_P3: C670.2 U1.D13
PEG_PRX_GTX_P4: C672.2 U1.F14
PEG_PRX_GTX_P5: C674.2 U1.D15
PEG_PRX_GTX_P6: C679.2 U1.F16
PEG_PRX_GTX_P7: C681.2 U1.D17
PEG_PRX_GTX_P8: C869.2 U1.E18
PEG_PRX_GTX_P9: C874.2 U1.E19
PEG_PRX_GTX_P10: C876.2 U1.E20
PEG_PRX_GTX_P11: C878.2 U1.E21
PEG_PRX_GTX_P12: C880.2 U1.E22
PEG_PRX_GTX_P13: C882.2 U1.E23
PEG_PRX_GTX_P14: C883.2 U1.E24
PEG_PRX_GTX_P15: C886.2 U1.E25
PEG_PTX_C_GRX_N0: C32.1 G2.BK27
PEG_PTX_C_GRX_N1: C30.1 G2.BL29
PEG_PTX_C_GRX_N2: C28.1 G2.BM30
PEG_PTX_C_GRX_N3: C26.1 G2.BK30
PEG_PTX_C_GRX_N4: C24.1 G2.BL32
PEG_PTX_C_GRX_N5: C22.1 G2.BM33
PEG_PTX_C_GRX_N6: C20.1 G2.BK33
PEG_PTX_C_GRX_N7: C18.1 G2.BL35
PEG_PTX_C_GRX_N8: C16.1 G2.BM36
PEG_PTX_C_GRX_N9: C14.1 G2.BK36
PEG_PTX_C_GRX_N10: C12.1 G2.BL38
PEG_PTX_C_GRX_N11: C10.1 G2.BM39
PEG_PTX_C_GRX_N12: C8.1 G2.BK39
PEG_PTX_C_GRX_N13: C6.1 G2.BL41
PEG_PTX_C_GRX_N14: C4.1 G2.BM42
PEG_PTX_C_GRX_N15: C2.1 G2.BK42
PEG_PTX_C_GRX_P0: C31.1 G2.BL27
PEG_PTX_C_GRX_P1: C29.1 G2.BK29
PEG_PTX_C_GRX_P2: C27.1 G2.BM29
PEG_PTX_C_GRX_P3: C25.1 G2.BL30
PEG_PTX_C_GRX_P4: C23.1 G2.BK32
PEG_PTX_C_GRX_P5: C21.1 G2.BM32
PEG_PTX_C_GRX_P6: C19.1 G2.BL33
PEG_PTX_C_GRX_P7: C17.1 G2.BK35
PEG_PTX_C_GRX_P8: C15.1 G2.BM35
PEG_PTX_C_GRX_P9: C13.1 G2.BL36
PEG_PTX_C_GRX_P10: C11.1 G2.BK38
PEG_PTX_C_GRX_P11: C9.1 G2.BM38
PEG_PTX_C_GRX_P12: C7.1 G2.BL39
PEG_PTX_C_GRX_P13: C5.1 G2.BK41
PEG_PTX_C_GRX_P14: C3.1 G2.BM41
PEG_PTX_C_GRX_P15: C1.1 G2.BL42
PEG_PTX_GRX_N0: C32.2 U1.B10
PEG_PTX_GRX_N1: C30.2 U1.B11
PEG_PTX_GRX_N2: C28.2 U1.B12
PEG_PTX_GRX_N3: C26.2 U1.B13
PEG_PTX_GRX_N4: C24.2 U1.B14
PEG_PTX_GRX_N5: C22.2 U1.B15
PEG_PTX_GRX_N6: C20.2 U1.B16
PEG_PTX_GRX_N7: C18.2 U1.B17
PEG_PTX_GRX_N8: C16.2 U1.C18
PEG_PTX_GRX_N9: C14.2 U1.A19
PEG_PTX_GRX_N10: C12.2 U1.C20
PEG_PTX_GRX_N11: C10.2 U1.A21
PEG_PTX_GRX_N12: C8.2 U1.C22
PEG_PTX_GRX_N13: C6.2 U1.A23
PEG_PTX_GRX_N14: C4.2 U1.C24
PEG_PTX_GRX_N15: C2.2 U1.A25
PEG_PTX_GRX_P0: C31.2 U1.C10
PEG_PTX_GRX_P1: C29.2 U1.A11
PEG_PTX_GRX_P2: C27.2 U1.C12
PEG_PTX_GRX_P3: C25.2 U1.A13
PEG_PTX_GRX_P4: C23.2 U1.C14
PEG_PTX_GRX_P5: C21.2 U1.A15
PEG_PTX_GRX_P6: C19.2 U1.C16
PEG_PTX_GRX_P7: C17.2 U1.A17
PEG_PTX_GRX_P8: C15.2 U1.B18
PEG_PTX_GRX_P9: C13.2 U1.B19
PEG_PTX_GRX_P10: C11.2 U1.B20
PEG_PTX_GRX_P11: C9.2 U1.B21
PEG_PTX_GRX_P12: C7.2 U1.B22
PEG_PTX_GRX_P13: C5.2 U1.B23
PEG_PTX_GRX_P14: C3.2 U1.B24
PEG_PTX_GRX_P15: C1.2 U1.B25
PEG_RCOMP: R1.2 U1.G2
PLT_RST_N: JIO1.17 R117.2 R123.2 R237.1 R274.1 R458.2 R478.2 R483.2 R840.2 R2096.1 R2099.1 R2101.2 U4.4 U63.1
PM_BATLOW_N: R139.2 U2.BD13
PM_PCH_PWROK: R147.2 R262.2 U2.AW11
PM_PCH_PWROK_R: R262.1 U5.C1
PM_RSMRST_N: R149.2 U2.AV11 U2.BA11 U5.N3
POST_I2C_CLK: R319.2 R321.2 U7.12 U8.17
POST_I2C_DATA: R318.2 R320.2 U7.11 U8.16
POST_I2S_BCLK: C336.1 R298.1 U8.23
POST_I2S_IN: C333.1 R322.1 U7.5
POST_I2S_LRCLK: C335.1 R301.1 U8.25
POST_I2S_MCLK: C337.1 R296.1 U8.22
POST_I2S_OUT: C334.1 R302.1 U8.24
PROC_SELECT_N: R21.2 U1.BN1
PS1_NVVDD_EN: PR30.1 PU5.10
PSYS: PR216.1 PR226.1 PR1192.1 PU1101.29 U5.F12
PWM1_VCC: PR1599.2 PU1101.34
PWM1A_ICCMAX: PR1193.1 PR1632.2 PU1101.30
PWM2_VCC: PR1622.2 PU1101.33
PWM3_VCC: PR1623.2 PU1101.32
PWM4_VCC: PR1629.2 PU1101.31
PWR_LED_W: JIO1.52 U5.M5
PWR_LEVEL: D2011.1 R255.1 U5.N1
PWR_LEVEL_R: D2011.2 D2016.2 G2.BE6 R983.1
PWR_SRC_CRTCAL_N: PR25.1 PR27.1 PR35.1 PU5.9
PWR_SRC_WARN_N: PR31.1 PR32.1 PU5.8
REGN: PC215.1 PR214.2 PR222.2 PR223.2 PU201.20
REMOTE1_N: C634.1 C635.2 Q10.3 U25.3
REMOTE1_P: C634.2 C635.1 Q10.1 Q10.2 U25.2
REMOTE2_N: C636.1 C638.2 Q24.3 U25.5
REMOTE2_P: C636.2 C638.1 Q24.1 Q24.2 U25.4
RF_KILL_BT_N: R102.1 R484.2 U2.BC23
RF_KILL_WIFI_N: R99.1 R517.2 U2.BD24
ROM_CS: G2.BJ4 R2168.2
ROM_CS_R: R944.1 R2168.1 U2021.1
ROM_SCLK: G2.BK3 R2154.2 R2155.2 R2209.1
ROM_SCLK_R: R2209.2 U2021.6
ROM_SI: G2.BK2 R929.1 R2150.2 R2151.2
ROM_SI_R: R929.2 U2021.5
ROM_SO: G2.BK4 R928.1 R2152.2 R2153.2
ROM_SO_R: R928.2 U2021.2
RTCRST_N: C188.1 Q12.1 R163.1 TP77.1 U2.BC10
RTD3_CIO_PWR_EN_R: R2041.1 R2042.1 R2282.1 U2005.F1
RTD3_USB_PWR_EN_R: R2043.1 R2044.1 U2005.D4
SATA_A_DE: R466.1 R472.2 U14.9
SATA_A_EQ1: R470.1 R476.2 U14.17
SATA_A_EQ2: R469.1 R475.2 U14.18
SATA_B_DE: R465.1 R471.2 U14.8
SATA_B_EQ1: R468.1 R474.2 U14.19
SATA_B_EQ2: R467.1 R473.2 U14.13
SATA_REXT: R463.1 U14.6
SATA_RX__R_N0: R2234.1 U14.12
SATA_RX__R_P0: R2115.1 U14.11
SATA_RX_C_DN0: C567.2 U14.4
SATA_RX_C_DP0: C571.2 U14.5
SATA_RX_C_N0: C569.2 JHDD1.4
SATA_RX_C_P0: C570.2 JHDD1.5
SATA_RX_DN0: C567.1 R2233.1 U2.H42
SATA_RX_DP0: C571.1 R2110.1 U2.H40
SATA_RX_N0: C569.1 R2230.2 R2234.2
SATA_RX_P0: C570.1 R2115.2 R2231.2
SATA_TX__R_N0: R2113.1 U14.14
SATA_TX__R_P0: R2112.1 U14.15
SATA_TX_C_DN0: C566.2 U14.2
SATA_TX_C_DP0: C565.2 U14.1
SATA_TX_C_N0: C568.2 JHDD1.2
SATA_TX_C_P0: C564.2 JHDD1.1
SATA_TX_DN0: C566.1 R2106.1 U2.E45
SATA_TX_DP0: C565.1 R2229.1 U2.F45
SATA_TX_N0: C568.1 R2107.2 R2113.2
SATA_TX_P0: C564.1 R2112.2 R2232.2
SENSOR_INT_N: R552.2 U23.C2 U24.C2
SERIRQ: R179.1 R294.1 U2.BA17
SERIRQ_R: R294.2 U5.G2
SLP_S3_N: R144.2 R2033.1 U5.A12
SLP_S3_N_R: R144.1 U2.AW15
SLP_S4_N: PD401.1 R145.2 U5.A13
SLP_S4_N_R: R145.1 U2.BD15
SLP_S5_N: TP71.1(TP-1) U2.BA13
SLP_SUS_N: TP74.1(TP-1) U2.BB13
SMB_CLK: PR430.1 Q1.6 R153.1 U2.AW44
SMB_CLK_GPU: G2.BJ8 Q80.1 R2294.1
SMB_DATA: PR426.1 Q1.3 R155.1 U2.BB43
SMB_DATA_GPU: G2.BH8 Q80.4 R2295.1
SMBALERT_N: R169.2 U2.BB41
SML0_CLK: R150.1 U2.AY44
SML0_DATA: R151.1 U2.BB39
SML0ALERT_N: R170.1 R372.1 U2.BA40
SML1_CLK: Q2.6 R158.1 U2.AW42
SML1_DATA: Q2.3 R159.1 U2.AW45
SNUB_3V: PC313.1 PR310.2
SNUB_5V: PC314.1 PR311.2
SPDIF_OUT: TP103.1(TP-1) U7.2
SPK_CON_L+: C356.2 JSPKR1.2 R68.1
SPK_CON_L-: C357.2 JSPKR1.1 R69.1
SPK_CON_R+: C359.2 JSPKR1.4 R66.1
SPK_CON_R-: C355.2 JSPKR1.3 R67.1
SPK_L+: TP91.1(TP-1) U7.49
SPK_L-: TP92.1(TP-1) U7.50
SPK_R+: R343.2 U7.47
SPK_R-: R339.2 U7.48
SPKR_LED_GND: JSPBL1.6 L2014.1 L2015.1
SRTCRST_N: C187.1 R160.1 U2.BB10
SSD1_DAS: JSSD1.10 TP99.1(TP-1)
SSD2_DAS_DSS: JSSD2.10 TP100.1(TP-1)
STRAP0: G2.BL3 R2156.2 R2162.1
STRAP1: G2.BL4 R2157.2 R2163.1
STRAP2: G2.BM4 R2158.2 R2164.1
STRAP3: G2.BM5 R2159.2 R2165.1
STRAP4: G2.BK5 R2160.2 R2166.1
STRAP5: G2.BJ5 R2161.2 R2167.1
SUSACK_N: TP72.1(TP-1) U2.BB19
SUSCLK: R148.1 R456.2 U2.AN15
SUSON: JIO1.47 PR425.2 PR1317.1 PR1408.1 R258.2 R496.1 R873.1 U5.E2
SUSON_N: PQ1404.5 PQ1404.6 PR1406.1
SUSPWRDNACK: TP73.1(TP-1) U2.BD19
SW1_3PH_A: PR1145.2 PR1185.1 PR1504.2
SW1_5V: PL302.1 PQ302.6 PQ302.7 PQ302.8 PR311.1
SW2_3PH_A: PR1149.2 PR1184.1 PR1513.2
SW2_3V: PL301.2 PQ301.6 PQ301.7 PQ301.8 PR310.1
SW3_3PH_A: PR1151.2 PR1183.1 PR1604.2
SW4_3PH_A: PR1147.2 PR1205.1 PR1612.2
SW_1PH: PR1154.2 PR1212.1 PR1618.2
SWD_CLK: R2092.1 U2007.G4
SWD_DAT: R2091.1 U2007.F4
SWF_AVDD: C366.2 R329.1 R335.1 U9.7
SWF_CON_R+: C377.2 JSWF1.2 R71.1
SWF_CON_R-: C378.2 JSWF1.1 R70.1
SWF_GAIN0: R341.1 R345.2 U9.5
SWF_GAIN1: R342.1 R348.2 U9.6
SWF_PLIMIT: C375.2 R331.1 R332.2 U9.10
SWF_R+: C374.1 R71.2 R333.1 U9.23 U9.25
SWF_R-: C376.1 R70.2 R334.1 U9.18 U9.20
SWF_RINN: C381.2 U9.11
SWF_RINP: C384.2 U9.12
SWF_SD_N: R330.1 U9.1 U9.2
SWF_VCLAMP: C373.2 R332.1 U9.9
SYS_PEX_RST_MON_N: G2.BE2 R999.2 R2171.1 U62.2
SYS_PWROK: R146.1 R263.2 U2.AY1
SYS_PWROK_R: R263.1 U5.D6
SYS_RESET_N: R143.1 R178.1 U2.AW1
TBT_BATLOW_N: R2036.1 U2005.F2
TBT_CIO_PLUG_EVENT_N: R2031.1 U2.L43
TBT_CIO_PLUG_EVENT_N_R: R2031.2 R2053.1 U2005.W2
TBT_CIO_PWR_EN: R2041.2 U2.R35
TBT_EE_CLK: R2287.1 U2005.AB4 U2012.6
TBT_EE_CS_N: R2019.1 R2290.1 U2005.AC3 U2012.1
TBT_EE_DI: R2288.1 U2005.AB3 U2012.5
TBT_EE_DO: R2018.1 R2289.1 U2005.AC4 U2012.2
TBT_EE_WP_N: R2017.1 U2005.V1 U2012.3
TBT_FORCE_PWR: R2039.2 R2097.1 U2.U35
TBT_FORCE_PWR_R: R2039.1 R2040.1 U2005.H4
TBT_HDMI_DDC_CLK: R2283.1 U2005.Y2
TBT_HDMI_DDC_DATA: R2284.1 U2005.Y1
TBT_HOLD_N: R2020.1 U2012.7
TBT_I2C_SCL: R2028.1 U2005.U2 U2007.D2
TBT_I2C_SDA: R2026.1 U2005.U1 U2007.D1
TBT_PROC_GPIO1: R2024.1 U2005.E2
TBT_RBIAS: R2035.2 U2005.H6
TBT_RESET_N: R2030.2 U2007.F11
TBT_RESET_N_R: R2030.1 U2005.F4
TBT_RSENSE: R2035.1 U2005.J6
TBT_SLP_S3_N: R2033.2 R2034.1 U2005.D2
TBT_SNK0_CFG1: R2082.1 U2005.N4
TBT_SNK0_DDC_CLK: R2118.1 U2005.Y5
TBT_SNK0_DDC_DATA: R2119.1 U2005.R4
TBT_SNK1_DDC_CLK: R2054.1 U2005.Y8
TBT_SRC_CFG1: R2023.1 R2120.2 U2005.AA1
TBT_SRC_HPD: R2121.2 U2005.G1
TBT_SVR_IND: PL2001.1 U2005.C1 U2005.C2 U2005.D1
TBT_TCK: R2013.1 U2005.T4
TBT_TDI: R2011.1 U2005.Y4
TBT_TDO: R2014.1 U2005.W4
TBT_TEST_EN: R2025.1 U2005.E1
TBT_TEST_PWG: R2027.1 U2005.AB5
TBT_TMS: R2012.1 U2005.V4
TBT_TMU_CLK_OUT: R2038.1 U2005.V2
TBT_USB_PWR_EN: R2043.2 U2.L44
TBT_WAKE_N: R2094.1 U2005.W1
TBT_XTAL_25_IN: C2048.1 R2010.2 U2005.D22 Y2001.1
TBT_XTAL_25_OUT: C2046.1 R2010.1 U2005.D23 Y2001.3
TBTA_CC1: C2130.1 D59.2 JTYPC1.A5 U2007.L9
TBTA_CC2: C2129.1 D56.2 JTYPC1.B5 U2007.L10
TBTA_DEBUG1: R2075.2 U2007.L2
TBTA_DEBUG2: R2076.2 U2007.K2
TBTA_DEBUG3: R2071.2 U2007.L3
TBTA_DEBUG4: R2072.2 U2007.K3
TBTA_DPSRC_AUX_N: C2071.2 R2069.2 U2007.J2
TBTA_DPSRC_AUX_P: C2070.2 R2080.1 U2007.J1
TBTA_HPD: R2049.1 R2063.1 U2005.M4
TBTA_I2C_INT: R2037.1 U2005.J4 U2007.C1
TBTA_LDO_BMC: C2117.1 U2007.E1
TBTA_LSRX: R2045.2 R2088.1 U2005.A4
TBTA_LSTX: R2048.2 R2087.1 U2005.A5
TBTA_MRESET_R: R2065.2 R2093.2 R2099.2 R2103.2 U2007.E11
TBTA_ROSC: R2079.1 U2007.G2
TBTA_RX0_N: D62.2 JTYPC1.B11 U2005.A21
TBTA_RX0_P: D63.2 JTYPC1.B10 U2005.B21
TBTA_RX1_N: D66.2 JTYPC1.A10 U2005.B15
TBTA_RX1_P: D67.2 JTYPC1.A11 U2005.A15
TBTA_SBU1: D58.2 JTYPC1.A8 R2089.2
TBTA_SBU2: D57.2 JTYPC1.B8 R2090.1
TBTA_TX0_N: C2069.2 D61.2 JTYPC1.A2
TBTA_TX0_P: C2068.2 D60.2 JTYPC1.A3
TBTA_TX1_N: C2067.2 D65.2 JTYPC1.B3
TBTA_TX1_P: C2066.2 D64.2 JTYPC1.B2
TBTA_UART_RX: R2064.2 U2007.E2 U2007.F2
TBTA_USB2_D_N: U2005.D20 U2007.K5
TBTA_USB2_D_P: U2005.E20 U2007.L5
TBTA_USB2_N_B: D2006.2 JTYPC1.B7 U2007.L7
TBTA_USB2_N_T: D2005.1 JTYPC1.A7 U2007.L6
TBTA_USB2_P_B: D2006.1 JTYPC1.B6 U2007.K7
TBTA_USB2_P_T: D2005.2 JTYPC1.A6 U2007.K6
TBTA_VBUS: C2122.1 C2123.1 C2125.1 C2126.2 C2136.1 D2004.1 JTYPC1.A4 JTYPC1.A9 JTYPC1.B4 JTYPC1.B9 U2007.A10 U2007.B10 U2007.H11 U2007.J10 U2007.J11 U2007.K11
TBTB_HPD: R2050.1 U2005.G2
TBTB_LSRX: R2052.1 U2005.B5
TBTB_LSTX: R2051.1 U2005.B4
TBTB_RX0_N: CM13.2 R500.1 U2005.B13
TBTB_RX0_N_R: CM13.1 D54.5 D54.6 JUSB1.5 R500.2
TBTB_RX0_P: CM13.3 R497.1 U2005.A13
TBTB_RX0_P_R: CM13.4 D54.4 D54.7 JUSB1.6 R497.2
TBTB_TX0_N: C621.1 U2005.B11
TBTB_TX0_N_R: CM14.1 D54.2 D54.9 JUSB1.8 R501.2
TBTB_TX0_P: C648.1 U2005.A11
TBTB_TX0_P_R: CM14.4 D54.1 D54.10 JUSB1.9 R499.2
TBTB_USB2_D_N: CM15.2 R519.1 U2005.D19
TBTB_USB2_D_N_R: CM15.1 D33.2 JUSB1.2 R519.2
TBTB_USB2_D_P: CM15.3 R522.1 U2005.E19
TBTB_USB2_D_P_R: CM15.4 D33.1 JUSB1.3 R522.2
TGR_1.2V: PC401.1 PQ401.4 PU401.16
TGR_3V: PC310.1 PQ301.4 PU301.8
TGR_5V: PC309.2 PQ302.4 PU301.18
THERM_ALERT_N: G2.BJ3 Q93.1 R982.2
THERMDA: U2005.AB23 U2005.AC23
TP_LED_GND: JTPBL1.1 JTPBL1.6 L2009.1 L2010.1
TP_PS2_CLK: R241.1 R576.1 U5.A11
TP_PS2_CLK_R: C643.1 D40.2 JTP1.2 R576.2
TP_PS2_DAT: R242.1 R575.1 U5.B11
TP_PS2_DAT_R: C644.1 D41.2 JTP1.3 R575.2
TP_SKL_BJ13: TP14.1(TP-1) U1.BJ13
TP_SKL_BJ14: TP13.1(TP-1) U1.BJ14
TP_SKL_BJ16: TP20.1(TP-1) U1.BJ16
TP_SKL_BJ24: TP27.1(TP-1) U1.BJ24
TP_SKL_BJ33: TP37.1(TP-1) U1.BJ33
TP_SKL_BJ34: TP35.1(TP-1) U1.BJ34
TP_SKL_BK16: TP22.1(TP-1) U1.BK16
TP_SKL_BK24: TP25.1(TP-1) U1.BK24
TP_SKL_BL33: TP8.1(TP-1) U1.BL33
TP_SKL_BM33: TP6.1(TP-1) U1.BM33
TP_SKL_BR1: TP11.1(TP-1) U1.BR1
TP_SKL_BT2: TP12.1(TP-1) U1.BT2
TP_SKL_D1: TP5.1(TP-1) U1.D1
TP_SKL_E1: TP7.1(TP-1) U1.E1
TP_SKL_E2: TP10.1(TP-1) U1.E2
TP_SKL_E3: TP9.1(TP-1) U1.E3
TP_SMB_CLK: JTP1.5 R573.2
TP_SMB_DAT: JTP1.6 R572.2
TSENSE_1PH_A: PC1163.1 PR1182.2 PU1101.11
TSENSE_3PH_A: PC1162.1 PR1180.2 PU1101.37
TURBO_BTN_N: JKB1.44 R830.2 R832.2
TURBO_GPIO1: R546.1 R833.2
TURBO_GPIO3: R526.1 R844.1
TURBO_LED: JKB1.48 R896.2
UG_3V: PQ301.3 PU301.10
UG_5V: PQ302.3 PU301.16
USB2_CHG_PN: CM12.2 R532.1 U21.11
USB2_CHG_PN_R: CM12.1 D49.2 JUSB2.2 R532.2
USB2_CHG_PP: CM12.3 R533.1 U21.10
USB2_CHG_PP_R: CM12.4 D49.1 JUSB2.3 R533.2
USB2_COMP: R130.1 U2.AG3
USB2_DN1: JIO1.32 U2.AF5
USB2_DN2: U2.AD5 U21.2
USB2_DN3: JCAM1.2 U2.AG8
USB2_DN4: R917.1 U2.AE1
USB2_DN4_R: D48.2 JKB1.40 R917.2
USB2_DN5: JWLAN1.5 U2.AC2
USB2_DN6: JIO1.29 U2.AF2
USB2_DP1: JIO1.33 U2.AG7
USB2_DP2: U2.AD7 U21.3
USB2_DP3: JCAM1.3 U2.AG10
USB2_DP4: R918.1 U2.AE2
USB2_DP4_R: D37.2 JKB1.41 R918.2
USB2_DP5: JWLAN1.3 U2.AC3
USB2_DP6: JIO1.30 U2.AF3
USB2_OTG_ID: R63.2 U2.AG2
USB3_RX_DN1: JIO1.38 U2.B7
USB3_RX_DN3: CM10.2 R530.1 U2.B10
USB3_RX_DN3_R: CM10.1 D53.5 D53.6 JUSB2.5 R530.2
USB3_RX_DN6: JIO1.44 U2.K15
USB3_RX_DP1: JIO1.39 U2.A7
USB3_RX_DP3: CM10.3 R528.1 U2.A9
USB3_RX_DP3_R: CM10.4 D53.4 D53.7 JUSB2.6 R528.2
USB3_RX_DP6: JIO1.45 U2.K13
USB3_TX_DN1: JIO1.35 U2.C11
USB3_TX_DN3: C504.1 U2.C13
USB3_TX_DN3_C: C504.2 CM11.2 R531.1
USB3_TX_DN3_R: CM11.1 D53.2 D53.9 JUSB2.8 R531.2
USB3_TX_DN6: JIO1.41 U2.B15
USB3_TX_DN6_C: C621.2 CM14.2 R501.1
USB3_TX_DP1: JIO1.36 U2.B11
USB3_TX_DP3: C500.1 U2.D13
USB3_TX_DP3_C: C500.2 CM11.3 R529.1
USB3_TX_DP3_R: CM11.4 D53.1 D53.10 JUSB2.9 R529.2
USB3_TX_DP6: JIO1.42 U2.C15
USB3_TX_DP6_C: C648.2 CM14.3 R499.1
USB_CHG_CLT1: U5.C2 U21.6
USB_CHG_CLT2: U5.B8 U21.7
USB_CHG_CLT3: U5.E1 U21.8
USB_CHG_EN: R498.1 U5.D1
USB_CHG_ILIM_HI: R505.1 U21.16
USB_CHG_ILIM_LO: R504.1 U21.15
USB_CHG_ILIM_SEL: R503.1 U21.4
USB_CHG_STATUS_N: R540.2 U21.9
USB_OC0_N: JIO1.49 RP1.1 U2.AD43
USB_OC1_N: RP1.3 U2.AD42 U18.3
USB_OC2_N: RP1.2 U2.AD39 U21.13
USB_OC3_N: JIO1.48 RP1.4 U2.AC44
USB_OC_N: R875.2 U2.W43 U2.W44 U2.Y41 U2.Y43
USB_OTG_VBUSSENSE: R62.2 U2.AD10
USB_STATUS_N_R: R379.2 R540.1 U5.A8
V_PATH: PC202.1 PQ201.1 PQ201.2 PQ201.3 PQ202.1 PQ202.2 PQ202.3 PQ205.1 PQ205.2 PQ205.3 PR204.1 PR236.2
VBL_INT_N: PR1315.1 PU1306.6 R777.1
VCIN0_PT1: R557.2 R558.1 U5.G12
VCOUT1_PROCHOT: R555.1 U5.B13 U26.2
VR_SVID_ALERT_1: PR1239.1 PU1101.4
VR_SVID_CLK_1: PR1238.2 PU1101.5
VR_SVID_DAT_1: PR1237.1 PU1101.3
VRAM_VDDQ_ADJ: PR414.1 PR3408.1 R980.2 R981.2
VRAM_VDDQ_ADJ_R: G2.BH4 R981.1
VRAM_VREF_CTL: G2.BD3 Q81.2 Q82.2 Q83.2 Q84.2 R858.1
VRHOT_203: PR1233.2 PU1101.12
VSBP_2: PQ206.1 PR230.1
VSBP_3: PC204.2 PC230.1 PQ904.4 PR230.2 PR234.2
VSN_1PH: PC1141.2 PR1177.2 PU1101.14
VSN_3PH_A: PC1139.2 PR1166.2 PU1101.52
VSP_1PH: PC1143.2 PR1175.2 PU1101.15
VSP_3PH_A: PC1137.2 PR1121.2 PU1101.51
WLAN_CK_REQ_N: JWLAN1.53 Q8.1 R457.2
WLAN_RST_N: JWLAN1.52 R458.1
WLAN_SUSCLK: JWLAN1.50 R456.1
WLAN_WAKE_N: JWLAN1.55 R459.2
XCLK_BIASREF: R189.1 U2.E1
XDP_BPM0_N: TP56.1(TP-1) U1.BR27
XDP_BPM1_N: TP62.1(TP-1) U1.BT27
XDP_BPM2_N: TP2.1(TP-1) U1.BM31
XDP_BPM3_N: TP3.1(TP-1) U1.BT30
XDP_HOOK3: R588.2 R593.1 TP60.1(TP-1)
XDP_PRDY_N: R201.2 TP23.1(TP-1) U1.BP27
XDP_PREQ_N: R25.1 R200.2 TP21.1(TP-1) U1.BL30
XDP_PRS: R336.1 R594.1 TP59.1(TP-1)
XDP_TCK: R27.1 R220.2 TP48.1(TP-1) U1.BR28
XDP_TDI: R306.2 TP51.1(TP-1) U1.BL32
XDP_TDO: R24.1 R507.2 TP49.1(TP-1) U1.BT28
XDP_TMS: R216.2 TP52.1(TP-1) U1.BP28
XDP_TRST_N: R29.1 R202.2 TP50.1(TP-1) U1.BP30
XTAL_IN: C1399.1 G2.BL6 Y6.1
XTAL_LAN_IN: C276.1 R281.2 U6.8 Y4.1
XTAL_LAN_OUT: C277.1 R281.1 U6.7 Y4.3
XTAL_OUT: C1400.1 G2.BM6 Y6.3
N34955: C247.1 R264.1
N151202: PC1158.1 PR1243.1
N151523: PC1133.1 PR1162.2
N153421: PC1137.1 PC1139.1 PR1165.2 PR1166.1
N162072: PH1103.2 PR1146.1 PR1148.2
N168892: PR1190.1 PU1101.27
N169056: PC1153.2 PR1197.2 PU1101.13
N170540: PC1151.1 PR1195.1
N170610: PC1150.1 PR1194.2
N171722: PH1106.2 PR1198.1 PR1199.2
N172077: PC1142.2 PR1176.1 PU1101.22
N187198: PR1188.2 PU1101.8
N187431: PH1105.1 PR1179.2 PR1180.1
N188686: PH1107.1 PR1181.2 PR1182.1
N16691093: C2043.1 U2005.AB7
N16691099: C2044.1 U2005.AC7
N16691181: C2045.1 U2005.AB9
N16691187: C2047.1 U2005.AC9
N16691295: C2049.1 U2005.AB11
N16691301: C2050.1 U2005.AC11
N16691335: C2051.1 U2005.AB13
N16691365: C2052.1 U2005.AC13
N16691909: C2027.1 U2005.Y23
N16691941: C2031.1 U2005.T23
N16691945: C2033.1 U2005.T22
N16691949: C2029.1 U2005.Y22
N16693389: C2028.2 U2005.V23
N16693435: C2030.2 U2005.V22
N16693587: C2032.2 U2005.P23
N16693593: C2034.2 U2005.P22
N16693655: C2036.2 U2005.K23
N16693677: C2038.2 U2005.K22
N16693763: C2040.2 U2005.F23
N16693769: C2042.2 U2005.F22
N16693791: C2035.1 U2005.M23
N16693827: C2039.1 U2005.H23
N16693831: C2041.1 U2005.H22
N16693835: C2037.1 U2005.M22
N16694173: C2056.1 U2005.AB15
N16694179: C2057.1 U2005.AC15
N16694217: C2058.1 U2005.AB17
N16694223: C2059.1 U2005.AC17
N16694285: C2060.1 U2005.AB19
N16694291: C2061.1 U2005.AC19
N16694353: C2062.1 U2005.AB21
N16694359: C2063.1 U2005.AC21
N16694397: C2133.2 U2005.Y12
N16694403: C2134.2 U2005.W12
N16694687: C2070.1 U2005.Y15
N16694693: C2071.1 U2005.W15
N16695077: C2067.1 U2005.B17
N16695083: C2066.1 U2005.A17
N16695201: C2069.1 U2005.B19
N16695207: C2068.1 U2005.A19
N16731494: R2087.2 U2007.L4
N16731524: R2088.2 U2007.K4
N16732102: R2077.2 R2078.2 U2007.F10
N16819243: R278.2 U6.32
N16819245: R279.2 U6.33
N16821473: R282.1 U6.5
N16827117: C282.1 C283.2 C284.1 C285.2 C286.1 C287.2 C288.1 C289.2 C290.1 TL1.1 TL1.4 TL1.7 TL1.10
N16827394: C291.1 R283.2
N16843215: R2063.2 U2007.C10
N16897992: R2060.2 U2007.B2
N16898760: R2062.2 U2007.D10
N16899256: R2084.2 U2007.G11
N16968466: R2068.1 U2007.E4
N16968469: R2070.1 U2007.D5
N16968572: C2131.2 U2007.H7
N16976376: C328.2 C329.2 U7.18
N16976592: C326.2 C327.2 U7.21
N16976910: C324.2 C325.1 U7.22
N16977173: C318.2 U7.27
N16977182: C318.1 U7.28
N16977185: C321.1 U7.26
N16977188: C321.2 U7.25
N16977287: C315.1 U7.31
N16977319: C317.1 U7.29
N16977470: C313.1 U7.41
N16978248: C306.2 C307.1 U7.43
N16979537: C309.1 U7.44
N16980185: C330.2 C331.1 R313.1 R314.1
N17007017: R296.2 U7.55
N17007044: R298.2 U7.56
N17007081: R301.2 U7.1
N17007119: R302.2 U7.3
N17009629: C358.2 U8.28
N17009645: C360.2 U8.32
N17009647: C360.1 U8.34
N17009661: C361.2 U8.35
N17009677: C362.1 U8.36
N17009679: C362.2 U8.37
N17009693: C363.1 U8.38
N17009767: C364.1 U8.11
N17009783: C365.1 U8.12
N17009785: C365.2 U8.13
N17010419: R322.2 U8.21
N17011679: C351.2 U8.5
N17011706: C352.2 U8.1
N17011853: C353.2 U8.48
N17011867: C354.2 U8.44
N17104532: R2058.2 U2007.A5
N17104536: R2059.2 U2007.B5
N17166492: R2086.2 U2007.D7
N17166775: R2085.2 U2007.G10
N17246415: R2032.1 U2005.N6
N17249246: TP93.1(TP-1) U7.4
N17282944: R2089.1 U2007.K8
N17283025: R2090.2 U2007.L8
N17351028: R2093.1 U2011.4
N17351043: C2139.1 R2096.2 R2097.2 U2011.2
N17738807: C383.1 C384.1 R344.1 R346.1
N17740217: C374.2 U9.22 U9.26
N17740396: C376.2 U9.17 U9.21
N17741392: C379.1 R333.2
N17741619: C380.1 R334.2
N17787956: R554.2 U25.7
N17791490: C382.1 R343.1 R344.2
N17791539: C381.1 C383.2 R340.1 R347.1
N17791569: C382.2 R339.1 R340.2
N18154072: PQ1404.3 PR1407.1
N18154233: PQ1405.3 PR1411.1
N18154289: PQ1405.2 PR1410.2
N18154418: PQ1404.2 PR1408.2
N18154431: PQ1401.2 PR1405.2
N18155028: PQ1403.3 PR1404.1
N18155196: PQ1403.6 PR1413.1
N18288660: PC220.1 PR218.1 PU201.18
N18288662: PC203.1 PQ203.4 PR231.2
N18288666: PC203.2 PL201.2 PQ203.1 PQ203.2 PQ203.3 PR207.1 PR211.2
N18288670: PC214.1 PR214.1 PU201.19
N18288674: PC221.2 PR221.2 PU201.10
N18343239: PTP903.1(TP-1) PU902.28
N18346836: PC906.1 PU901.27 PU901.29
N18346842: PR902.2 PU901.30
N18346852: PC906.2 PR902.1
N18346922: PC911.1 PR905.2
N18349561: PT1001.1(TP-1) PU1001.28
N18349775: PC1006.1 PU1001.27 PU1001.29
N18349779: PR1001.2 PU1001.30
N18349781: PC1006.2 PR1001.1
N18349859: PC1011.1 PR1004.2
N18350194: PC1007.1 PU1002.27 PU1002.29
N18350200: PR1008.2 PU1002.30
N18350280: PC1027.1 PR1011.2
N18421582: PC1007.2 PR1008.1
N18842312: PC128.1 PR116.2
N19686618: C175.1 R96.2
N19687681: C172.1 R92.2
N20070704: PC972.2 PR904.1 PU901.7
N20070817: PR909.1 PU901.3
N20070821: PR910.2 PU901.31
N20070823: PR906.2 PU901.2
N20071127: PR908.1 PU901.4
N20073306: PTP901.1(TP-1) PU901.28
N20073337: PTP902.1(TP-1) PU901.8 PU901.9 PU901.10 PU901.11
N20074453: PTP904.1(TP-1) PU902.8 PU902.9 PU902.10 PU902.11
N20074727: PR919.2 PU902.30
N20074738: PC23.1 PU902.27 PU902.29
N20076374: PTP905.1(TP-1) PU1001.8 PU1001.9 PU1001.10 PU1001.11
N20077877: PTP906.1(TP-1) PU1002.8 PU1002.9 PU1002.10 PU1002.11
N20137254: PC435.1 PR429.2
N20137290: PC428.1 PR418.2
N20137326: PC424.1 PR428.2
N20137941: PC411.1 PR405.2 PU401.12
N20137996: PR404.1 PU401.13
N20138007: PR406.1 PR407.1 PU401.11
N20138043: PC401.2 PR401.2
N20153824: PC230.2 PC665.1 PC667.1 PL602.1 PQ904.5 PR608.2 PU603.3
N20153845: PC666.1 PR608.1 PU603.9
N20154004: PD601.2 PL602.2 PR417.1 PU603.6 PU603.7
N20154042: PR609.2 PR612.1 PU603.2
N20154060: PC678.2 PU603.10
N20154066: PR611.1 PU603.1
N20154076: PC677.1 PR611.2
N20157139: PC1271.1 PR1225.2
N20157150: PC1275.1 PR1222.2
N20171191: PC1510.2 PR1501.2
N20171267: PR1501.1 PU1501.30
N20172372: PC1530.2 PR1508.2
N20172448: PR1508.1 PU1502.30
N20172556: PT1504.1(TP-1) PU1502.8 PU1502.9 PU1502.10 PU1502.11
N20172566: PL1502.1 PR1514.1 PU1502.12 PU1502.13 PU1502.14 PU1502.15 PU1502.16 PU1502.17 PU1502.18
N20172586: PC1530.1 PU1502.27 PU1502.29
N20172640: PL1502.3 PR1511.1
N20172665: PL1502.2 PR1513.1
N20172725: PL1501.1 PR1507.1 PU1501.12 PU1501.13 PU1501.14 PU1501.15 PU1501.16 PU1501.17 PU1501.18
N20172742: PL1501.3 PR1505.1
N20172758: PL1501.2 PR1504.1
N20172772: PT1502.1(TP-1) PU1501.8 PU1501.9 PU1501.10 PU1501.11
N20172788: PC1510.1 PU1501.27 PU1501.29
N20172887: PC1520.1 PR1507.2
N20172906: PC1541.1 PR1514.2
N20233119: PQ1401.3 PR1412.1
N20234305: PT1501.1(TP-1) PU1501.28
N20234840: PT1503.1(TP-1) PU1502.28
N21283256: C210.1 C211.1 R223.2 R224.2 R226.2
N21871531: D38.2 R429.2 R430.2
N21871557: D38.1 D39.1 Q11.3 R571.2
N21871764: Q11.2 R569.1
N22215424: Q7.6 R395.1
N22216469: Q7.3 R396.1
N22751697: PR1306.1 PU1304.4
N22751755: PL1301.1 PU1306.9 PU1306.10
N22751764: PR1310.2 PU1306.8
N22751770: PR1314.2 PU1306.5
N22751809: PC1312.1 PR1309.1 PU1306.3
N22751813: PR1312.2 PU1306.4
N22751871: PR1311.1 PU1307.2
N22751880: PC1311.2 PC1313.2 PU1307.5
N22752556: PR1302.1 PU1301.4
N22806469: PQ101.2 PQ101.3 PR106.2 PR108.1
N22806481: PQ101.6 PR105.2 PR107.2
N22806527: PC104.1 PC105.1 PF102.2 PL103.1 PL104.1
N22807451: PF101.1 PL101.2 PL102.2
N22864850: PR409.2 PR433.2 PU402.2
N22864858: PR426.2 PU402.4
N22864873: PR430.2 PU402.5
N22875618: PQ1402.2 PQ1402.3 PR1414.1
N23003437: PC676.1 PQ206.2 PR610.2
N23054269: PC515.1 PR506.2
N23054303: PC514.1 PR504.2
N23054336: PC504.1 PR502.2
N23056736: PC1259.1 PU1254.5
N23057133: PC1251.1 PR1251.2 PU1252.1
N23057736: PC1254.1 PU1252.5
N23081959: PL1601.1 PR1607.1 PU1601.12 PU1601.13 PU1601.14 PU1601.15 PU1601.16 PU1601.17 PU1601.18
N23081971: PL1601.3 PR1605.1
N23081985: PL1601.2 PR1604.1
N23081993: PT1602.1(TP-1) PU1601.8 PU1601.9 PU1601.10 PU1601.11
N23082001: PC1608.1 PU1601.27 PU1601.29
N23082126: PC1608.2 PR1601.2
N23082214: PR1601.1 PU1601.30
N23082223: PC1619.1 PR1607.2
N23083331: PL1602.1 PR1614.1 PU1602.12 PU1602.13 PU1602.14 PU1602.15 PU1602.16 PU1602.17 PU1602.18
N23083348: PL1602.3 PR1613.1
N23083362: PL1602.2 PR1612.1
N23083370: PT1604.1(TP-1) PU1602.8 PU1602.9 PU1602.10 PU1602.11
N23083378: PC1627.1 PU1602.27 PU1602.29
N23083503: PC1627.2 PR1608.2
N23083591: PR1608.1 PU1602.30
N23083597: PC1638.1 PR1614.2
N23089660: PC1659.1 PR1621.2
N23089662: PL1603.1 PR1621.1 PU1603.12 PU1603.13 PU1603.14 PU1603.15 PU1603.16 PU1603.17 PU1603.18
N23089674: PL1603.3 PR1619.1
N23089690: PL1603.2 PR1618.1
N23089696: PC1650.1 PU1603.27 PU1603.29
N23089706: PT1606.1(TP-1) PU1603.8 PU1603.9 PU1603.10 PU1603.11
N23089821: PC1650.2 PR1615.2
N23089907: PR1615.1 PU1603.30
N23163323: PR920.1 PU902.3
N23163349: PC973.2 PR918.1 PU902.7
N23163371: PR915.2 PU902.31
N23163373: PR922.2 PU902.2
N23163385: PR992.1 PU902.4
N23164129: PR1009.1 PU1001.3
N23164159: PC1074.2 PR1053.1 PU1001.7
N23164181: PR1020.2 PU1001.31
N23164183: PR1007.2 PU1001.2
N23164187: PR1005.1 PU1001.4
N23165109: PR1014.1 PU1002.3
N23165131: PC1081.2 PR1022.1 PU1002.7
N23165157: PR1023.2 PU1002.31
N23165159: PR1024.2 PU1002.2
N23165163: PR1025.1 PU1002.4
N23165920: PR1597.1 PU1501.3
N23165924: PC1511.1 PR1502.2 PU1501.6
N23165942: PC1512.2 PR1503.1 PU1501.7
N23165976: PR1598.2 PU1501.31
N23165978: PR1506.2 PU1501.2
N23165982: PR1599.1 PU1501.4
N23166837: PR1595.1 PU1502.3
N23166841: PC1531.1 PR1509.2 PU1502.6
N23166859: PC1532.2 PR1510.1 PU1502.7
N23166885: PR1596.2 PU1502.31
N23166887: PR1512.2 PU1502.2
N23166891: PR1622.1 PU1502.4
N23167680: PR1624.1 PU1601.3
N23167702: PC1610.2 PR1603.1 PU1601.7
N23167736: PR1625.2 PU1601.31
N23167738: PR1606.2 PU1601.2
N23167742: PR1623.1 PU1601.4
N23168679: PR1631.1 PU1602.3
N23168701: PC1629.2 PR1610.1 PU1602.7
N23168727: PR1628.2 PU1602.31
N23168729: PR1611.2 PU1602.2
N23168733: PR1629.1 PU1602.4
N23169663: PR1633.1 PU1603.3
N23169685: PC1648.2 PR1617.1 PU1603.7
N23170380: PR1630.2 PU1603.31
N23170382: PR1632.1 PU1603.4
N23170384: PR1620.2 PU1603.2
N24008107: PT1601.1(TP-1) PU1601.28
N24010016: PC1609.1 PR1602.2 PU1601.6
N24010249: PC1628.1 PR1609.2 PU1602.6
N24011067: PC1647.1 PR1616.2 PU1603.6
N24022243: PC907.1 PR903.2 PU901.6
N24022700: PC1542.1 PR911.2 PU902.6
N24023177: PC1072.1 PR1002.2 PU1001.6
N24023662: PC1082.1 PR1021.2 PU1002.6
N24034924: PC1327.2 PU1308.5
N24579709: C310.1 U5.K5
N24733526: R872.1 U50.2
N25031555: C699.1 R300.1 U58.2
N25091766: R521.2 U61.2
N25091772: C572.2 R61.1 U61.1
N25389389: PQ202.5 PR201.1 PR233.2
N25407327: PC927.1 PR912.2
N25440711: PC1141.1 PC1143.1 PR1169.2 PR1177.1
N25456253: PC205.1 PC224.1 PR233.1 PU201.32
N25456262: PC206.1 PC224.2 PR232.1 PU201.31
N25470408: PC1307.1 PR1304.1 PU1303.A1 PU1303.A4
N25470498: PR1305.1 PU1303.B3
N25470530: PC1317.2 PU1303.B2
N25541282: JWLAN1.54 R484.1
N25541303: JWLAN1.56 R517.1
N25547911: C510.2 R849.2
N25547913: C511.2 R850.2
N25547935: D9.1 R847.1
N25547941: D10.1 R848.1
N25681410: R873.2 U50.4
N25683019: R930.2 U19.J4
N25683144: C320.1 U19.K5
N25685333: TP143.1(TP-1) U19.D12
N25685335: TP155.1(TP-1) U19.D13
N25685337: TP161.1(TP-1) U19.E12
N25691111: TP130.1(TP-1) U50.3
N25940457: R537.1 U59.4
N27165992: R257.1 U5.N8
N27176542: R546.2 R777.2 U5.E13
N27536412: R498.2 U21.5
N27707657: R832.1 U22.2
N27707680: R833.1 U22.3
N27707693: R834.1 U22.4
N27707695: R834.2 TP138.1(TP-1)
N27707716: R835.1 U22.5
N27707880: R836.1 U22.6
N27707929: R837.1 U22.7
N27708322: R57.2 U56.2
N27708482: R838.1 U22.10
N27708566: R839.1 U22.8
N27708610: R840.1 U22.9
N27708793: R841.2 U22.12
N27708827: R842.2 U22.13
N27708900: R843.2 U22.14
N27709001: TP132.1(TP-1) U22.20
N27709027: TP133.1(TP-1) U22.19
N27709052: TP144.1(TP-1) U22.18
N27709061: TP181.1(TP-1) U22.17
N27709088: TP182.1(TP-1) U22.16
N27794221: R844.2 U22.15
N28118695: PQ1402.5 PR1415.2
N28118785: PQ1402.6 PR1403.1
N28551818: PC201.1 PC202.2 PR202.1 PR235.1 PR236.1 PR237.1
N28552039: PR213.2 PU201.6
N28552088: PR215.2 PU201.7
N28552117: PR216.2 PU201.8
N28552363: PR219.2 PU201.9
N28552439: PC222.2 PR221.1
N28552547: PR222.1 PR224.2 PU201.11
N28554029: PC213.1 PC216.1 PR211.1 PU201.15
N28554039: PC213.2 PC217.1 PR212.1 PU201.14
N28554122: PR210.1 PU201.24
N28554284: PC212.1 PR210.2
N28555638: PR204.2 PU201.29
N28555679: PC207.2 PU201.28
N28555719: PC207.1 PU201.27
N28555734: PC231.1 PR205.2 PU201.26
N28559619: PD201.1 PD202.1 PR218.2
N28559889: PR217.2 PU201.17
N28559931: PH201.2 PR217.1
N28563405: PR223.1 PR225.2 PU201.16
N28563583: PR220.2 PU201.12
N28615744: PC23.2 PR919.1
N28664348: PR208.2 PU201.13
N29688421: PT602.1(TP-1) PU605.3
N29688423: PT603.1(TP-1) PU605.4
N29688473: PR624.2 PU605.15
N29688500: PR647.1 PR648.1 PU605.14
N29688522: PR649.2 PU605.16
N29884571: C168.1 LD1.3 R184.2
N29884573: C169.1 LD1.1 R191.2
N29961497: R495.1 U18.2
N29961526: R496.2 U18.4
N30237927: C509.2 D55.1 R854.2 SWPWR2.1 SWPWR2.3
N30678816: PC601.2 PR605.1
N31577862: JEDP1.5 R894.2
N31743879: R580.2 U26.4
N33040713: C407.2 Q52.2 R152.2 R791.2
N33040971: C406.2 Q29.2 Q52.6 R377.2
N33486178: R523.2 U5.G10
N33525072: PQ1409.5 PQ1409.6 PR712.2 PR3551.2
N33525121: PQ1409.2 PR414.2 PR416.1
N33525138: PR703.2 PR704.1 PU701.13
N33525142: PC721.1 PR717.2
N33525205: PC720.1 PR716.2
N33525247: PC712.1 PR714.2
N33525265: PR720.2 PR722.2 PU702.2
N33525329: PQ1409.3 PR415.2
N33525740: PC3409.1 PR3404.2
N33525746: PC3425.1 PR3409.2
N33525779: PC3436.2 PC3438.2 PR3420.2 PR3421.1 PR3422.1
N33533058: D39.2 R570.1
N33547696: PR3426.1 PR3449.2 PU1604.13
N33548040: PC3515.1 PR3434.2
N33548052: PC3519.1 PR3445.2
N33548085: PC3506.2 PC3514.2 PR3435.1 PR3437.1 PR3438.2
N33548178: PC3518.1 PR3431.2 PR3433.1 PR3540.1
N33575839: PC3528.1 PR3459.2
N33575872: PC3538.1 PR3460.2
N33575908: PC3533.1 PR3462.2
N33575935: PR3464.2 PU1309.2
N33583518: PH1108.1 PR1446.2 PR1449.1
N33583760: PC1429.2 PR1461.1
N33583816: PC1431.2 PR1463.1
N33583836: PR1467.2 PU1605.39
N33589722: PR3526.2 PU1605.13 PU1605.14 PU1605.15
N33598415: PT1005.1(TP-1) PU1606.8 PU1606.9 PU1606.10 PU1606.11
N33598431: PC3547.2 PR3538.1
N33598435: PR3538.2 PU1606.30
N33598437: PC3547.1 PU1606.27 PU1606.29
N33598858: PR3536.1 PU1606.3
N33598864: PC3556.2 PR3539.1 PU1606.7
N33598872: PR3534.2 PU1606.31
N33598874: PR3533.2 PU1606.2
N33598878: PR3535.1 PU1606.4
N33598972: PC3551.1 PR3531.2
N33599032: PC3558.1 PR3537.2 PU1606.6
N33607325: PR3432.2 PR3541.1
N33610549: PR3468.1 PR3547.2
N33610807: PC3542.1 PR3466.1 PR3467.2 PR3542.2
N33675888: PQ201.4 PQ205.4 PR237.2
N33675896: PQ202.4 PR235.2
N33769583: Q53.2 Q53.3 R827.1
N33769629: Q53.5 R435.2
N34215558: R2314.2 U2015.20
N34263843: R2315.2 U2016.8
N34625001: C2153.2 U2005.Y11
N34625004: C2154.2 U2005.W11
N35183294: C1340.1 Q13.2 R1003.2 R1004.2
N35184706: C685.1 G2.BB30 R16.2
N35211433: G2.R44 R1022.2
N35211439: G2.P44 R1021.2
N35211449: G2.R45 R1023.1
N35211451: G2.P45 TP118.1(TP-1)
N35211455: G2.E52 R1024.2 R1025.1
N35236381: Q75.5 R996.2 R998.2
N35237831: Q76.2 R988.2 R989.2
N35237855: Q76.5 R991.2 R992.2
N35239365: R962.2 R963.1 R2156.1 R2157.1 R2158.1 R2159.1 R2160.1 R2161.1
N35242647: R2171.2 R2172.1 U63.4
N35243502: G2.BM24 TP113.1(TP-1)
N35243504: G2.BM23 R2255.2 TP116.1(TP-1)
N35243522: G2.BL23 R2254.2 TP117.1(TP-1)
N35243524: G2.BK24 R2256.2 R2257.1 TP114.1(TP-1)
N35243532: G2.BL24 R1019.1
N35243651: G2.BK23 R1020.1
N35248107: C887.1 R774.1 R2219.1
N35248159: Q81.6 R2213.2
N35249592: R874.2 U48.J1
N35249617: C907.1 R2215.1 R2218.1
N35249695: R2216.2 U2022.J1
N35260582: C908.1 R2221.1 R2223.1
N35260616: Q82.6 R866.2
N35261197: C1326.1 R871.1 R2220.1
N35261623: R859.2 U2023.J1
N35261629: R2222.2 U55.J1
N35266531: Q83.6 R2224.2
N35267092: R900.2 U2025.J1
N35267128: C2425.1 R901.1 R903.1
N35267218: R904.2 U2024.J1
N35268749: C1353.1 R2226.1 R2227.1
N35274430: C1373.1 R785.1 R906.1
N35274464: Q84.6 R909.2
N35275015: R913.2 U2026.J1
N35275051: C2439.1 R914.1 R916.1
N35275141: R2228.2 U60.J1
N35284510: Q85.5 Q85.6 R2184.2
N35284576: PC12.1 PJ1506.2 PU1607.4
N35284626: PC14.1 PR39.1 PU7.A1
N35284705: C2221.1 Q85.2 R2186.2
N35285830: PC10.1 PR29.2 PR3553.2 PU5.12
N35285832: PC11.2 PR36.2 PU5.14
N35285834: PC11.1 PR24.2 PR3554.2 PU5.15
N35285836: PC10.2 PR26.2 PU5.11
N35285838: PR23.1 PR28.1 PR34.1 PU5.5
N35285847: PC9.2 PR22.2 PU5.4
N35285970: Q86.5 Q86.6 R2188.2
N35286052: C2222.1 Q86.2 R2189.2
N35290550: R2229.2 R2232.1
N35290561: R2106.2 R2107.1
N35290569: R2230.1 R2233.2
N35290577: R2110.2 R2231.1
N35291020: R464.1 U14.16
N35291238: R462.2 U14.7
N36026252: PR306.1 PU301.5
N36026261: PC303.2 PR304.1 PU301.3
N36026271: PC315.1 PR315.2 PU301.12
N36026291: PC316.1 PR312.2 PU301.13
N36026325: PC309.1 PR308.2
N36026360: PR307.1 PU301.1
N36026424: PC310.2 PR309.1
N36217862: PC3567.1 PR3549.1 PU8.A1
N36341567: G2.BK6 R2251.2 R2252.1
N36341862: G2.BJ6 R2253.1
N36344834: PC3580.1 PR3555.2 PR3568.2 PU5.2
N36344836: PC3580.2 PR3569.2 PU5.1
N36354771: PC13.1 PR38.2 PU1607.2
N36355836: PC3577.2 PC3578.2 PU1607.5
N36384934: PR2261.1 PR3556.2 PR3558.2
N36385245: PR3560.2 PR3561.2 Q95.3
N36390914: C1332.1 Q88.2 R808.1
N36390918: C1330.1 Q87.4 Q88.6
N36391449: C2682.1 Q97.5 R2262.1
N36493829: C1338.1 Q91.2 R813.2
N36493854: C1341.1 Q92.2 R1009.2
N36493878: Q92.3 R1008.1
N36493887: C1342.1 Q90.2 R1013.2
N36493900: Q90.3 R1012.1
N36494579: C2680.1 Q94.2 R2259.2
N36494588: Q94.3 R2270.1
N36494795: Q100.3 R2264.1
N36494804: C2685.1 Q100.2 R2266.2
N36495019: Q101.3 R2267.1
N36495028: C2686.1 Q101.2 R2269.2
N36495768: D2015.1 R565.2
N36495771: D2014.1 R862.2
N36715737: C888.1 Q49.2 R781.2
N36820462: C2411.2 G2.BF20
N36820464: C2165.2 G2.BE20
N36820466: C2413.2 G2.BH20
N36820468: C2412.2 G2.BG20
N36820470: C2414.2 G2.BF18
N36820472: C2163.2 G2.BG18
N36820474: C2410.2 G2.BF17
N36820476: C2164.2 G2.BE17
N36821237: Q74.5 R994.2 R997.2
N36821400: Q74.2 R1017.2 R1018.2
N37204333: C525.2 U2013.2
N37204567: R455.1 U2013.7
N37209952: R488.1 U2014.7
N37210471: C537.2 U2014.2
N37405187: PU1.2 R440.2
N37465825: R2287.2 U2007.A3
N37465828: R2288.2 U2007.B4
N37465831: R2289.2 U2007.A4
N37465834: R2290.2 U2007.B3
N37850508: R2311.2 U2030.2
N37850516: R2313.1 U2030.4
N37851943: R2312.1 U2030.3
N37999620: PR3578.2 PU1608.4
N37999622: PR3575.2 PU1608.5
N37999632: PR3576.2 PR3577.2 PU1608.2
N38000060: PR3583.2 PU1609.4
N38000062: PR3580.2 PU1609.5
N38000072: PR3581.2 PR3582.2 PU1609.2
N38001025: PR3587.2 PU1610.4
N38001027: PR3584.2 PU1610.5
N38001037: PR3586.1 PR3588.1 PU1610.2
N39102963: R2333.2 U2031.2
N39102977: R2328.1 U2031.4
N39102995: R2327.1 U2031.3
N39195476: Q104.5 R1011.2 R2330.2 R2331.2 R2332.2
N39291118: Q105.5 R2335.2 R2336.2 R2337.2 R2338.2
N39709009: Q106.1 R2339.2 R2340.2
N396855230: PR410.1 PU402.8
N396894630: PR3574.1 PU1608.8
N396912040: PR3585.1 PU1610.8
N396930910: PR3556.1 Q95.5
N396953540: PT1004.1(TP-1) PU1606.28
N396955126: PT1003.1(TP-1) PU1002.28
N397008670: PT1605.1(TP-1) PU1603.28
N397008960: PT1603.1(TP-1) PU1602.28
N397041123: PR3579.1 PU1609.8

Pads without a net: D6 5; D7 5; G2 A17 A42 AA44 AC7 AC8 AC9 AD45 AD46 AF49 AG8 AG9 AG52 AM1 AM2 AM3 AM5 AM6 AM7 AM8 AN1 AN2 AN3 AN6 AN7 AN9 AN44 AR1 AR2 AR3 AR5 AR6 AR7 AR8 AT1 AT2 AT3 AT6 AT7 AT9 AT44 AT45 AV1 AV2 AV3 AV5 AV6 AV7 AV8 AW1 AW2 AW3 AW6 AW7 AW9 AW47 AW48 BA1 BA2 BA5 BA6 BA7 BA8 BA9 BB2 BB3 BB6 BB7 BB8 BD4 BD14 BE7 BE12 BF9 BF12 BG1 BG6 BG12 BH6 BH12 BJ1 BJ2 BJ9 BJ11 BK15 BK18 BK20 BK21 BK44 BL15 BL18 BL20 BL21 BM14 BM15 BM20 BM21 D17 D41 E29 F9 F29 F41 G9 G14 G35 G41 H6 H7 H14 H24 H35 J14 J23 J24 J35 J41 J46 J47 M7 M8 M44 M45 P9 U1 V4 V44 V45; JBAT1 8; JDIMM1 87 88 91 92 95 97 100 101 104 105 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 162 165; JDIMM3 87 88 91 92 95 97 100 101 104 105 162 165; JDIMM4 87 88 91 92 95 97 100 101 104 105 162 165; JEC1 1 2; JEDP1 1 2 3 4 6 37 38 39 40; JHDMI1 13 14; JSSD1 6 8 20 22 24 26 28 30 32 34 36 38 40 42 44 46 48 54 56 58 67 68 69; JSSD2 6 8 20 22 24 26 28 30 32 34 36 38 40 42 44 46 48 54 56 58 67 68 69; JWLAN1 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 32 34 36 38 40 42 44 46 48 58 59 60 61 62 64 65 66 67 68 70 71 73; NOREF 1; NOREF#2 1; NOREF#5 1; NOREF#6 1; NOREF#7 1; NOREF#8 1; NOREF#9 1; NOREF#10 1; PU5 13 16; PU301 19; PU402 6 7; PU605 32; PU901 1; PU902 1; PU1001 1; PU1002 1; PU1204 3 4 27; PU1501 1; PU1502 1; PU1601 1; PU1602 1; PU1603 1; PU1606 1; PU1608 6 7; PU1609 6 7; PU1610 6 7; Q5 3 4 5; Q8 3 4 5; Q13 3 4 5; Q35 3 4 5; Q49 3 4 5; Q52 3 4 5; Q75 1 2 6; Q81 3 4 5; Q82 3 4 5; Q83 3 4 5; Q84 3 4 5; Q88 3 4 5; Q91 3 4 5; Q93 3 4 5; Q95 1 2 6; Q98 3 4 5; U1 A27 A29 AA14 AE29 AF29 AF30 AF31 AF32 AF33 AF34 AG13 AG14 AG31 AG32 AG33 AG34 AG35 AG36 AH13 AH14 AH29 AH30 AH31 AH32 AH35 AH36 AH37 AH38 AJ8 AJ13 AJ14 AJ29 AJ30 AJ31 AJ32 AJ33 AJ34 AJ35 AJ36 AK31 AK32 AK33 AK34 AK35 AK36 AK37 AK38 AL13 AL29 AL30 AL31 AL32 AL35 AL36 AL37 AL38 AM13 AM14 AM29 AM30 AM31 AM32 AM33 AM34 AM35 AM36 AN13 AN14 AN31 AN32 AN33 AN34 AN35 AN36 AN37 AN38 AP13 AP14 AP29 AP30 AP31 AP32 AP35 AP36 AP37 AP38 AR29 AR30 AR31 AR32 AR33 AR34 AR35 AR36 AT13 AT14 AT31 AT32 AT33 AT34 AT35 AT36 AT37 AT38 AU13 AU14 AU29 AU30 AU31 AU32 AU35 AU36 AU37 AU38 AV29 AV30 AV31 AV32 AV33 AV34 AV35 AV36 AW7 AW8 AW9 AW10 AW11 AW13 AW14 AW31 AW32 AW33 AW34 AW35 AW36 AW37 AW38 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 AY29 AY30 AY31 AY32 AY35 AY36 AY37 AY38 B2 B26 B27 B28 B29 B30 B33 B34 B36 B38 BA1 BA2 BA3 BA4 BA5 BA13 BA14 BA29 BA30 BA31 BA32 BA33 BA34 BA35 BA36 BB13 BB14 BB31 BB32 BB33 BB34 BB35 BB36 BB37 BB38 BC29 BC30 BC31 BC32 BC35 BC36 BC37 BC38 BD13 BD14 BD29 BD30 BD31 BD32 BD33 BD34 BD35 BD36 BE31 BE32 BE33 BE34 BE35 BE36 BE37 BE38 BF13 BF14 BF29 BF30 BF31 BF32 BF35 BF36 BF37 BF38 BG29 BG30 BG31 BG32 BG33 BG34 BG35 BG36 BH30 BH33 BH34 BH35 BH36 BH37 BH38 BJ17 BJ19 BJ20 BJ21 BJ23 BJ26 BJ27 BJ28 BJ35 BJ36 BJ37 BJ38 BK17 BK19 BK20 BK21 BK23 BK26 BK27 BK28 BL14 BL15 BL16 BL17 BL18 BL19 BL20 BL21 BL22 BL23 BL24 BL25 BL26 BL27 BL28 BL31 BL34 BL36 BL37 BM14 BM15 BM16 BM17 BM22 BM24 BM36 BM37 BN15 BN16 BN17 BN33 BN35 BN36 BN37 BN38 BP1 BP15 BP16 BP17 BP25 BP37 BP38 BR2 BR15 BR16 BR17 BR25 BR31 BR35 BR37 BT15 BT16 BT17 BT29 BT37 C1 C26 C28 C30 C33 C34 C38 D27 D29 D34 E26 E27 E28 E29 E30 E33 E36 E37 F26 F28 F30 F33 F34 F35 F37 G3 G13 G29 G38 H24 H33 H34 H36 H37 J3 J24 J34 J35 J37 J38 K36 K37 N29 R14; U2 A12 A14 AA1 AA2 AA44 AA45 AB2 AB3 AB13 AB33 AB35 AB41 AB44 AC43 AD2 AD3 AD31 AD35 AD38 AE17 AE44 AF17 AF41 AG14 AG15 AG35 AG36 AG39 AG44 AH43 AH44 AJ7 AJ8 AJ11 AJ13 AJ33 AJ35 AJ38 AJ39 AJ42 AJ43 AJ44 AL7 AL8 AL27 AL35 AL36 AL39 AL42 AL43 AL44 AM1 AM2 AM43 AM44 AN2 AN17 AN29 AN36 AN38 AN41 AN42 AR15 AR17 AR19 AR22 AR24 AR27 AR29 AR31 AT31 AT33 AT43 AT44 AU41 AU43 AU44 AV2 AV3 AV4 AV13 AV15 AV29 AV43 AV44 AW2 AW4 AW24 AW27 AW31 AW33 AW35 AY2 B8 B12 B13 B14 BA4 BA5 BA33 BA41 BB3 BB17 BB22 BB31 BB33 BB38 BC4 BC8 BC15 BC19 BC22 BC26 BC27 BC33 BC35 BC36 BC38 BD1 BD6 BD14 BD17 BD18 BD21 BD22 BD27 BD33 BD34 BD35 BD36 BD38 BD39 BE2 BE5 BE6 BE21 BE34 BE39 C8 C14 C22 D22 E11 G11 G13 G37 G44 G45 H13 H43 H44 J45 K19 K37 K44 L5 L7 L19 L37 L39 N29 N31 N38 N39 N42 N44 P1 P2 P3 P24 P27 P29 P31 P44 R2 R3 R4 R7 R8 R11 R13 R24 R27 R43 R44 T44 T45 U2 U3 U5 U7 U13 U36 U39 U41 U42 U43 V1 V2 W2 W3 W7 W13 W35 W36 W42 Y5; U5 A2; U6 23 25 26 28 38 39; U8 18 19 40; U9 13; U19 A2 A3 A5 A8 B7 D6 D7 E6 E8 G2 H1 H2 H9 H10 H12 J1 J2 J7 J8 J9 J12 J13 K1 K2 K8 K9 K12 L12 L13 M2 M8 M9 M10 M13 N9 N10 N11 N12 N13; U25 8; U26 1; U48 A5 A10 U5 U10; U55 A5 A10 U5 U10; U56 1; U58 1; U59 1; U60 A5 A10 U5 U10; U2005 A7 A9 A23 B7 B9 B23 E18 J1 J2 L1 L2 N1 N2 R1 R2 V18 W16 W19 Y16 Y19; U2007 A9 B6 B9 L11; U2011 1 5; U2013 15 21 33 34 37 43 46; U2014 15 21 33 34 37 43 46; U2015 16 17 23; U2022 A5 A10 U5 U10; U2023 A5 A10 U5 U10; U2024 A5 A10 U5 U10; U2025 A5 A10 U5 U10; U2026 A5 A10 U5 U10

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 7534 vias
v2: diameter 0.406, hole 0.203, TOP to BOTTOM, 1105 vias
v3: diameter 0.457, hole 0.203, TOP to BOTTOM, 3474 vias
v4: diameter 0.305, hole 0.152, TOP to BOTTOM, 2 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.0VALW_PWRGD: length 2.2
  TOP w0.097: PR509.2 264.92,48.77 264.76,48.92 264.04,48.92 263.88,48.76 PU501.2
1.0VG_BS: length 2.3
  TOP w0.508: PR714.1 215.96,167.73 v2(216.65,168.43) v1(217.18,168.95)
1.0VG_EN: length 5.1
  TOP w0.097: v1(217.39,164.93) 218.03,164.29 PC717.1 PR718.1 PR715.1 v2(217.27,162.51)
  BOTTOM w0.097: v1(217.39,164.93) 216.52,165.79 PU702.1
1.0VG_ILIM: length 2.8
  TOP w0.254: v1(217.39,166.58) 217.77,166.96 PR724.1 PR723.2
  BOTTOM w0.254: PU702.3 217.28,166.69 v1(217.39,166.58)
1.2V_B+: length 8.5
  TOP w0.356: PR412.1 105.63,88.85 105.51,88.98 v1(105.25,88.98)
  IN08 w0.508: v1(105.25,88.98) 105.51,88.98 106.4,88.09 106.4,86.31 107.79,84.92 v1(107.79,82.63)
  vias: v1(106.78,81.36) v1(107.16,82.63) v1(107.16,81.99) v1(107.28,80.98) v1(107.79,81.99) v1(107.79,81.36) v2(107.16,77.93)
