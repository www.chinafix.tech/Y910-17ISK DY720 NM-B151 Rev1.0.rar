# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE3_TBT_RX_DN2: length 240.6
  IN05 w0.076: 238.55,69.62 238.56,69.62 238.62,69.68 238.77,69.68 238.86,69.59 238.86,68.48 239.06,68.28 239.26,68.28 v3(239.49,68.05)
  IN05 w0.114: v1(46.32,73.74) 46.45,73.87 46.72,73.87 46.83,73.75 46.83,71.47 47.72,70.58 47.72,69.43 52.79,64.36 52.79,62.32 54.9,60.21 54.9,60.21 56.1,59.01 57.63,59.01 57.88,58.75 57.88,57.37 58.5,56.75 58.5,51.91 60.81,49.61 68.8,49.61 69.45,48.96 72.5,48.96 73.66,47.81 90.04,47.81 90.39,47.45 97.25,47.45 101.44,51.64 103.09,51.64 107.92,56.47 107.92,59.64 109.19,60.91 109.19,64.34 109.75,64.91 115.41,64.91 115.63,64.68 118.37,64.68 119.23,63.82 139.14,63.82 139.68,64.36 139.68,64.77 141.78,66.87 144.75,66.87 145.78,67.9 146.78,67.9 147.92,69.04 147.92,72.72 148.87,73.67 167.86,73.67 168.12,73.92 182.4,73.92 182.72,74.25 201.15,74.25 202.35,75.45 212.75,75.45 213.43,76.13 222.19,76.13 223.34,77.27 231.2,77.27 231.54,77.61 233.39,77.61 234.67,76.33 234.67,74 236.56,72.11 236.56,69.95 236.88,69.62 238.55,69.62
  BOTTOM w0.104: C2038.1 47.75,73.74 47.56,73.93 v1(47.04,73.93) 46.51,73.93 v1(46.32,73.74) ; U2.L17 239.57,67.97 v3(239.49,68.05)
PCIE3_TBT_RX_DP2: length 240.6
  IN05 w0.076: v3(239.49,68.66) 239.26,68.43 239.12,68.43 239.01,68.55 239.01,69.65 238.83,69.83 238.62,69.83 238.56,69.89 238.55,69.89
  IN05 w0.114: 238.55,69.89 237,69.89 236.82,70.06 236.82,72.22 234.93,74.11 234.93,76.44 233.5,77.87 231.43,77.87 231.09,77.54 223.23,77.54 222.08,76.39 213.32,76.39 212.64,75.71 202.24,75.71 201.04,74.51 182.61,74.51 182.29,74.19 168.01,74.19 167.75,73.94 148.76,73.94 147.66,72.83 147.66,69.15 146.67,68.16 145.67,68.16 144.64,67.14 141.67,67.14 139.42,64.88 139.42,64.47 139.03,64.09 119.35,64.09 118.48,64.95 115.74,64.95 115.52,65.17 109.64,65.17 108.92,64.45 108.92,61.02 107.65,59.75 107.65,56.58 102.98,51.91 101.33,51.91 97.14,47.72 90.5,47.72 90.15,48.07 73.77,48.07 72.61,49.23 69.56,49.23 68.91,49.88 60.92,49.88 58.77,52.02 58.77,56.86 58.15,57.48 58.15,58.86 57.74,59.27 56.21,59.27 55.01,60.48 53.06,62.43 53.06,64.47 47.99,69.54 47.99,70.69 47.1,71.58 47.1,73.86 46.83,74.13 46.57,74.13 v1(46.32,74.37)
  BOTTOM w0.104: C2036.1 47.75,74.37 47.56,74.19 46.51,74.19 v1(46.32,74.37) ; v3(239.49,68.66) 240.09,68.66 U2.K17
PCIE3_TBT_TX_DN2: length 233.7
  IN05 w0.114: v1(52.8,75.14) 52.48,75.46 52.48,75.72 52.78,76.03 53.44,76.03 53.91,75.55 53.91,75.36 54.13,75.15 54.32,75.15 54.56,74.91 54.56,74.71 54.77,74.5 54.97,74.5 55.21,74.26 55.21,74.07 55.42,73.85 55.61,73.85 56.09,73.38 56.09,73.13 55.97,73.02 55.97,72.68 56.09,72.56 56.09,69.05 56.26,68.88 56.26,68.68 56.48,68.46 56.69,68.46 56.91,68.24 56.91,68.03 57.13,67.81 57.33,67.81 58.03,67.11 58.03,66.6 58.66,65.98 58.91,65.98 60.41,64.48 60.41,62.96 61.55,61.82 61.55,58.78 63.99,56.34 64.99,56.34 67.41,53.93 71.6,53.93 72.61,52.91 79.5,52.91 80.13,52.28 90.39,52.28 91.41,53.29 95.85,53.29 98.01,55.45 101.31,55.45 104.36,58.5 104.36,61.42 104.74,61.8 104.74,65.74 107.79,68.79 111.09,68.79 111.73,69.42 117.19,69.42 117.7,68.91 119.98,68.91 120.37,68.53 127.73,68.53 128.75,69.55 128.75,71.98 129.01,72.24 130.43,72.24 130.66,72.01 132.96,72.01 134.44,73.49 135.86,73.49 137.51,75.14 144.49,75.14 145.4,76.04 145.4,77.57 145.82,77.99 146.94,77.99 149.04,80.09 206.47,80.09 206.98,80.6 211.8,80.6 211.99,80.78 221.56,80.78 222.84,82.06 229.61,82.06 230.01,82.46 230.35,82.46 230.48,82.34 230.8,82.34 230.93,82.46 231.26,82.46 231.39,82.34 231.72,82.34 231.85,82.46 232.17,82.46 232.3,82.34 232.63,82.34 232.76,82.46 233.09,82.46 233.22,82.34 233.55,82.34 233.68,82.46 234.07,82.46 234.48,82.06 234.97,82.06 235.8,81.23 237.07,81.23 238.98,79.32 238.98,76.17 238.8,75.99 238.68,75.99 238.45,76.23 v1(238.45,76.28)
  BOTTOM w0.076: U2.B20 238.87,72.72 238.68,72.91 238.68,73.43
  BOTTOM w0.104: 238.68,73.43 238.68,74.88 238.86,75.06 238.86,75.87 v1(238.45,76.28) ; v1(52.8,75.14) 52.61,75.33 52.61,75.67 C2037.2
PCIE3_TBT_TX_DP2: length 233.6
  IN05 w0.114: v1(52.17,75.14) 52.21,75.19 52.21,75.83 52.67,76.29 53.55,76.29 56.36,73.49 56.36,69.16 58.3,67.22 58.3,66.71 58.77,66.25 59.02,66.25 60.68,64.59 60.68,63.07 61.82,61.93 61.82,58.89 64.1,56.61 65.1,56.61 67.52,54.19 71.71,54.19 72.72,53.18 79.61,53.18 80.24,52.54 90.28,52.54 91.3,53.56 95.74,53.56 97.9,55.72 101.2,55.72 104.1,58.61 104.1,61.53 104.48,61.91 104.48,65.85 107.68,69.05 110.98,69.05 111.62,69.69 117.3,69.69 117.81,69.18 120.09,69.18 120.48,68.8 127.62,68.8 128.48,69.66 128.48,72.09 128.9,72.51 130.54,72.51 130.77,72.27 132.85,72.27 134.33,73.75 135.75,73.75 137.4,75.4 144.38,75.4 145.13,76.15 145.13,77.68 145.71,78.25 146.83,78.25 148.93,80.36 206.36,80.36 206.87,80.86 211.69,80.86 211.87,81.05 221.45,81.05 222.73,82.32 229.5,82.32 229.9,82.73 234.18,82.73 234.59,82.32 235.08,82.32 235.91,81.5 237.18,81.5 239.25,79.43 239.25,76.06 238.91,75.72 238.53,75.72 v1(238.45,75.64)
  BOTTOM w0.076: U2.C20 238.72,72.07 238.6,72.19 238.6,72.78 238.53,72.85 238.53,73.32 238.42,73.42 238.42,73.43
  BOTTOM w0.104: C2035.2 52.35,75.68 52.35,75.32 v1(52.17,75.14) ; 238.42,73.43 238.42,74.99 238.6,75.16 238.6,75.56 238.52,75.64 v1(238.45,75.64)
PCIE4_TBT_RX_DN3: length 238.8
  IN05 w0.114: v3(238.48,70.95) 238.75,71.23 238.75,71.38 238.63,71.5 237.92,71.5 237.73,71.7 237.73,72.45 235.76,74.42 235.76,75.9 236.38,76.52 236.38,78.53 236.09,78.81 230.29,78.81 229.9,78.43 222.84,78.43 221.72,77.31 212.83,77.31 212.58,77.05 201.28,77.05 199.63,75.4 180.96,75.4 180.64,75.08 167.64,75.08 167.38,74.83 148.12,74.83 146.28,72.98 145.89,72.98 145,72.09 145,68.79 144.25,68.04 140.19,68.04 137.64,65.48 119.47,65.48 119.01,65.94 116.1,65.94 115.97,66.07 109.27,66.07 108.03,64.83 108.03,61.4 106.76,60.13 106.76,57.09 102.73,53.05 100.82,53.05 96.37,48.61 91.14,48.61 90.5,49.24 74.12,49.24 73.24,50.13 69.93,50.13 69.29,50.77 61.68,50.77 61.07,51.38 61.07,55.05 59.79,56.34 59.79,57.1 59.15,57.73 59.15,60.67 52.68,67.13 52.04,67.13 50.52,68.66 50.52,72.22 49.87,72.86 48.74,72.86 48.1,73.5 48.1,74.24 47.61,74.74 47.61,76.29 48.1,76.79 v1(48.1,77.19)
  BOTTOM w0.097: v3(238.48,70.95) 238.8,70.95 U2.E20
  BOTTOM w0.104: C2042.1 47.91,77.57 47.91,77.39 v1(48.1,77.19)
PCIE4_TBT_RX_DP3: length 238.8
  IN05 w0.114: v3(238.48,70.31) 237.97,70.82 237.97,71.08 237.46,71.58 237.46,72.34 235.49,74.31 235.49,76.01 236.11,76.63 236.11,78.42 235.98,78.55 230.4,78.55 230.01,78.16 222.95,78.16 221.83,77.04 212.94,77.04 212.69,76.79 201.39,76.79 199.74,75.14 181.07,75.14 180.75,74.81 167.75,74.81 167.49,74.56 148.24,74.56 146.39,72.71 146,72.71 145.27,71.98 145.27,68.68 144.36,67.77 140.3,67.77 137.75,65.22 119.36,65.22 118.9,65.68 115.99,65.68 115.86,65.8 109.38,65.8 108.3,64.72 108.3,61.29 107.03,60.02 107.03,56.98 102.84,52.78 100.93,52.78 96.48,48.34 91.03,48.34 90.39,48.97 74.01,48.97 73.12,49.86 69.82,49.86 69.18,50.5 61.57,50.5 60.8,51.26 60.8,54.94 59.52,56.23 59.52,56.99 58.88,57.62 58.88,60.56 52.57,66.87 51.93,66.87 50.25,68.55 50.25,72.11 49.76,72.6 48.63,72.6 47.84,73.39 47.84,74.13 47.34,74.63 47.34,76.4 47.54,76.61 47.54,77.09 v1(47.47,77.17)
  BOTTOM w0.097: v3(238.48,70.31) 238.93,70.31 U2.G19
  BOTTOM w0.104: C2040.1 47.65,77.58 47.65,77.35 v1(47.47,77.17)
PCIE4_TBT_TX_DN3: length 238
  IN05 w0.114: v1(50.12,75.18) 49.83,75.47 49.83,76.33 49.48,76.67 48.88,76.67 48.34,76.14 48.34,75.03 49.5,73.87 50.13,73.87 51.66,72.34 52.55,72.34 52.93,71.96 52.93,69.8 57.77,64.96 58.66,64.96 59.39,64.23 59.39,62.58 60.66,61.31 60.66,58.36 63.58,55.44 63.87,55.44 64.09,55.22 64.09,54.7 65.76,53.04 71.22,53.04 72.61,51.64 75.79,51.64 76.68,50.75 78.58,50.75 79.09,51.26 90.77,51.26 91.16,50.88 93.95,50.88 95.47,52.4 97.38,52.4 99.54,54.56 101.69,54.56 105.25,58.12 105.25,60.91 105.63,61.29 105.63,64.98 108.5,67.85 119.56,67.85 120.14,67.26 135.9,67.26 137.07,68.44 137.07,73.13 138.19,74.25 145.02,74.25 146.29,75.52 146.53,75.52 147.16,76.15 147.16,76.95 149.29,79.07 207.11,79.07 207.49,79.45 221.6,79.45 222.47,80.32 236.72,80.32 238.08,78.96 238.08,77.58 237.71,77.22 237.71,75.81 237.33,75.43 237.33,74.53 v3(237.74,74.12)
  BOTTOM w0.104: C2041.2 50.03,76.46 49.84,76.27 49.84,75.46 v1(50.12,75.18) ; v3(237.74,74.12) 237.78,74.12 237.89,74.02 237.89,72.7 238.1,72.49 U2.B21
PCIE4_TBT_TX_DP3: length 238
  IN05 w0.114: v3(237.74,74.76) 238.02,74.48 238.27,74.48 238.53,74.74 238.53,75.03 238.37,75.19 237.86,75.19 237.74,75.3 237.74,75.46 237.98,75.7 237.98,77.11 238.35,77.47 238.35,79.07 236.83,80.59 222.36,80.59 221.49,79.72 207.38,79.72 207,79.34 149.17,79.34 146.9,77.06 146.9,76.26 146.42,75.78 146.18,75.78 144.91,74.51 138.08,74.51 136.81,73.24 136.81,68.55 135.79,67.53 120.25,67.53 119.67,68.11 108.39,68.11 105.37,65.09 105.37,61.4 104.99,61.02 104.99,58.23 101.58,54.83 99.43,54.83 97.27,52.67 95.36,52.67 93.84,51.15 91.27,51.15 90.88,51.53 78.98,51.53 78.47,51.02 76.79,51.02 75.9,51.91 72.72,51.91 71.33,53.31 65.87,53.31 64.36,54.81 64.36,55.33 63.98,55.71 63.69,55.71 60.93,58.47 60.93,61.42 59.66,62.69 59.66,64.34 58.77,65.23 57.88,65.23 53.19,69.91 53.19,72.07 52.66,72.61 51.77,72.61 50.24,74.13 49.61,74.13 48.61,75.14 48.61,76.03 48.99,76.41 49.37,76.41 49.56,76.22 49.56,75.28 49.46,75.18 v1(49.31,75.18)
  BOTTOM w0.104: v3(237.74,74.76) 238.14,74.35 238.14,73.1 U2.A21 ; C2039.2 49.4,76.46 49.59,76.27 49.59,75.46 v1(49.31,75.18)
PCIE9_SSD2_RX_DN0: length 146.2
  IN05 w0.076: v3(232.63,70.55) 232.39,70.3 232.31,70.3 232.21,70.41 232.21,70.83 232.26,70.88 232.26,70.9
  IN05 w0.114: 232.26,70.9 232.26,71.44 231.05,72.65 230.11,72.65 228.54,74.22 225.37,74.22 222.63,71.48 222.63,65.21 222.24,64.82 222.24,63.86 221.02,62.63 220.41,62.63 213.68,55.9 188.76,55.9 186.98,54.12 153.65,54.12 150.76,51.24 120.26,51.24 117.91,53.59 117.91,55 118.06,55.15 v1(118.31,55.15)
  BOTTOM w0.104: R482.1 110.36,57.18 111.04,57.18 111.37,56.84 111.37,55.83 114.16,53.04 116.79,53.04 118.03,54.27 118.03,54.87 v1(118.31,55.15) ; v3(232.63,70.55) 233,70.55 233.11,70.44 U2.G31
PCIE9_SSD2_RX_DP0: length 146.2
  IN05 w0.076: v3(232.63,69.9) 232.39,70.15 232.25,70.15 232.06,70.34 232.06,70.83 232,70.88 232,70.9
  IN05 w0.114: 232,70.9 232,71.33 230.94,72.39 230,72.39 228.43,73.95 225.48,73.95 222.89,71.36 222.89,65.09 222.51,64.71 222.51,63.74 221.13,62.36 220.52,62.36 213.79,55.64 188.87,55.64 187.09,53.86 153.76,53.86 150.87,50.97 120.15,50.97 117.64,53.48 117.64,55 v1(117.49,55.15)
  BOTTOM w0.104: R481.1 110.15,57.66 110.38,57.43 111.14,57.43 111.63,56.95 v1(111.63,56.21) 111.63,55.93 114.27,53.29 116.68,53.29 117.77,54.38 117.77,55.05 117.66,55.15 v1(117.49,55.15) ; U2.H31 232.78,69.9 v3(232.63,69.9)
PCIE9_SSD2_RX_R_DN0: length 27.6
  BOTTOM w0.104: R482.2 109.04,57.18 108.22,57.18 v1(107.71,57.69) 107.21,58.19 107.21,61.37 106.4,62.18 103.6,62.18 102.05,63.73 102.05,75.24 102.73,75.92 104.91,75.92 105.03,76.04 JSSD2.43
PCIE9_SSD2_RX_R_DP0: length 27.6
  BOTTOM w0.104: JSSD2.41 105.03,75.54 104.91,75.66 102.84,75.66 102.31,75.13 102.31,63.84 103.71,62.44 106.5,62.44 107.46,61.48 107.46,58.3 108.32,57.44 108.55,57.44 108.66,57.54 108.66,58.14 108.83,58.32 109.04,58.32 109.24,58.12 R481.2
PCIE9_SSD2_TX_C_DN0: length 2.6
  BOTTOM w0.104: JSSD2.47 106.67,77.04 106.82,77.19 107,77.19 107.08,77.11 107.08,76.86 107.31,76.64 107.6,76.64 107.93,76.31 C197.1
PCIE9_SSD2_TX_C_DP0: length 2.6
  BOTTOM w0.104: JSSD2.49 106.69,77.54 106.78,77.45 107.11,77.45 107.34,77.22 107.34,76.97 107.42,76.89 107.59,76.89 107.93,77.23 C198.1
PCIE9_SSD2_TX_DN0: length 153.1
  IN05 w0.114: v3(217.01,74.5) 217.14,74.63 217.14,74.98 216.89,75.24 213.81,75.24 212.82,74.25 202.41,74.25 201.52,73.36 183.36,73.36 183.03,73.03 168.68,73.03 168.43,72.78 149.89,72.78 149.58,72.47 149.58,68.28 148.31,67.01 146.15,67.01 145.06,65.92 143.03,65.92 140.04,62.93 114.79,62.93 v1(113.89,63.83)
  BOTTOM w0.076: 232.55,74.38 232.55,74.37 232.49,74.32 232.49,73.97 233.42,73.04 233.42,72.39 U2.C31
  BOTTOM w0.104: v1(113.89,63.83) 114.14,63.83 114.29,63.98 114.29,66.61 113.86,67.03 v1(113.86,67.52) 113.86,70.84 109.82,74.89 109.82,76.55 109.64,76.73 109.06,76.73 108.84,76.52 C197.2 ; 232.55,74.38 232.55,74.84 232.13,75.26 232.13,76.34 227.87,80.6 221.84,80.6 217.14,75.9 217.14,74.63 v3(217.01,74.5)
PCIE9_SSD2_TX_DP0: length 153.1
  IN05 w0.114: v3(217.77,74.5) 217.55,74.5 217.41,74.64 217.41,75.09 217,75.51 213.7,75.51 212.71,74.51 202.3,74.51 201.41,73.63 183.25,73.63 182.92,73.3 168.57,73.3 168.32,73.05 149.78,73.05 149.31,72.58 149.31,68.39 148.19,67.28 146.04,67.28 144.95,66.19 142.92,66.19 139.93,63.2 114.9,63.2 114.71,63.39 v1(114.71,63.83)
  BOTTOM w0.076: U2.B31 233.05,72.54 233.19,72.39 233.27,72.47 233.27,72.98 232.34,73.9 232.34,74.32 232.29,74.37 232.29,74.38
  BOTTOM w0.104: 232.29,74.38 232.29,74.74 231.87,75.15 231.87,76.23 227.76,80.34 227.47,80.34 227.34,80.22 226.93,80.22 226.8,80.34 226.38,80.34 226.26,80.22 225.84,80.22 225.72,80.34 225.3,80.34 225.18,80.22 224.76,80.22 224.64,80.34 221.94,80.34 217.4,75.79 217.4,75.01 217.47,74.93 217.92,74.93 217.98,74.88 217.98,74.58 217.9,74.5 v3(217.77,74.5) ; C198.2 109.15,76.99 109.75,76.99 110.08,76.66 110.08,74.99 114.12,70.95 114.12,67.14 114.54,66.72 114.54,64 v1(114.71,63.83)
PCIE10_SSD2_RX_DN1: length 162.9
  IN05 w0.076: 234.26,71.27 234.26,71.26 234.26,71.18 234.44,71.01 234.44,70.37 234.17,70.11 233.95,70.11 v3(233.78,69.93)
  IN05 w0.114: 234.26,71.27 234.17,71.36 234.17,71.5 229.79,75.88 224.44,75.88 221.1,72.54 221.1,66.25 218.94,64.09 218.93,64.09 212.52,57.68 194.95,57.68 194.64,57.99 188.19,57.99 186.86,56.66 153.66,56.66 150.08,53.09 123.97,53.09 122.99,54.06 122.99,54.86 122.99,54.86 v1(123.21,55.08)
  BOTTOM w0.104: v1(123.21,55.08) 122.96,54.82 122.96,53.99 122.64,53.67 122.03,53.67 121.51,54.19 121.51,57.23 117.7,61.04 113.76,61.04 111.4,63.4 v1(111.4,69.8) 111.4,70.52 109.25,72.66 107,72.66 106.88,72.54 JSSD2.29 ; U2.G29 234.25,70.18 234,69.93 v3(233.78,69.93)
PCIE10_SSD2_RX_DP1: length 162.9
  IN05 w0.076: 234.07,71.08 234.08,71.07 234.16,71.07 234.28,70.95 234.28,70.44 234.11,70.26 233.95,70.26 233.78,70.44 v3(233.78,70.56)
  IN05 w0.114: 234.07,71.08 233.99,71.16 233.9,71.25 233.9,71.39 229.68,75.61 224.55,75.61 221.37,72.43 221.37,66.14 219.05,63.82 219.04,63.82 212.63,57.41 194.84,57.41 194.53,57.73 188.3,57.73 186.97,56.4 153.77,56.4 150.19,52.82 123.86,52.82 122.73,53.95 122.73,54.75 v1(122.39,55.08)
  BOTTOM w0.104: v1(122.39,55.08) 122.12,54.8 122.12,54.64 122.27,54.49 122.57,54.49 122.7,54.36 122.7,54.1 122.53,53.93 122.14,53.93 121.76,54.3 121.76,57.34 117.8,61.3 113.87,61.3 111.65,63.51 111.65,70.62 109.36,72.92 107,72.92 106.88,73.04 JSSD2.31 ; U2.E29 233.78,70.64 v3(233.78,70.56)
PCIE10_SSD2_TX_C_DN1: length 2
  BOTTOM w0.104: JSSD2.35 106.88,74.04 107,74.16 107.45,74.16 C199.1
PCIE10_SSD2_TX_C_DP1: length 2
  BOTTOM w0.104: JSSD2.37 106.88,74.54 107,74.42 107.4,74.42 C200.1
PCIE10_SSD2_TX_DN1: length 152.6
  IN05 w0.114: v1(112.26,63.83) 112.41,63.68 112.41,63.15 113.52,62.04 142.22,62.04 144.37,64.19 144.37,64.74 144.66,65.03 145.66,65.03 146.75,66.12 148.94,66.12 149.7,66.88 182.49,66.88 184.12,68.51 184.12,71.96 184.63,72.47 196.95,72.47 197.84,71.58 200.65,71.58 203.57,68.66 206.11,68.66 207.88,70.43 210.52,70.43 213.43,73.33 216.14,73.33 v3(216.25,73.22)
  BOTTOM w0.076: 231.21,75.24 231.21,75.22 231.26,75.17 231.26,74.35 231.72,73.89 231.72,73.65 232.13,73.24 232.13,72.91 232.33,72.71 232.33,72.14 U2.C32
  BOTTOM w0.104: 231.21,75.24 231.21,75.65 227.78,79.07 221.95,79.07 219.55,76.68 219.55,74.6 218.41,73.46 216.49,73.46 v3(216.25,73.22) ; C199.2 108.58,73.94 108.58,74.15 108.72,74.29 109.28,74.29 112.62,70.95 v1(112.62,70.18) 112.62,64.19 v1(112.26,63.83)
PCIE10_SSD2_TX_DP1: length 152.6
  IN05 w0.114: v3(216.25,74) 216.25,73.82 216.03,73.6 213.32,73.6 210.41,70.69 207.77,70.69 206,68.93 203.68,68.93 200.76,71.85 197.95,71.85 197.06,72.74 184.52,72.74 183.85,72.07 183.85,68.62 182.38,67.15 149.59,67.15 148.83,66.39 146.64,66.39 145.55,65.3 144.55,65.3 144.1,64.85 144.1,64.3 142.11,62.31 113.63,62.31 112.68,63.26 112.68,63.59 112.92,63.83 v1(113.08,63.83)
  BOTTOM w0.076: 231.47,75.24 231.47,75.23 231.41,75.18 231.41,74.41 231.87,73.96 231.87,73.71 232.28,73.31 232.28,72.98 232.56,72.69 U2.B32
  BOTTOM w0.104: v3(216.25,74) 216.25,73.82 216.35,73.72 218.3,73.72 219.3,74.71 219.3,76.79 221.84,79.33 227.89,79.33 231.47,75.75 231.47,75.24 ; C200.2 108.87,74.54 109.38,74.54 112.87,71.05 112.87,64.04 v1(113.08,63.83)
PCIE11_SSD2_RX_DN2: length 159.4
  IN05 w0.076: 233.2,69.29 233.2,69.29 233.14,69.23 233.14,68.6 232.92,68.38 232.76,68.38 v3(232.53,68.15)
  IN05 w0.114: 233.2,69.29 233.2,69.42 233.33,69.55 233.33,71.4 232.77,71.96 232.69,71.96 229.56,75.09 224.97,75.09 221.86,71.98 221.86,65.66 221.09,64.89 221.09,64.6 213.28,56.79 188.39,56.79 186.61,55.01 153.26,55.01 150.41,52.16 122.34,52.16 120.45,54.05 120.45,54.88 v1(120.73,55.15)
  BOTTOM w0.104: U2.L31 232.64,68.05 v3(232.53,68.15) ; v1(120.73,55.15) 120.6,55.02 120.6,54.68 120.3,54.39 119.3,54.39 118.84,54.84 118.84,56.59 116.68,58.75 113.75,58.75 108.94,63.57 108.94,68.32 107.72,69.54 JSSD2.17
PCIE11_SSD2_RX_DP2: length 159.4
  IN05 w0.076: v3(232.53,68.91) 232.51,68.89 232.51,68.66 232.63,68.53 232.86,68.53 232.99,68.66 232.99,69.22 232.93,69.28 232.93,69.29
  IN05 w0.114: v1(119.91,55.15) 120.19,54.88 120.19,53.94 122.23,51.9 150.52,51.9 153.38,54.75 186.72,54.75 188.5,56.52 213.39,56.52 221.36,64.49 221.36,64.78 222.13,65.55 222.13,71.87 225.08,74.83 229.45,74.83 232.58,71.7 232.66,71.7 233.06,71.29 233.06,69.66 232.93,69.53 232.93,69.29
  BOTTOM w0.104: v1(119.91,55.15) 120.13,55.15 120.34,54.94 120.34,54.79 120.19,54.64 119.4,54.64 119.1,54.95 119.1,56.7 116.79,59.01 113.86,59.01 109.19,63.68 v1(109.19,65.99) 109.19,68.43 107.58,70.04 JSSD2.19 ; v3(232.53,68.91) 232.64,68.81 U2.K31
PCIE11_SSD2_TX_C_DN2: length 2
  BOTTOM w0.104: JSSD2.23 106.88,71.04 107,71.16 107.49,71.16 107.74,70.91 C201.1
PCIE11_SSD2_TX_C_DP2: length 2
  BOTTOM w0.104: C202.1 107.32,71.42 107,71.42 106.88,71.54 JSSD2.25
PCIE11_SSD2_TX_DN2: length 145.8
  IN05 w0.114: v3(216.25,71.25) 216.15,71.35 214.62,71.35 210.41,67.14 186.41,67.14 185.19,65.92 150.14,65.92 149.45,65.23 147.12,65.23 146.65,64.77 146.65,63.2 144.61,61.15 111.1,61.15 110.12,62.13 110.12,63.46 v1(109.95,63.63)
  BOTTOM w0.076: 230.23,75.37 230.24,75.37 230.31,75.37 230.47,75.2 230.47,74.63 230.72,74.38 231.34,73.77 231.34,73.49 231.67,73.16 231.67,72.45 U2.C33
  BOTTOM w0.104: C201.2 108.61,70.86 108.61,71.21 108.78,71.38 109.14,71.38 110.21,70.31 v1(110.21,68.28) 110.21,63.89 v1(109.95,63.63) ; v3(216.25,71.25) 216.25,71.26 216.42,71.43 218.11,71.43 220.34,73.66 220.34,75.55 222.98,78.18 227.42,78.18 230.23,75.37
PCIE11_SSD2_TX_DP2: length 145.8
  IN05 w0.114: v1(110.76,63.63) 110.61,63.63 110.39,63.41 110.39,62.24 111.21,61.42 144.5,61.42 146.39,63.31 146.39,64.88 147.01,65.5 149.34,65.5 150.03,66.19 185.08,66.19 186.29,67.4 210.3,67.4 214.51,71.62 216.03,71.62 216.25,71.83 v3(216.25,72.04)
  BOTTOM w0.076: 230.41,75.55 230.42,75.54 230.42,75.47 230.49,75.4 230.63,75.26 230.63,74.69 230.83,74.49 231.49,73.83 231.49,73.55 231.82,73.22 231.82,72.7 231.94,72.58 U2.B33
  BOTTOM w0.104: v3(216.25,72.04) 216.25,71.83 216.4,71.68 218,71.68 220.09,73.77 220.09,75.65 222.87,78.44 227.52,78.44 230.41,75.55 ; v1(110.76,63.63) 110.46,63.93 110.46,70.42 109.24,71.63 108.86,71.63 C202.2
PCIE12_SSD2_RX_DN3: length 154.8
  IN05 w0.114: v1(116.41,55.17) 116.66,55.17 116.76,55.07 116.76,54.89 116.53,54.66 116.19,54.66 116.01,54.49 116.01,53.2 118.89,50.32 151.11,50.32 153.26,52.47 186.59,52.47 189.13,55.01 214.47,55.01 220.64,61.18 220.94,61.18 223.39,63.63 223.39,70.97 225.04,72.62 229.08,72.62 229.77,71.93 230.77,71.93 231.27,71.43 231.27,70.73 231.36,70.64 231.57,70.64 v3(231.62,70.69)
  BOTTOM w0.104: v3(231.62,70.69) 232.12,70.19 U2.G33 ; JSSD2.5 106.88,66.54 107,66.66 107.15,66.66 107.46,66.35 107.46,63.66 112.49,58.63 112.49,56.36 114.97,53.88 115.97,53.88 116.29,54.19 116.29,55.05 v1(116.41,55.17)
PCIE12_SSD2_RX_DP3: length 154.8
  IN05 w0.114: v3(231.62,69.85) 231.62,69.98 231.01,70.59 231.01,71.32 230.66,71.66 229.65,71.66 228.97,72.35 225.15,72.35 223.65,70.86 223.65,63.52 221.05,60.91 220.75,60.91 214.58,54.75 189.24,54.75 186.7,52.21 153.38,52.21 151.23,50.06 118.78,50.06 115.74,53.09 115.74,55.02 v1(115.59,55.17)
  BOTTOM w0.104: JSSD2.7 106.88,67.04 107,66.92 107.25,66.92 107.72,66.46 107.72,63.76 112.75,58.74 v1(112.75,57.74) 112.75,56.47 115.08,54.13 115.87,54.13 116.03,54.3 116.03,54.51 115.93,54.61 115.62,54.61 115.44,54.79 115.44,55.02 v1(115.59,55.17) ; v3(231.62,69.85) 231.62,69.8 232.01,69.41 U2.H33
PCIE12_SSD2_TX_C_DN3: length 14.6
  BOTTOM w0.104: C203.1 109.29,60.73 109.18,60.62 108.95,60.62 108.89,60.69 108.89,61.45 v1(108.08,62.26) 107.27,63.07 104.22,63.07 103.35,63.94 103.35,67.92 103.59,68.16 104.91,68.16 105.03,68.04 JSSD2.11
PCIE12_SSD2_TX_C_DP3: length 14.5
  BOTTOM w0.104: JSSD2.13 105.03,68.54 104.91,68.42 103.49,68.42 103.09,68.02 103.09,63.83 104.11,62.82 107.16,62.82 108.63,61.34 108.63,60.94 C204.1
PCIE12_SSD2_TX_DN3: length 137.5
  IN05 w0.114: v3(216.25,69.67) 216.25,69.8 216,70.05 214.97,70.05 211.17,66.25 186.79,66.25 185.57,65.03 150.9,65.03 150.6,64.74 150.6,64.36 149.71,63.47 149.71,62.83 148.19,61.31 148.19,60.17 147.79,59.77 134.85,59.77 134.35,60.27 109.81,60.27 108.85,59.3 108.85,59.14 109.07,58.92 v1(109.28,58.92)
  BOTTOM w0.076: 226.95,77.29 226.97,77.29 227.02,77.35 227.18,77.35 230.96,73.57 230.96,72.97 U2.B35
  BOTTOM w0.104: v3(216.25,69.67) 216.4,69.82 217.92,69.82 v1(220.71,72.61) 221.08,72.98 221.08,75.01 223.36,77.29 226.95,77.29 ; C203.2 109.3,59.82 109,59.52 109,59.2 v1(109.28,58.92)
PCIE12_SSD2_TX_DP3: length 137.5
  IN05 w0.114: v1(108.46,58.92) 108.58,59.04 108.58,59.41 109.7,60.53 134.46,60.53 134.96,60.04 147.68,60.04 147.92,60.28 147.92,61.42 149.45,62.94 149.45,63.58 150.34,64.47 150.34,64.85 150.79,65.3 185.46,65.3 186.68,66.51 211.06,66.51 214.86,70.31 216.12,70.31 v3(216.25,70.45)
  BOTTOM w0.076: 226.95,77.55 226.97,77.55 227.02,77.5 227.25,77.5 231.11,73.64 231.11,73.1 231.22,73 U2.A35
  BOTTOM w0.104: 226.95,77.55 223.25,77.55 220.82,75.12 220.82,73.08 217.81,70.08 216.49,70.08 216.25,70.32 v3(216.25,70.45) ; C204.2 108.44,59.82 108.74,59.52 108.74,59.2 v1(108.46,58.92)
PCIE13_SSD1_RX_DN0: length 173.5
  IN05 w0.114: v1(103.35,50.8) 103.17,50.63 101.54,50.63 99.38,48.47 99.38,39.86 101.96,37.28 109.83,37.28 118.71,46.16 152.55,46.16 153.71,47.32 172.18,47.32 173,48.14 187.79,48.14 189.76,50.12 217.77,50.12 220.81,53.15 222.46,53.15 223.12,53.82 223.12,54.83 223.57,55.29 225.61,55.29 228.07,57.75 228.07,61.15 227.53,61.7 227.53,64.7 228.16,65.33 228.16,67.01 229.59,68.43 229.59,69.68 229.96,70.05 230.52,70.05 v3(230.57,70.01)
  BOTTOM w0.104: JSSD1.41 105.2,51.17 104.95,51.41 102.58,51.41 102.43,51.26 102.43,50.59 102.7,50.33 102.83,50.33 102.97,50.46 102.97,50.56 102.86,50.66 102.86,50.89 102.99,51.02 103.12,51.02 v1(103.35,50.8) ; v3(230.57,70.01) 230.57,70.1 230.8,70.34 U2.G35
PCIE13_SSD1_RX_DP0: length 173.5
  IN05 w0.114: v1(103.35,49.97) 103.42,50.04 103.42,50.24 103.31,50.36 101.65,50.36 99.65,48.36 99.65,39.97 102.07,37.54 109.71,37.54 118.6,46.43 152.44,46.43 153.6,47.59 172.07,47.59 172.89,48.41 187.68,48.41 189.65,50.38 217.66,50.38 220.7,53.42 222.35,53.42 222.85,53.93 222.85,54.94 223.46,55.55 225.5,55.55 227.81,57.86 227.81,61.04 227.26,61.59 227.26,64.81 227.9,65.44 227.9,67.12 229.32,68.54 229.32,69.79 229.85,70.31 230.1,70.31 230.18,70.39 230.18,70.74 230.25,70.82 230.49,70.82 230.57,70.74 v3(230.57,70.64)
  BOTTOM w0.104: U2.E35 230.68,70.64 v3(230.57,70.64) ; JSSD1.43 102.48,51.67 102.18,51.37 102.18,50.48 102.69,49.97 v1(103.35,49.97)
PCIE13_SSD1_TX_C_DN0: length 2.8
  BOTTOM w0.104: C189.1 108.07,52.41 107.64,52.41 107.26,52.79 107.02,52.79 106.9,52.67 JSSD1.47
PCIE13_SSD1_TX_C_DP0: length 2.9
  BOTTOM w0.104: C190.1 108.45,53.02 108.1,52.66 107.75,52.66 107.36,53.05 107.02,53.05 106.9,53.17 JSSD1.49
PCIE13_SSD1_TX_DN0: length 140
  IN05 w0.114: v1(110.05,52.03) 110.42,52.39 111.08,52.39 111.87,53.18 111.87,56.99 113.76,58.88 127.42,58.88 127.7,59.16 129.1,59.16 129.37,58.88 148.16,58.88 149.7,60.42 149.7,61.04 151.1,62.44 185.39,62.44 186.28,63.33 186.28,64.39 187.24,65.36 212.25,65.36 215.03,68.14 215.88,68.14 v3(216.25,67.77)
  BOTTOM w0.076: U2.C36 230.55,72.43 230.55,72.8 230.63,72.88 230.63,73.35 230.1,73.87 229.95,74.02 229.81,74.02 227.38,76.46 227.17,76.46 227.11,76.41 227.1,76.41
  BOTTOM w0.104: v3(216.25,67.77) 216.43,67.95 217.32,67.95 219.55,70.18 220.44,70.18 v1(221.31,71.05) 221.51,71.25 221.51,71.9 221.97,72.36 221.97,74.63 223.74,76.41 227.1,76.41 ; C189.2 109.72,52.38 109.93,52.38 110.05,52.25 v1(110.05,52.03)
PCIE13_SSD1_TX_DP0: length 139.9
  IN05 w0.114: v1(110.05,53.04) 110.44,52.66 110.97,52.66 111.6,53.29 111.6,57.1 113.65,59.15 127.31,59.15 127.59,59.42 129.21,59.42 129.48,59.15 148.05,59.15 149.44,60.53 149.44,61.15 150.99,62.7 185.28,62.7 186.01,63.44 186.01,64.5 187.13,65.62 212.14,65.62 214.92,68.41 215.87,68.41 v3(216.25,68.79)
  BOTTOM w0.076: U2.B36 230.78,72.62 230.78,73.41 230.21,73.98 230.02,74.17 229.88,74.17 227.44,76.61 227.17,76.61 227.11,76.66 227.1,76.66
  BOTTOM w0.104: v1(110.05,53.04) 110.05,52.81 109.95,52.71 109.7,52.71 C190.2 ; v3(216.25,68.79) 216.25,68.41 216.45,68.21 217.21,68.21 219.45,70.44 220.33,70.44 221.25,71.36 221.25,72.01 221.71,72.47 221.71,74.74 223.64,76.66 227.1,76.66
PCIE14_SSD1_RX_DN1: length 161.1
  IN05 w0.076: 227.2,68.97 227.21,68.97 227.26,68.91 227.37,68.91 228.42,69.97 228.42,70.29 228.56,70.43 228.56,71.53 228.63,71.6 228.85,71.6 228.92,71.53 v3(228.92,71.45)
  IN05 w0.114: v1(103.07,47.55) 102.79,47.84 102.29,47.84 101.58,47.13 101.58,41.57 104.71,38.43 109.29,38.43 118.2,47.34 151.9,47.34 153.86,49.3 187.31,49.3 189.9,51.88 216.88,51.88 218.92,53.93 219.94,53.93 221.22,55.21 221.47,55.21 222.59,56.32 222.59,56.96 224.27,58.64 225.41,58.64 226.38,59.61 226.38,65.15 226.85,65.62 226.85,66.87 226.63,67.1 226.63,68.63 226.97,68.97 227.2,68.97
  BOTTOM w0.104: v1(103.07,47.55) 103.41,47.89 104.14,47.89 104.49,48.24 104.98,48.24 105.05,48.17 JSSD1.29 ; v3(228.92,71.45) 228.92,71.67 229.05,71.8 229.46,71.8 229.57,71.7 229.57,71.52 229.47,71.42 U2.D39
PCIE14_SSD1_RX_DP1: length 161.1
  IN05 w0.076: 227.2,68.7 227.21,68.7 227.26,68.76 227.43,68.76 228.57,69.9 228.57,70.22 228.71,70.36 228.71,70.6 v3(228.92,70.82)
  IN05 w0.114: v1(103.07,48.38) 102.79,48.1 102.18,48.1 101.32,47.24 101.32,41.46 104.6,38.17 109.41,38.17 118.31,47.07 152.01,47.07 153.97,49.03 187.42,49.03 190.01,51.62 216.99,51.62 219.03,53.66 220.05,53.66 221.33,54.94 221.58,54.94 222.85,56.21 222.85,56.85 224.38,58.37 225.52,58.37 226.65,59.5 226.65,65.04 227.12,65.51 227.12,66.98 226.9,67.21 226.9,68.52 227.08,68.7 227.2,68.7
  BOTTOM w0.104: JSSD1.31 105.05,48.67 104.88,48.5 104.38,48.5 104.03,48.15 103.3,48.15 v1(103.07,48.38) ; U2.E37 229.71,70.82 v3(228.92,70.82)
PCIE14_SSD1_TX_C_DN1: length 2.7
  BOTTOM w0.104: JSSD1.35 106.9,49.67 107.02,49.79 107.56,49.79 107.64,49.87 108.08,49.87 C191.1
PCIE14_SSD1_TX_C_DP1: length 2.7
  BOTTOM w0.104: C192.1 108.07,50.12 107.53,50.12 107.46,50.05 107.02,50.05 106.9,50.17 JSSD1.37
PCIE14_SSD1_TX_DN1: length 145.3
  IN05 w0.114: v1(110.05,49.49) 110.05,49.58 109.77,49.86 108.67,49.86 108.55,49.75 108.55,48.85 108.68,48.72 111.35,48.72 112.87,50.24 112.87,56.6 114.54,58.26 127.79,58.26 128.01,58.03 128.98,58.03 129.21,58.26 150.1,58.26 152.95,61.11 152.96,61.11 153.42,61.56 185.53,61.56 186.43,62.46 201.04,62.46 202.41,63.83 211.61,63.83 214.06,66.29 216.35,66.29 216.48,66.42 216.48,66.75 216.35,66.88 v3(216.25,66.88)
  BOTTOM w0.076: 227.01,75.85 227.02,75.85 227.08,75.8 227.53,75.8 229.59,73.74 229.59,73.32 229.71,73.19 229.71,72.68 U2.B38
  BOTTOM w0.104: v3(216.25,66.88) 216.25,66.53 216.4,66.38 216.76,66.38 219.98,69.6 221.02,69.6 222.17,70.75 222.17,71.68 222.6,72.11 222.6,74.35 224.09,75.85 227.01,75.85 ; v1(110.05,49.49) 110.05,49.71 109.93,49.84 109.72,49.84 C191.2
PCIE14_SSD1_TX_DP1: length 145.3
  IN05 w0.114: v3(216.25,65.87) 216.09,66.03 214.18,66.03 211.72,63.57 202.52,63.57 201.15,62.2 186.54,62.2 185.64,61.29 153.53,61.29 153.07,60.84 153.06,60.84 150.21,57.99 129.32,57.99 129.09,57.76 127.9,57.76 127.68,57.99 114.65,57.99 113.14,56.48 113.14,50.13 111.46,48.45 108.57,48.45 108.29,48.74 108.29,49.86 108.56,50.13 109.68,50.13 v1(110.05,50.5)
  BOTTOM w0.076: U2.C38 229.56,72.32 229.56,73.13 229.43,73.26 229.43,73.68 227.46,75.64 227.08,75.64 227.02,75.59 227.01,75.59
  BOTTOM w0.104: C192.2 109.7,50.17 109.95,50.17 110.05,50.27 v1(110.05,50.5) ; v3(216.25,65.87) 216.42,66.04 216.79,66.04 220.09,69.34 v1(220.7,69.34) 221.12,69.34 222.42,70.64 222.42,71.58 222.85,72.01 222.85,74.25 224.2,75.59 227.01,75.59
PCIE15_SSD1_RX_DN2: length 153.4
  IN05 w0.076: 226.89,69.78 226.9,69.78 226.95,69.73 227.52,69.73 227.96,70.17 227.96,70.56 228.1,70.71 228.1,70.83 v3(228.01,70.92)
  IN05 w0.114: v1(104.08,44.89) 104.29,44.69 104.29,44.43 104.21,44.35 103.7,44.35 103.61,44.44 103.61,45.28 103.44,45.45 103.18,45.45 102.98,45.24 102.98,44.59 103.09,44.48 103.09,44.02 102.98,43.9 102.98,43.45 103.09,43.33 103.09,42.88 102.98,42.76 102.98,41.62 105.27,39.32 108.91,39.32 117.93,48.34 151.65,48.34 153.75,50.44 187.2,50.44 189.67,52.91 215.62,52.91 218.28,55.58 219.81,55.58 223.27,59.05 223.27,61 225.27,63 225.27,65.18 225.69,65.6 225.69,65.88 225.52,66.04 225.52,66.63 225.83,66.93 225.83,68.92 226.69,69.78 226.89,69.78
  BOTTOM w0.104: U2.F41 228.44,70.83 228.35,70.92 v3(228.01,70.92) ; v1(104.08,44.89) 104.43,45.23 104.98,45.23 104.99,45.23 105,45.23 105.05,45.17 JSSD1.17
PCIE15_SSD1_RX_DP2: length 153.3
  IN05 w0.076: 226.89,69.52 226.91,69.52 226.96,69.57 227.58,69.57 228.11,70.11 228.11,70.5 228.38,70.77 228.38,71.16 v3(228.01,71.53)
  IN05 w0.114: 226.89,69.52 226.8,69.52 226.09,68.81 226.09,66.82 225.79,66.52 225.79,66.15 225.95,65.99 225.95,65.48 225.53,65.07 225.53,62.89 223.54,60.89 223.54,58.94 219.92,55.31 218.39,55.31 215.73,52.65 189.78,52.65 187.31,50.17 153.86,50.17 151.76,48.07 118.04,48.07 109.02,39.06 105.16,39.06 102.71,41.51 102.71,45.36 103.07,45.72 v1(104.08,45.72)
  BOTTOM w0.104: v1(104.08,45.72) 104.31,45.49 104.87,45.49 105.05,45.67 JSSD1.19 ; U2.E41 228.26,71.28 v3(228.01,71.53)
PCIE15_SSD1_TX_C_DN2: length 2.7
  BOTTOM w0.104: JSSD1.23 106.9,46.67 107.02,46.79 107.54,46.79 107.64,46.69 108.07,46.69 C193.1
PCIE15_SSD1_TX_C_DP2: length 2.7
  BOTTOM w0.104: JSSD1.25 106.9,47.17 107.02,47.05 107.65,47.05 107.75,46.95 108.08,46.95 C194.1
PCIE15_SSD1_TX_DN2: length 141.3
  IN05 w0.114: v1(110.05,46.31) 110.47,46.73 112.26,46.73 114.15,48.62 114.15,56.23 114.9,56.98 127.25,56.98 127.85,56.38 129.39,56.38 129.99,56.98 150.57,56.98 153.24,59.64 185.39,59.64 187.05,61.31 195.27,61.31 195.73,60.84 201.06,60.84 202.64,62.42 211.97,62.42 213.89,64.34 214.09,64.34 v3(214.47,63.96)
  BOTTOM w0.076: 226.64,74.86 226.66,74.86 226.71,74.91 227.53,74.91 229.05,73.38 229.05,72.7 U2.B39
  BOTTOM w0.104: 226.64,74.86 224.73,74.86 223.74,73.87 223.74,71.47 223.36,71.09 223.36,69.95 221.42,68 v1(220.7,68) 220.02,68 216.21,64.19 214.71,64.19 v3(214.47,63.96) ; C193.2 109.72,46.66 109.93,46.66 110.05,46.54 v1(110.05,46.31)
PCIE15_SSD1_TX_DP2: length 141.3
  IN05 w0.114: v1(110.05,47.33) 110.05,47.25 110.31,47 112.15,47 113.89,48.73 113.89,56.34 114.79,57.24 127.36,57.24 127.96,56.64 129.28,56.64 129.88,57.24 150.46,57.24 153.13,59.91 185.28,59.91 186.94,61.57 195.38,61.57 195.84,61.11 200.95,61.11 202.53,62.69 211.86,62.69 213.78,64.61 214.1,64.61 v3(214.47,64.98)
  BOTTOM w0.076: 226.64,75.11 226.66,75.11 226.71,75.06 227.59,75.06 229.2,73.45 229.2,73.1 U2.A39
  BOTTOM w0.104: v3(214.47,64.98) 214.47,64.68 214.71,64.45 216.11,64.45 219.92,68.26 221.31,68.26 223.11,70.06 223.11,71.2 223.49,71.58 223.49,73.97 224.63,75.11 226.64,75.11 ; C194.2 109.7,46.99 109.95,46.99 110.05,47.1 v1(110.05,47.33)
PCIE16_SSD1_RX_DN3: length 144.3
  IN05 w0.114: v1(108.12,42.01) 108.12,42.12 107.96,42.28 107.07,42.28 106.57,41.78 106.57,41.27 106.99,40.85 109.16,40.85 117.67,49.36 151.4,49.36 153.63,51.58 186.95,51.58 189.49,54.12 214.84,54.12 217.32,56.61 219.57,56.61 220.56,57.59 220.56,59.12 221.35,59.91 221.98,59.91 222.41,60.34 222.41,61.39 224.57,63.55 224.57,68.8 226.44,70.66 226.44,71.48 226.56,71.61 226.92,71.61 227.05,71.48 227.05,71.28 v3(226.87,71.1)
  BOTTOM w0.104: v1(108.12,42.01) 107.84,42.29 107.02,42.29 106.9,42.17 JSSD1.5 ; U2.D43 227.1,71.47 227.1,71.33 v3(226.87,71.1)
PCIE16_SSD1_RX_DP3: length 144.3
  IN05 w0.114: v3(227.43,70.82) 227.27,70.67 226.82,70.67 224.84,68.69 224.84,63.44 222.68,61.28 222.68,60.23 222.09,59.64 221.46,59.64 220.82,59.01 220.82,57.48 219.68,56.34 217.43,56.34 214.95,53.86 189.6,53.86 187.06,51.32 153.74,51.32 151.52,49.09 117.78,49.09 109.27,40.58 106.87,40.58 106.3,41.16 106.3,41.89 106.96,42.55 107.84,42.55 v1(108.12,42.83)
  BOTTOM w0.104: v3(227.43,70.82) 227.6,71 U2.E42 ; JSSD1.7 106.9,42.67 107.02,42.55 107.84,42.55 v1(108.12,42.83)
PCIE16_SSD1_TX_C_DN3: length 2.8
  BOTTOM w0.104: C195.1 108.08,44.15 107.59,44.15 107.23,43.79 107.02,43.79 106.9,43.67 JSSD1.11
PCIE16_SSD1_TX_C_DP3: length 2.8
  BOTTOM w0.104: JSSD1.13 106.9,44.17 107.02,44.05 107.13,44.05 107.48,44.41 108.07,44.41 C196.1
PCIE16_SSD1_TX_DN3: length 141.9
  IN05 w0.114: v3(211.93,59.52) 211.93,59.67 211.71,59.9 210.66,59.9 209.96,59.19 195.72,59.19 194.5,60.42 193.16,60.42 192.25,59.5 187.41,59.5 186.15,58.25 153.1,58.25 150.82,55.96 131.28,55.96 130.72,55.4 126.85,55.4 126.29,55.96 115.41,55.96 115.04,55.6 115.04,47.95 111.23,44.14 110.33,44.14 110.05,43.86 v1(110.05,43.77)
  BOTTOM w0.076: U2.A41 228.41,73 228.49,73.07 228.49,73.22 227.44,74.27 225.72,74.27 225.67,74.22 225.65,74.22
  BOTTOM w0.104: 225.65,74.22 225.37,74.22 224.63,73.49 224.63,71.14 224.28,70.79 224.28,69.07 221.97,66.75 v1(221.08,66.75) 220.04,66.75 213.18,59.9 212.15,59.9 211.93,59.68 v3(211.93,59.52) ; v1(110.05,43.77) 110.05,44 109.93,44.12 109.72,44.12 C195.2
PCIE16_SSD1_TX_DP3: length 141.9
  IN05 w0.114: v1(110.05,44.79) 110.44,44.4 111.12,44.4 114.78,48.06 114.78,55.71 115.3,56.23 126.4,56.23 126.96,55.66 130.61,55.66 131.17,56.23 150.71,56.23 152.99,58.51 186.04,58.51 187.3,59.77 192.14,59.77 193.05,60.68 194.61,60.68 195.83,59.46 209.85,59.46 210.55,60.16 211.81,60.16 211.93,60.29 v3(211.93,60.53)
  BOTTOM w0.076: 225.65,74.48 225.66,74.48 225.71,74.43 227.5,74.43 228.64,73.29 228.64,73.1 U2.A40
  BOTTOM w0.104: 225.65,74.48 225.26,74.48 224.38,73.59 224.38,71.25 224.02,70.89 224.02,69.18 221.86,67.01 219.94,67.01 214.83,61.91 213.08,60.15 212.31,60.15 v3(211.93,60.53) ; v1(110.05,44.79) 110.05,44.56 109.95,44.45 109.7,44.45 C196.2
PCIE_AR_RST_N: length 16.7
  TOP w0.097: R2101.1 v1(61.82,92.03)
  IN03 w0.091: v2(49.92,89.63) 50.29,90 50.29,90.5 50.79,91.01 54.83,91.01 55.34,90.5 55.34,90 56.61,88.73 58.77,88.73 61.82,91.77 v1(61.82,92.03)
  BOTTOM w0.178: U2005.L4 50.25,89.96 v2(49.92,89.63)
PCIE_CR_RX_DN: length 86.9
  IN10 w0.114: v3(237.33,70.44) 237.46,70.56 237.65,70.56 237.77,70.44 237.77,68.33 236.56,67.12 236.56,62.32 237.21,61.67 244.32,61.67 244.6,61.4 246.33,61.4 247.7,60.02 249.4,60.02 249.75,59.67 254.59,59.67 254.87,59.39 257.78,59.39 258.59,58.59 261.67,58.59 263.73,60.65 266.56,60.65 267.96,59.25 276.58,59.25 281.66,54.17 283.19,54.17 286.11,51.25 287.38,51.25 287.94,50.69 287.94,45.12 289.16,43.89 290.23,43.89 v1(290.55,43.58)
  BOTTOM w0.104: U2.G22 237.62,70.61 237.5,70.61 v3(237.33,70.44) ; JIO1.24 299.84,43.72 299.77,43.79 299.07,43.79 298.72,44.15 293.95,44.15 293.67,43.87 290.84,43.87 v1(290.55,43.58)
PCIE_CR_RX_DP: length 86.9
  IN10 w0.114: v1(290.55,44.39) 290.32,44.16 289.28,44.16 288.2,45.23 288.2,50.8 287.49,51.51 286.22,51.51 283.3,54.44 281.77,54.44 276.69,59.52 268.07,59.52 266.67,60.91 263.62,60.91 261.56,58.85 258.7,58.85 257.89,59.66 254.99,59.66 254.7,59.94 249.86,59.94 249.51,60.29 247.81,60.29 246.44,61.66 244.71,61.66 244.43,61.94 237.32,61.94 236.82,62.43 236.82,67.01 238.04,68.22 238.04,70.55 237.76,70.83 237.55,70.83 v3(237.33,71.05)
  BOTTOM w0.104: JIO1.23 299.84,44.12 299.77,44.05 299.18,44.05 298.83,44.4 293.85,44.4 293.57,44.12 290.81,44.12 v1(290.55,44.39) ; v3(237.33,71.05) 237.51,70.87 237.62,70.87 U2.E22
PCIE_CR_TX_C_DN: length 2.8
  BOTTOM w0.104: C181.1 298.43,45.73 298.77,45.73 299.51,45 299.77,45 299.85,44.92 JIO1.21
PCIE_CR_TX_C_DP: length 2.8
  BOTTOM w0.104: C182.1 298.43,45.99 298.87,45.99 299.61,45.25 299.77,45.25 299.84,45.32 JIO1.20
PCIE_CR_TX_DN: length 96.3
  IN10 w0.114: v1(243.3,76.58) 243.47,76.42 243.47,75.76 243.24,75.53 242.68,75.53 242.25,75.09 242.25,73.19 243.89,71.54 243.89,70.36 245.71,68.54 247.08,68.54 248.43,67.19 248.43,64.51 249.46,63.49 253.75,63.49 254.6,64.34 254.6,64.98 256.24,66.62 263.99,66.62 266.03,68.66 279.12,68.66 280.32,67.46 280.32,63.58 281.73,62.17 285.86,62.17 289.66,58.37 290.67,58.37 292.88,56.16 292.88,52.11 294.74,50.26 294.74,46.43 295.53,45.64 296.09,45.64 v1(296.27,45.45)
  BOTTOM w0.076: 238.02,75.9 238.02,75.88 237.97,75.83 237.97,75.52 237.36,74.91 237.36,73.75 237.43,73.68 237.43,72.77 U2.B22
  BOTTOM w0.104: C181.2 296.88,45.73 296.55,45.73 v1(296.27,45.45) ; 238.02,75.9 238.02,77.09 238.27,77.34 240.57,77.34 240.78,77.13 241.69,77.13 241.84,76.99 242.11,76.99 242.25,77.13 242.51,77.13 242.66,76.99 242.93,76.99 243.07,77.13 243.45,77.13 243.61,76.97 243.61,76.83 243.36,76.58 v1(243.3,76.58)
PCIE_CR_TX_DP: length 96.3
  IN10 w0.114: v1(243.94,76.58) 243.84,76.58 243.74,76.48 243.74,75.65 243.35,75.26 242.79,75.26 242.51,74.98 242.51,73.3 244.16,71.65 244.16,70.47 245.82,68.81 247.19,68.81 248.05,67.95 248.7,67.3 248.7,64.62 249.57,63.76 253.64,63.76 254.34,64.45 254.34,65.09 256.13,66.88 263.88,66.88 265.92,68.93 279.23,68.93 280.58,67.57 280.58,63.69 281.84,62.44 285.97,62.44 289.77,58.64 290.78,58.64 293.15,56.27 293.15,52.22 295,50.37 295,46.55 295.64,45.9 296.27,45.9 296.36,46 296.36,46.21 296.3,46.27 v1(296.27,46.27)
  BOTTOM w0.076: 237.76,75.9 237.76,75.89 237.81,75.84 237.81,75.58 237.21,74.97 237.21,73.69 237.28,73.62 237.28,73.06 U2.A23
  BOTTOM w0.104: v1(243.94,76.58) 243.86,76.66 243.86,77.08 243.56,77.39 240.89,77.39 240.67,77.6 238.16,77.6 237.76,77.2 237.76,75.9 ; v1(296.27,46.27) 296.55,45.99 296.88,45.99 C182.2
PCIE_LAN_RX_C_DN: length 2.3
  TOP w0.104: C274.2 48.1,58.45 48.1,58.75 48.43,59.08 48.43,59.34 48.36,59.41 U6.29
PCIE_LAN_RX_C_DP: length 2.3
  TOP w0.104: C275.2 48.36,58.45 48.36,58.65 48.69,58.98 48.69,59.34 48.76,59.41 U6.30
PCIE_LAN_RX_DN: length 208.1
  TOP w0.104: C274.1 48.01,56.87 48.01,56.56 48.36,56.21 51.64,56.21 52.66,57.23 54.76,57.23 v1(55.13,57.61) 56.59,59.06 56.59,60.78 v1(56.79,60.99)
  IN03 w0.114: v3(236.16,69.22) 236.16,69 236.02,68.87 235.55,68.87 235.26,68.58 235.26,66.97 233.81,65.52 233.81,64.25 233.64,64.08 227.29,64.08 226.68,63.47 225.16,63.47 224.39,62.7 223.51,62.7 221.98,61.18 214.2,61.18 209.9,65.48 128.37,65.48 126.97,66.88 117.69,66.88 116.54,68.04 111.84,68.04 110.07,69.8 106.65,69.8 105.9,69.05 90.03,69.05 84.19,63.21 72.72,63.21 70.56,65.37 62.09,65.37 57.12,60.4 56.62,60.4 56.39,60.63 56.39,60.82 56.56,60.99 v1(56.79,60.99)
  BOTTOM w0.104: U2.K24 v3(236.16,69.22)
PCIE_LAN_RX_DP: length 208.1
  TOP w0.104: C275.1 48.51,57.38 48.34,57.38 48.26,57.3 48.26,56.67 48.46,56.47 51.53,56.47 52.55,57.49 54.65,57.49 v1(56.01,58.85) 56.33,59.16 56.33,60.88 56.22,60.99 v1(55.97,60.99)
  IN03 w0.114: v3(236.16,68.45) 236.01,68.6 235.66,68.6 235.53,68.47 235.53,66.86 234.08,65.41 234.08,64.14 233.75,63.81 227.4,63.81 226.79,63.2 225.27,63.2 224.51,62.44 223.62,62.44 222.09,60.91 214.09,60.91 209.79,65.22 128.26,65.22 126.86,66.62 117.58,66.62 116.43,67.77 111.73,67.77 109.96,69.54 106.76,69.54 106.01,68.79 90.14,68.79 84.3,62.94 72.61,62.94 70.45,65.1 62.2,65.1 57.23,60.13 56.51,60.13 56.12,60.52 56.12,60.84 v1(55.97,60.99)
  BOTTOM w0.104: U2.L24 v3(236.16,68.45)
PCIE_LAN_TX_C_DN: length 2.5
  TOP w0.104: U6.36 50.12,62.89 50.19,62.82 51.05,62.82 51.27,62.6 51.49,62.6 C185.1
PCIE_LAN_TX_C_DP: length 2.5
  TOP w0.104: C186.1 51.52,62.34 51.16,62.34 50.94,62.56 50.19,62.56 50.12,62.49 U6.35
PCIE_LAN_TX_DN: length 244.5
  TOP w0.104: v1(82.14,57.61) 81.89,57.36 81.23,57.36 79.38,59.21 76.39,59.21 75.55,58.38 73.76,58.38 72.86,57.48 72.86,56.83 70.09,54.06 62.18,54.06 59.66,56.58 59.66,61.12 58.17,62.62 53.03,62.62 C185.2
  IN05 w0.114: v1(82.14,57.61) 82.27,57.48 83.28,57.48 84.66,56.1 88.63,56.1 90.16,57.62 92.95,57.62 95.24,59.91 95.87,59.91 96.48,60.52 96.48,61.91 97.24,62.68 98,62.68 99.42,64.1 99.42,65.47 100.67,66.71 100.67,68.14 104,71.47 105.05,71.47 106.32,72.74 109.59,72.74 110.09,73.24 113.65,73.24 114.41,74.01 119.97,74.01 120.22,73.75 125.02,73.75 128.35,77.07 128.82,77.07 130.96,79.21 133.97,79.21 135.74,80.99 142.1,80.99 142.96,81.85 142.96,86.01 144.16,87.21 145.53,87.21 146.8,88.48 194.04,88.48 194.39,88.84 194.39,90.11 195.75,91.46 203.37,91.46 203.93,90.9 210.52,90.9 212.06,89.36 212.06,87.84 213.58,86.31 237.46,86.31 243.96,79.82 243.96,79.21 v1(244.09,79.07)
  BOTTOM w0.076: U2.C24 236.3,72.36 236.3,75.85 236.25,75.91 236.25,75.92
  BOTTOM w0.104: 236.25,75.92 236.25,79.21 236.98,79.93 243.44,79.93 243.89,79.49 243.89,79.28 v1(244.09,79.07)
PCIE_LAN_TX_DP: length 244.5
  TOP w0.104: v1(82.14,56.85) 81.88,57.1 81.12,57.1 79.27,58.95 76.5,58.95 75.66,58.12 73.86,58.12 73.12,57.37 73.12,56.72 70.2,53.8 62.07,53.8 59.4,56.47 59.4,61.02 58.06,62.36 53.03,62.36 C186.2
  IN05 w0.114: v1(243.27,79.07) 243.51,79.07 243.69,79.25 243.69,79.7 237.35,86.05 213.47,86.05 211.79,87.73 211.79,89.25 210.41,90.63 203.82,90.63 203.26,91.2 195.86,91.2 194.66,90 194.66,88.73 194.15,88.22 146.91,88.22 145.64,86.95 144.27,86.95 143.23,85.9 143.23,81.74 142.21,80.72 135.85,80.72 134.08,78.95 131.07,78.95 128.93,76.81 128.46,76.81 125.14,73.49 120.11,73.49 119.86,73.74 114.52,73.74 113.76,72.98 110.21,72.98 109.7,72.47 106.43,72.47 105.16,71.2 104.11,71.2 100.93,68.02 100.93,66.6 99.69,65.36 99.69,63.99 98.11,62.41 97.35,62.41 96.74,61.8 96.74,60.4 95.98,59.64 95.35,59.64 93.06,57.36 90.27,57.36 88.74,55.83 84.55,55.83 83.17,57.21 82.35,57.21 82.14,57 v1(82.14,56.85)
  BOTTOM w0.076: 236.51,75.92 236.51,75.91 236.46,75.85 236.46,72.62 236.5,72.58 U2.B24
  BOTTOM w0.104: 236.51,75.92 236.51,77.49 236.64,77.62 236.64,77.91 236.51,78.04 236.51,78.32 236.64,78.46 236.64,78.74 236.51,78.87 236.51,79.1 237.08,79.68 237.28,79.68 237.42,79.53 237.73,79.53 237.88,79.68 238.11,79.68 238.25,79.53 238.56,79.53 238.71,79.68 238.94,79.68 239.09,79.53 239.4,79.53 239.54,79.68 239.78,79.68 239.92,79.53 240.23,79.53 240.37,79.68 240.61,79.68 240.75,79.53 241.06,79.53 241.21,79.68 241.44,79.68 241.59,79.53 241.9,79.53 242.04,79.68 242.27,79.68 242.42,79.53 242.73,79.53 242.87,79.68 243.33,79.68 243.63,79.38 243.63,79.1 243.53,79 243.35,79 v1(243.27,79.07)
PCIE_RBIAS: length 1.2
  TOP w0.254: v2(51.22,83.78) 51.28,83.73 R2015.1
  BOTTOM w0.178: v2(51.22,83.78) 51.55,84.11 U2005.N16
PCIE_RCOMPN: length 3.7
  BOTTOM w0.104: U2.B18 239.89,72.64 239.89,74.14 240.07,74.32
  BOTTOM w0.305: R129.1 240.38,75.82 v2(240.38,75.06) 240.38,74.63 240.07,74.32
PCIE_RCOMPP: length 5.4
  BOTTOM w0.104: U2.C17 239.96,72.31 240.15,72.49 240.15,73.75 240.39,73.99
  BOTTOM w0.305: 240.39,73.99 240.84,74.44 240.84,75.77 R129.2 v2(242.08,76.03)
PCIE_SSD1_CLKREQ_N: length 3.9
  BOTTOM w0.097: Q9.1 95.29,53.79 R512.1 v2(96.79,54.23) 97.12,54.23 97.44,53.92 JSSD1.52
PCIE_SSD1_RST_N: length 99.3
  IN05 w0.091: v1(97.83,39.32) 97.51,39.65 97.51,40.59 92.81,45.29 90.14,45.29 89.13,46.3 83.66,46.3 81.5,44.15 77.06,44.15 75.03,46.18 72.23,46.18 71.34,47.07 67.41,47.07 66.64,47.83 58.26,47.83 57.12,48.97 57.12,50.5 55.09,52.53 54.83,52.53 52.42,54.94 52.42,57.74 51.79,58.37 46.83,58.37 45.7,57.24 41.48,57.24 40.61,58.12 40.61,59.01 39.34,60.28 37.94,60.28 36.93,59.26 35.78,59.26 35.28,59.77 34.13,59.77 33.88,60.02 33.88,61.04 33.24,61.67 v1(32.48,61.67)
  IN10 w0.091: v1(97,53.24) 96.7,52.94 96.7,41.15 97.83,40.01 v1(97.83,39.32)
  BOTTOM w0.097: JSSD1.50 97.18,53.42 v1(97,53.24) ; R478.1 32.81,61.67 v1(32.48,61.67)
PCIE_SSD2_CLKREQ_N: length 33.5
  IN10 w0.091: v1(92.55,51.77) 93.49,52.7 93.49,64.39 94.08,64.98 94.08,72.34 95.22,73.49 v1(95.22,76.15)
  BOTTOM w0.097: Q9.4 93.58,52.79 v1(92.55,51.77) 93.44,50.88 R508.1 ; JSSD2.52 96.98,78.29 96.87,78.18 96.37,78.18 95.22,77.04 v1(95.22,76.15)
PCIE_SSD2_RST_N: length 3.8
  BOTTOM w0.097: R483.1 96.11,77.39 v2(96.14,77.42) 96.51,77.79 JSSD2.50
PCIE_WAKE_N: length 354.7
  TOP w0.097: R459.1 265.65,77.93 265.91,78.18 269.72,78.18 270.23,77.68 270.23,73.87 272.26,71.83 276.45,71.83 276.7,71.58 276.7,66.5 v1(276.32,66.12) ; v3(241.65,49.86) 241.27,49.86 240.63,49.23 240.63,48.85 240.13,48.34 R138.1 ; v2(57.86,89.74) 58.39,89.74 58.77,90.12 R2094.2
  IN03 w0.091: v1(257.65,60.15) 257.65,59.52 258.67,58.5 258.67,51.64 255.85,48.82 255.85,46.44 249.05,39.64 215.17,39.64 209.82,44.99 159.65,44.99 152.88,51.77 118.21,51.77 112.11,45.67 109.82,45.67 107.92,43.77 106.97,43.77 105.7,42.5 91.54,42.5 90.95,43.09 83.11,43.09 82.27,42.24 78.46,42.24 76.93,43.77 71.44,43.77 70.93,43.26 68.86,43.26 67.11,45 67.11,47.4 66.18,48.34 64.61,48.34 v1(63.22,46.94)
  IN05 w0.091: v1(257.65,60.15) 257.65,62.31 258.57,63.23 258.57,63.74 259.02,64.19 259.43,64.19 259.67,64.43 274.25,64.43 275.94,66.12 v1(276.32,66.12)
  IN08 w0.091: v3(241.65,49.86) 242.16,50.37 245.46,50.37 245.59,50.5 251.68,50.5 251.94,50.24 257.02,50.24 258.92,52.15 258.92,59.64 258.67,59.9 257.91,59.9 v1(257.65,60.15)
  IN10 w0.091: v1(63.22,46.94) 66.14,49.86 66.26,49.86 67.53,51.13 67.53,51.36 65.72,53.17 62.33,53.17 60.93,54.56 60.93,63.99 60.04,64.88 60.04,74.07 58.9,75.21 58.9,78.82 57.86,79.86 v2(57.86,89.74)
  BOTTOM w0.097: U2.BC13 242.36,52.23 242.13,52 242.13,51.72 242.03,51.61 242.03,50.62 241.65,50.24 v3(241.65,49.86)
PCIE_WLAN_RX_DN: length 44.8
  IN10 w0.114: v3(238.48,68.45) 238.98,68.96 238.98,69.69 239.2,69.91 239.2,71.8 240.25,72.85 240.25,74.5 242.79,77.04 245.59,77.04 246.35,76.28 262.35,76.28 263.11,77.04 270.35,77.04 271.01,76.38 271.52,76.38 v1(271.75,76.15)
  BOTTOM w0.104: v1(271.75,76.15) 271.54,76.36 270.93,76.36 270.25,77.03 JWLAN1.43 ; v3(238.48,68.45) 238.09,68.07 U2.L22
PCIE_WLAN_RX_DP: length 44.8
  IN10 w0.114: v3(238.48,69.22) 238.62,69.22 238.72,69.31 238.72,69.8 238.93,70.02 238.93,71.91 239.99,72.96 239.99,74.61 242.68,77.31 245.7,77.31 246.46,76.55 262.24,76.55 263,77.31 270.46,77.31 271.12,76.65 271.69,76.65 271.85,76.81 271.85,76.94 v1(271.75,77.04)
  BOTTOM w0.104: U2.K22 238.09,68.83 v3(238.48,69.22) ; v1(271.75,77.04) 271.8,76.99 271.8,76.76 271.65,76.61 271.04,76.61 270.51,77.14 270.51,77.81 270.75,78.06 JWLAN1.41
PCIE_WLAN_TX_C_DN: length 3.8
  BOTTOM w0.104: JWLAN1.37 271.75,79.76 271.87,79.88 271.87,81.23 271.7,81.41 271.09,81.41 270.96,81.28 270.96,81.08 C183.1
PCIE_WLAN_TX_C_DP: length 3.8
  BOTTOM w0.104: JWLAN1.35 272.25,79.76 272.13,79.88 272.13,81.34 271.8,81.66 271.27,81.66 C184.1
PCIE_WLAN_TX_DN: length 45.3
  IN08 w0.114: v1(244.81,77.8) 244.57,77.57 244.57,77.07 244.83,76.81 252.09,76.81 253.22,77.94 256.12,77.94 256.38,77.68 256.38,77.49 v1(256.7,77.17)
  BOTTOM w0.076: U2.C23 237.11,71.98 236.82,72.27 236.82,75.23 237.08,75.48 237.08,75.85 237.03,75.91 237.03,75.92
  BOTTOM w0.104: v1(256.7,77.17) 256.53,77.17 256.19,77.51 256.19,77.74 256.89,78.44 258.29,78.44 261.3,81.45 269.68,81.45 C183.2 ; 237.03,75.92 237.03,77.66 237.99,78.62 v1(239.62,78.62) 244.37,78.62 244.65,78.34 244.65,77.96 v1(244.81,77.8)
PCIE_WLAN_TX_DP: length 45.3
  IN08 w0.114: v1(243.99,77.8) 244.21,77.58 244.3,77.49 244.3,76.96 244.71,76.55 252.2,76.55 253.33,77.68 256,77.68 256.12,77.57 256.12,77.41 v1(255.87,77.17)
  BOTTOM w0.076: 237.28,75.92 237.28,75.91 237.23,75.86 237.23,75.42 236.98,75.16 236.98,72.55 U2.B23
  BOTTOM w0.104: C184.2 269.98,81.7 261.19,81.7 258.18,78.7 256.78,78.7 255.93,77.84 255.93,77.23 v1(255.87,77.17) ; 237.28,75.92 237.28,77.55 238.09,78.36 v1(243.94,78.36) 244.26,78.36 244.39,78.23 244.39,77.39 244.27,77.27 244.01,77.27 243.86,77.42 243.86,77.68 v1(243.99,77.8)
PEG_PRX_C_GTX_N0: length 18.3
  TOP w0.104: v3(238.41,130.37) 238.58,130.2 238.58,130.08 238.47,129.98 238.24,129.98 237.72,130.51 236.59,130.51 235.99,129.9 233.42,129.9 233.06,130.25 230.39,130.25 229.82,129.68 224.04,129.68 223.37,130.36 222.7,130.36 222.6,130.46 222.6,130.69 C662.1
  BOTTOM w0.104: v3(238.41,130.37) 238.69,130.64 G2.BH26
PEG_PRX_C_GTX_N1: length 16.5
  TOP w0.104: v3(240.49,130.37) 240.49,130.98 240.23,131.24 239.73,131.24 239.51,131.01 236.06,131.01 235.61,130.56 233.82,130.56 233.39,130.99 229.99,130.99 229.57,130.57 227.15,130.57 226.32,131.4 C664.1
  BOTTOM w0.104: v3(240.49,130.37) G2.BE26
PEG_PRX_C_GTX_N2: length 18.8
  TOP w0.104: v3(239.09,131.67) 239.29,131.67 239.41,131.55 239.41,131.38 239.31,131.28 236.56,131.28 236.37,131.46 229.44,131.46 229.17,131.19 227.39,131.19 226.56,132.03 223.94,132.03 223.29,132.68 222.86,132.68 222.68,132.5 C654.1
  BOTTOM w0.104: v3(239.09,131.67) G2.BG27
PEG_PRX_C_GTX_N3: length 14.2
  TOP w0.104: C671.1 226.46,133.81 226.56,133.71 226.56,133.28 226.67,133.18 227.01,133.18 227.8,132.38 232.01,132.38 232.12,132.49 232.53,132.49 232.64,132.38 233.06,132.38 233.17,132.49 233.58,132.49 233.69,132.38 234.11,132.38 234.21,132.49 234.63,132.49 234.74,132.38 235.15,132.38 235.26,132.49 235.68,132.49 235.79,132.38 236.43,132.38 236.72,132.67 238.15,132.67 v3(238.44,132.39)
  BOTTOM w0.117: v3(238.44,132.39) 238.44,132.52 G2.BH29
PEG_PRX_C_GTX_N4: length 20.5
  TOP w0.104: C673.1 222.68,135.58 222.88,135.37 223.44,135.37 224.11,134.7 226.84,134.7 227.98,133.56 228.7,133.56 229.11,133.15 239.65,133.15 239.89,133.33 240.6,133.33 240.97,132.96 240.97,132.58 v3(241.09,132.47)
  BOTTOM w0.104: G2.BE29 v3(241.09,132.47)
PEG_PRX_C_GTX_N5: length 15.3
  TOP w0.076: v3(239.09,133.77) 239.16,133.77 239.24,133.84 239.24,134.06 239.16,134.14 238.93,134.14 238.6,133.81
  TOP w0.104: 238.6,133.81 238.43,133.64 236.39,133.64 236.04,133.99 229.38,133.99 227.5,135.87 226.46,135.87 C675.1
  BOTTOM w0.117: G2.BG30 v3(239.09,133.77)
