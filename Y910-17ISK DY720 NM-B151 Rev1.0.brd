# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN08: 222.22,195.91 214.85,195.91 211.17,199.6 211.17,205.82 211.34,205.99 268.28,205.99 268.32,205.95 268.32,204.93 267.81,204.42 222.73,204.42 221.46,203.15 221.46,202.14 222.09,201.5 223.49,201.5 224.89,202.9 232.38,202.9 233.78,201.5 235.68,201.5 237.08,202.9 244.7,202.9 245.84,201.76 247.87,201.76 248.89,202.77 257.65,202.77 258.54,201.88 260.83,201.88 261.46,202.52 269.84,202.52 271.24,201.12 271.24,198.07 270.86,197.69 262.35,197.69 261.72,198.33 261.72,199.98 261.59,200.1 260.45,200.1 260.19,199.85 260.19,198.71 259.3,197.82 250.29,197.82 249.52,198.58 249.52,200.1 249.4,200.23 248.38,200.23 248.13,199.98 248.13,198.58 247.37,197.82 237.84,197.82 237.46,198.2 237.46,200.1 237.33,200.23 236.19,200.23 236.06,200.1 236.06,197.82 235.68,197.44 225.9,197.44 225.52,197.82 225.52,198.83 225.01,199.34 223.87,199.34 223.36,198.83 223.36,197.06 ; 1 cut-out
GND on IN08: 289.91,107.65 294.61,107.65 295.24,107.01 295.24,92.28 294.61,91.65 288.26,91.65 286.86,93.04 286.86,106.63 288.01,107.78 289.78,107.78
GND on IN10: 237.46,185.75 214.35,185.75 213.71,185.12 213.71,183.21 212.06,181.56 212.06,176.36 212.82,175.59 224.63,175.59 228.7,179.66 235.3,179.66 235.43,179.53 237.46,179.53 237.84,179.91 237.84,185.37
GND on IN10: 220.57,95.84 236.95,95.84 237.71,95.08 237.71,90.63 236.95,89.87 221.08,89.87 219.81,91.14 219.81,95.08
GND on IN10: 109.57,205.57 109.95,205.95 132.56,205.95 133.95,204.55 133.95,202.64 133.57,202.26 130.91,202.26 130.78,202.39 120.49,202.39 116.81,198.71 114.14,198.71 113.38,197.95 113.38,183.09 115.03,181.44 115.03,171.4 114.4,170.77 109.82,170.77 109.57,171.02 ; 2 cut-outs
GND on IN10: 292.96,107.39 295.37,107.39 296.39,106.38 296.39,92.66 295.88,92.15 288.89,92.15 287.75,93.3 287.75,103.71 288.51,104.47 290.04,104.47
GND on IN10: 285.97,37.54 289.91,37.54 290.29,37.16 290.29,31.58 290.04,31.32 286.1,31.32 285.85,31.58 285.85,37.42
GND on IN10: 4.36,84.92 6.78,84.92 7.03,84.66 9.32,84.66 10.08,83.9 10.08,82.88 9.7,82.5 8.3,82.5 7.28,81.49 6.65,81.49 6.27,81.11 6.27,76.41 5.89,76.03 3.73,76.03 3.22,76.53 3.22,82.88 3.86,83.52 3.86,84.41
GND on IN10: 13.05,84.03 13.05,82.38 13.43,81.99 14.96,81.99 15.46,82.5 15.46,83.9 15.08,84.28 13.3,84.28
GND on IN10: 41.88,84.03 41.88,81.87 42.26,81.49 44.04,81.49 44.55,81.99 44.55,84.15 44.17,84.53 42.39,84.53
VBAT on TOP: 110.9,26.56 110.97,26.5 110.97,23.32 110.21,22.56 108.05,22.56 107.92,22.43 106.01,22.43 105.51,21.92 102.33,21.92 100.3,23.96 100.3,26.75 100.55,27 110.71,27 110.9,26.81
VBAT on BOTTOM: 100.43,28.53 109.32,28.53 110.08,27.77 110.08,24.34 109.44,23.7 94.51,23.7 93.11,22.3 83.41,22.3 82.77,22.94 82.77,27.77 82.8,27.79 82.8,28.93 83.28,29.42 99.54,29.42
VBAT on IN03: 99.92,27.38 99.92,23.32 110.46,23.32 110.46,27.38
VCC0V9_CIO on TOP: 52.17,87.73 52.17,87.5 51.96,87.29 51.96,87 51.81,86.85 51.43,86.85 51.33,86.74 51.33,86.52 51.73,86.11 52.01,86.11 52.1,86.15 52.12,86.19 52.55,86.19 52.67,86.31 52.67,86.69 52.67,86.95 52.72,87 52.72,87.79 52.65,87.86 52.3,87.86
VCC0V9_CIO on BOTTOM: 51.84,88.14 52.42,88.14 52.72,87.84 52.72,87.1 52.65,87.02 52.65,86.59 52.7,86.54 52.7,86.13 52.5,85.93 51.99,85.93 51.63,86.29 51.63,86.47 51.76,86.59 51.76,88.07
VCC0V9_DP on TOP: 53.53,85.78 53.53,87.72 53.44,87.81 53.44,87.96 53.06,88.34 52.93,88.34 52.8,88.22 52.8,87.61 52.83,87.58 52.83,86.82 52.93,86.72 52.93,86.19 52.8,86.06 52.29,86.06 52.24,86.01 52.24,85.63 52.34,85.53 53.27,85.53
VCC0V9_DP on BOTTOM: 53,87.25 53.26,87.25 53.59,86.92 53.59,85.42 53.46,85.3 53.33,85.3 52.72,85.91 52.72,86.97
VCC0V9_DP on BOTTOM: 50.16,88.8 50.95,88.8 51.07,88.67 51.07,87.81 50.72,87.46 50.16,87.46 50.13,87.43 50.13,87.15 50.54,86.74 50.54,86.11 50.39,85.96 50.06,85.96 49.73,86.29 49.73,87.43 49.68,87.48 49.68,87.84 49.83,87.99 50.01,87.99 50.21,88.19 50.21,88.45 50.11,88.55 50.11,88.75
VCC0V9_DP on IN03: 49.5,85.8 49.5,88.6 49.75,88.85 52.29,88.85 53.44,87.71 53.44,86.31 53.31,86.19 52.93,86.19 52.8,86.31 51.79,86.31 50.9,85.42 49.88,85.42
VCC0V9_LVR_OUT on TOP: 48.77,82.9 48.77,83.74 48.41,83.74 47.97,84.18 47.44,84.18 47.34,84.28 45.94,84.28 45.56,83.9 45.56,83.26 45.69,83.14 47.09,83.14 47.6,82.62 48.49,82.62
VCC0V9_PCIE on TOP: 50.25,83.12 49.89,82.75 49.62,82.75 49.37,82.5 49.37,81.87 49.12,81.61 49.12,79.91 49.17,79.86 50.06,79.86 50.13,79.94 50.13,81.61 50.9,82.38 50.9,85.02 50.85,85.07 50.36,85.07 50.25,84.96
VCC0V9_PCIE on BOTTOM: 50.14,82.95 49.86,82.67 49.86,82.45 49.91,82.4 50.09,82.4 50.67,83.06 51.08,83.06 51.46,82.68 51.59,82.67 51.79,82.88 51.79,83.36 51.79,83.51 51,84.31 51,85.44 50.93,85.52 50.65,85.52 50.53,85.41 50.53,84.63 50.36,84.46 50.36,83.95 50.14,83.73
VCC0V9_SVR on BOTTOM (solid shape): 43.78,97.62 43.78,94.06 40.23,94.06 40.1,94.19 40.1,97.23 40.86,98 43.4,98
VCC0V9_SVR on TOP: 50.82,86.85 50.95,87.02 50.95,87.11 51.25,87.4 51.25,88.01 51.12,88.14 50.87,88.14 50.62,87.89 50.49,87.89 50.36,87.76 50.36,87.48 50.24,87.35 49.85,87.35 49.42,87.79 49.42,87.81 49.28,87.95 49.18,87.95 49.04,87.81 49.04,87.43 49.83,86.64 50.08,86.64 50.29,86.85
VCC0V9_SVR on TOP: 46.71,85.7 46.63,85.7 46.5,85.58 46.15,85.58 46.02,85.45 46.02,85.14 46.1,85.07 46.4,85.07 46.48,84.99 46.48,84.92 46.73,84.66 47.4,84.66 47.7,84.96 48.29,84.96 48.29,84.92 48.76,84.92 48.84,84.99 48.84,85.88 48.69,86.03 48.49,86.03 48.19,86.33 46.9,86.33 46.76,86.19 46.76,85.75
VCC0V9_SVR on BOTTOM: 48.13,86.82 48.33,86.82 48.77,86.39 48.77,84.91 48.48,84.63 48.14,84.63 47.47,85.29 47.47,86.16
VCC0V9_SVR on IN08: 40.58,84.53 39.01,86.11 39.01,97.54 39.47,98 44.04,98 44.55,97.49 50.64,97.49 50.9,97.23 50.9,94.19 51.53,93.55 51.53,88.75 52.29,87.99 52.29,85.4 51.56,84.66 47.21,84.66 47.09,84.53 ; 1 cut-out
VCC3V3_S0 on TOP: 54.2,85.3 56.1,85.3 56.23,85.17 56.23,84.41 56.48,84.15 59.41,84.15 59.53,84.03 59.53,82.88 59.41,82.76 56.36,82.76 55.09,84.03 55.09,84.41 54.96,84.53 54.2,84.53 54.07,84.66 54.07,85.17
VCC3V3_S0 on IN03: 51.91,85.93 53.18,85.93 53.56,86.31 54.58,86.31 54.71,86.19 54.71,84.92 54.45,84.66 51.91,84.66 51.66,84.92 51.66,85.68
VCC3V3_S0_SYS on TOP (solid shape): 61.82,83.26 61.82,81.61 61.69,81.49 61.06,81.49 60.42,82.12 60.42,83.77 60.55,83.9 61.18,83.9
VCC3V3_S0_SYS on BOTTOM: 45.56,73.1 45.31,72.85 42.9,72.85 42.77,72.98 42.77,75.14 43.02,75.39 44.29,75.39 44.8,74.88 45.31,74.88 45.56,74.63
VCC3V3_S0_SYS on BOTTOM: 45.99,90.72 45.99,90.56 46.2,90.35 46.33,90.35 46.41,90.26 46.41,90.17 46.24,90 44.17,90 43.78,89.61 43.78,89.36 43.66,89.23 42.51,89.23 42.26,88.98 41.12,88.98 40.86,88.73 39.47,88.73 39.34,88.85 39.34,90.38 39.85,90.88 45.69,90.88 45.69,90.89 45.82,90.89
VCC3V3_S0_SYS on IN05: 48.36,87.84 49.63,87.84 50.52,86.95 51.28,86.95 51.91,86.31 54.58,86.31 56.48,84.41 57.88,84.41 59.53,82.76 60.93,82.76 61.69,81.99 61.69,81.74 60.93,80.98 52.8,80.98 51.91,81.87 51.91,83.77 51.53,84.15 51.15,84.15 50.9,84.41 50.9,84.66 49.75,85.8 49.25,85.8 48.23,86.82 48.23,87.71
VCC3V3_S0_SYS on VCC07: 40.1,94.31 45.82,94.31 46.2,93.93 46.2,73.1 45.82,72.72 39.72,72.72 38.58,73.87 38.58,88.73 36.93,90.38 36.93,91.14
VCC3V3_S0_SYS on IN10: 52.29,89.67 53.87,88.09 54.66,88.09 54.88,87.86 54.88,87.63 56.15,86.36 56.15,84.18 55.42,83.44 53.77,83.44 53.61,83.29 53.61,83.09 53.39,82.86 53.11,82.86 52.57,83.39 52.19,83.39 51.53,82.73 46.58,82.73 45.82,83.49 45.82,87.84 45.44,88.22 41.37,88.22 40.86,88.73 40.86,90.76 41.37,91.27 51.91,91.27 52.29,90.88
VCC3V3_SX_SYS_AR on IN05: 47.47,89.49 50.52,89.49 50.64,89.61 50.64,90.88 50.9,91.14 52.67,91.14 52.8,91.01 53.69,91.01 54.07,90.63 54.07,89.11 55.09,88.09 55.09,87.46 54.83,87.2 52.04,87.2 51.15,88.09 47.47,88.09 47.34,88.22 47.34,89.36
VCC5V0_SYS on TOP: 42.13,80.22 42.13,75.14 42.77,74.5 42.77,73.99 39.97,73.99 39.97,74.02 38.6,75.39 38.6,76.89 37.92,77.58 35.2,77.58 34.79,77.98 34.79,79.89 35.35,80.45 41.9,80.45
VCC5V0_SYS on BOTTOM: 34.64,77.3 36.55,77.3 37.69,78.44 38.98,78.44 39.44,77.98 41.93,77.98 42.26,78.31 42.26,80.06 41.96,80.37 41.14,80.37 41.12,80.34 35.4,80.34 34.96,79.9 34.96,78.63 34.51,78.18 34.51,77.42
VCC20V0_SYS on BOTTOM: 35.66,75.26 35.66,75.52 35.78,75.64 35.86,75.64 36.06,75.85 36.06,75.92 36.16,76.03 38.83,76.03 38.96,75.9 38.96,75.01 38.7,74.76 36.16,74.76
VCCIO_GND on TOP: 138.15,154.92 135.4,157.66 135.4,158.68 135.27,158.8 132.48,158.8 132.11,158.44 132.11,155.87 132.23,155.76 134.39,155.76 134.64,155.5 134.64,152.45 134,151.82 134,151.44 134.13,151.31 134.51,151.31 135.3,152.1 138.02,152.1 138.15,152.23
VCCIO_SW on BOTTOM: 132,151.57 132,150.04 132.63,149.41 132.63,147.37 132.38,147.12 128.67,147.12 128.34,146.79 127.78,146.79 127.58,146.99 127.58,148.14 127.83,148.39 128.77,148.39 128.95,148.57 128.95,151.18 129.46,151.69 131.87,151.69
VCCIO_VIN on TOP: 129.76,157.31 126.72,157.31 126.46,157.05 126.46,154.77 126.72,154.51 129.89,154.51 130.14,154.77 130.14,156.92
VCCIO_VIN on BOTTOM: 131.24,156.26 131.24,155.88 131.62,155.5 131.62,154.49 131.49,154.36 129.43,154.36 128.9,154.89 127.86,154.89 127.6,154.64 125.7,154.64 125.57,154.77 125.57,156.54 126.08,157.05 130.45,157.05
VCCIOP on BOTTOM: 134.23,143.74 134.26,143.72 138.78,143.72 139.29,143.21 139.29,140.29 139.11,140.11 131.62,140.11 130.65,139.14 128.87,139.14 128.49,139.53 128.49,143.72 127.99,144.22 127.99,144.86 128.04,144.91 132.81,144.91 133.98,143.74
VDD18_GPU on TOP: 245.21,121.36 246.35,121.36 246.6,121.11 246.6,120.73 247.59,120.73 247.67,120.81 247.67,121.26 247.77,121.36 248.25,121.36 248.28,121.34 250.44,121.34 250.54,121.24 250.54,119.84 250.16,119.46 245.97,119.46 245.46,118.95 245.08,118.95 244.44,119.59 244.44,120.6 244.57,120.73 244.95,120.73 245.08,120.86 245.08,121.24
VDD18_GPU on BOTTOM: 250.39,119.67 250.39,120.59 250.24,120.74 244.61,120.74 244.44,120.57 244.44,119.79 244.89,119.34 245.86,119.34 246.16,119.64 246.64,119.64 246.99,119.29 247.21,119.29 247.34,119.42 247.61,119.42 247.74,119.29 247.91,119.29 248.34,119.72 248.66,119.72 249.11,119.27 249.99,119.27
VDD18_GPU on BOTTOM: 218.41,118.57 217.9,119.08 217.9,121.36 218.16,121.62 219.93,121.62 220.31,121.24 222.85,121.24 223.11,120.98 223.11,118.7 222.98,118.57
VDD18_GPU on IN03: 229.97,114.89 226.03,114.89 225.78,114.63 221.46,114.63 220.95,115.14 220.95,120.35 221.2,120.6 221.84,120.6 222.47,121.24 223.24,121.24 223.3,121.17 224.19,121.17 226.47,118.89 229.2,118.89 230.16,117.94 234.16,117.94 235.81,116.28 242.03,116.28 244.19,118.44 244.19,120.86 244.44,121.11 250.29,121.11 250.67,120.73 250.67,119.46 250.03,118.82 249.02,118.82 248.51,118.32 248.51,116.79 248.13,116.41 248.13,108.92 247.49,108.28 239.75,108.28 239.36,108.66 233.27,108.66 231.87,110.06 231.87,112.98
(no net) on TOP: 213.49,164.51 213.21,164.23 213.21,164.16 212.83,163.78 210.66,163.78 210.28,164.16 210.28,167.08 210.54,167.34 213.08,167.34 213.49,166.92
(no net) on TOP: 214.36,169.76 214.1,170.02 210.67,170.02 210.41,169.75 210.41,168.35 210.66,168.1 213.96,168.1 214.36,168.49
(no net) on TOP: 281.27,64.85 281.27,65.61 281.4,65.74 283.18,65.74 283.31,65.61 283.31,63.83 283.18,63.71 281.4,63.71 281.27,63.83 281.27,64.6 280,64.6 280,64.85
(no net) on TOP: 218.54,153.5 218.54,150.96 218.92,150.57 220.44,150.57 220.57,150.7 220.57,152.61 221.33,153.37 221.33,160.48 220.82,160.99 219.17,160.99 218.92,160.73 218.92,160.6 218.68,160.35 218.16,160.35 218.16,158.45 218.28,158.32 218.92,158.32 219.3,157.94 219.3,154.26
(no net) on BOTTOM: 213.34,167.86 213.72,167.48 215.5,167.48 215.63,167.61 215.63,169.61 215.23,170.01 210.79,170.01 210.54,169.75 210.54,168.1 210.78,167.86
1.05G_LX on BOTTOM (solid shape): 215.53,166.28 215.53,165.01 215.65,164.89 215.91,164.89 216.42,164.38 216.42,161.97 216.29,161.84 213.24,161.84 212.69,162.39 210.92,162.39 210.79,162.51 210.79,163.4 210.92,163.53 213.24,163.53 213.75,164.04 213.75,164.8 214.26,165.31 214.26,166.28 214.38,166.41 215.4,166.41
203_VCC on BOTTOM: 120.19,189.79 120.01,189.97 120.01,192.15 120.06,192.21 122.27,192.21 122.37,192.1 122.37,191.43 122.31,191.38 121.94,191.38 121.81,191.25 121.81,190.55 121.71,190.45 121.1,190.45 121,190.35 121,189.92 120.87,189.79
+CORE_PLLVDD on TOP: 225.01,125.05 225.27,124.79 227.3,124.79 229.97,127.46 232.76,127.46 233.01,127.71 234.16,127.71 234.54,127.33 234.54,124.67 234.41,124.54 233.27,124.54 233.14,124.41 233.14,123.02 233.4,122.76 235.3,122.76 235.68,123.14 236.19,123.14 236.32,123.02 236.32,121.36 235.81,120.86 230.09,120.86 227.81,123.14 223.62,123.14 223.49,123.27 223.49,124.92 223.62,125.05
+FB_PLL_AVDD on TOP: 226.41,126.06 227.05,126.06 228.32,127.33 228.32,127.97 228.57,128.22 229.2,128.22 229.33,128.1 229.33,126.83 227.68,125.17 226.41,125.17 226.28,125.3 226.28,125.94
+FB_PLL_AVDD on IN03: 245.08,121.75 262.48,121.75 263.37,122.63 263.37,124.16 263.62,124.41 264.38,124.41 264.51,124.29 264.51,124.03 264.26,123.78 264.26,122.38 262.61,120.73 260.19,120.73 259.68,120.22 259.43,120.22 258.92,120.73 244.19,120.73 243.94,120.98 243.94,121.39 243.07,122.25 236.82,122.25 236.32,122.76 236.32,123.02 231.87,127.46 228.57,127.46 228.44,127.59 228.44,128.22 228.82,128.6 232.51,128.6 238.09,123.02 243.81,123.02
+FB_PLL_AVDD on IN10: 248.64,141.56 248.64,140.92 249.4,140.16 262.1,140.16 262.61,139.65 262.61,122.38 262.22,122 259.56,122 259.05,121.49 259.05,120.48 259.3,120.22 259.81,120.22 260.45,120.86 262.99,120.86 263.62,121.49 263.62,123.27 264.38,124.03 264.38,124.67 263.88,125.17 263.88,126.7 264.13,126.95 264.13,128.1 263.88,128.35 263.88,138.38 264,138.51 264.38,138.51 264.51,138.64 264.51,139.02 263.88,139.65 263.88,140.67 263.37,141.18 249.78,141.18 249.14,141.81 248.89,141.81
+FB_PLLVDD on TOP: 225.78,127.21 225.78,125.3 225.65,125.17 224.89,125.17 224.63,125.43 223.62,125.43 223.49,125.56 223.49,127.21 223.62,127.33 225.65,127.33
+IFP_IOVDD on TOP: 242.16,128.48 242.16,127.46 242.41,127.21 243.05,127.21 243.05,126.57 242.92,126.44 242.29,126.44 242.16,126.32 242.16,125.17 242.03,125.05 242.03,124.29 242.29,124.03 242.29,123.14 242.41,123.02 242.79,123.02 242.92,122.89 242.92,122.51 243.05,122.38 243.81,122.38 243.94,122.51 243.94,128.6 242.29,128.6
+IFP_IOVDD on BOTTOM: 241.65,128.86 243.17,128.86 243.43,128.6 243.43,122.15 243.22,121.95 241.42,121.95 241.14,122.23 241.14,128.35
+IFP_IOVDD on BOTTOM: 217.01,128.6 221.2,128.6 221.33,128.48 221.33,126.57 217.01,126.57 216.89,126.7 216.89,128.48
+IFP_IOVDD on IN05: 241.52,128.98 243.17,128.98 243.56,128.6 243.56,121.36 242.92,120.73 241.52,120.73 241.27,120.98 241.27,121.49 241.65,121.87 241.65,125.81 241.52,125.94
+IFP_IOVDD on IN08: 244.44,123.14 243.43,122.13 236.57,122.13 236.19,121.75 223.49,121.75 222.47,122.76 217.77,122.76 216.63,123.9 216.63,128.48 216.89,128.73 221.58,128.73 223.55,130.7 237.9,130.7 238.22,130.38 243.68,130.38 244.44,129.62
+NVVDDS on TOP: 261.21,140.44 261.84,140.44 261.89,140.39 261.89,139.81 261.77,139.68 261.77,138.59 261.44,138.26 261.44,137.77 261.72,137.49 261.72,137.16 261.61,137.06 261.23,137.06 261.13,137.16 261.13,137.54 260.98,137.7 260.98,138.26 261.21,138.48
+NVVDDS on TOP: 255.77,124.97 256,124.97 256.36,124.62 256.36,123.42 256.15,123.22 256.15,122.53 256,122.38 255.75,122.38 255.65,122.48 255.65,123.37 255.98,123.7 255.98,124.29 255.72,124.54 255.72,124.92
+NVVDDS on TOP: 253.49,139.65 253.79,139.65 253.87,139.58 253.87,138.61 253.77,138.51 253.77,137.72 253.89,137.6 253.89,137.21 253.82,137.14 253.46,137.14 253.36,137.24 253.36,139.53
+NVVDDS on TOP: 251.56,131.27 251.94,131.27 252.45,130.76 252.45,130.03 252.39,129.98 252.06,129.98 251.84,129.75 251.84,128.88 251.68,128.73 251.43,128.73 251.3,128.86 251.3,131.02
+NVVDDS on TOP: 251.48,124.95 251.84,124.95 251.94,124.84 251.94,124.54 252.11,124.36 252.11,123.52 251.99,123.4 251.99,121.8 251.89,121.69 251.56,121.69 251.38,121.87 251.38,123.65 251.48,123.75 251.48,124.51 251.35,124.64 251.35,124.82
+NVVDDS on TOP: 258.41,131.27 258.85,131.27 258.95,131.17 258.95,129.54 258.77,129.37 258.29,129.37 257.91,129.75 257.91,130.76
+NVVDDS on TOP: 211.93,156.04 218.54,156.04 218.79,155.78 218.79,154.13 218.16,153.5 215.62,153.5 214.73,154.38 212.19,154.38 211.93,154.64
+NVVDDS on TOP: 248.53,124.95 248.89,124.95 249.02,124.82 249.02,122.46 248.91,122.36 248.58,122.36 248.41,122.53 248.41,124.82
+NVVDDS on TOP: 261.36,124.95 261.67,124.95 261.84,124.77 261.84,121.82 261.69,121.67 261.41,121.67 261.34,121.75 261.34,124.92
+NVVDDS on TOP: 258.52,124.97 258.82,124.97 258.92,124.87 258.92,124.49 258.72,124.29 258.72,123.8 258.9,123.63 258.9,122.48 258.82,122.41 258.54,122.41 258.31,122.63 258.31,124.77
+NVVDDS on TOP: 219.43,108.16 225.52,108.16 226.54,107.14 230.09,107.14 231.36,108.41 237.97,108.41 238.22,108.16 238.22,107.52 238.73,107.01 238.73,106.63 241.14,104.22 241.14,100.41 240.51,99.77 219.3,99.77 218.92,100.16 218.92,104.35 219.43,104.85
+NVVDDS on TOP: 245.79,124.97 246.12,124.97 246.3,124.79 246.3,124.59 246.43,124.46 246.43,123.42 246.3,123.3 246.3,122.43 246.22,122.36 245.84,122.36 245.74,122.46 245.74,123.55 246.04,123.85 246.04,124.29 245.71,124.62 245.71,124.9
+NVVDDS on TOP: 258.52,139.68 258.8,139.68 258.92,139.55 258.92,138.61 258.59,138.28 258.59,137.8 258.9,137.49 258.9,137.19 258.74,137.04 258.44,137.04 257.98,137.49 257.98,138.79 258.39,139.2 258.39,139.55
+NVVDDS on TOP: 255.65,138.79 255.65,138.36 255.72,138.28 255.72,137.6 255.65,137.52 255.65,137.14 255.7,137.09 256.08,137.09 256.18,137.19 256.18,140.39 256.15,140.41 255.7,140.41 255.62,140.34 255.62,138.81
+NVVDDS on BOTTOM: 258.67,132.92 259.05,132.92 259.18,132.79 259.18,132.67 259.05,132.54 259.05,132.29 259.18,132.16 259.18,131.27 259.05,131.14 259.05,130.76 259.18,130.64 259.18,129.87 259.05,129.75 259.05,129.49 259.18,129.37 259.18,129.11 259.05,128.98 258.67,128.98 258.54,129.11 258.54,132.79
+NVVDDS on BOTTOM: 245.33,140.41 245.59,140.41 246.1,139.91 246.1,136.99 245.97,136.86 245.59,136.86 245.59,139.65 245.21,140.03 245.21,140.29
+NVVDDS on BOTTOM: 261.46,132.92 261.84,132.92 261.97,132.79 261.97,132.67 261.84,132.54 261.84,132.29 261.97,132.16 261.97,131.27 261.84,131.14 261.84,130.89 261.97,130.76 261.97,129.87 261.84,129.75 261.84,129.49 261.97,129.37 261.97,129.24 261.84,129.11 261.59,129.11 261.34,129.37 261.34,132.79
+NVVDDS on BOTTOM: 251.3,133.3 251.68,133.3 251.81,133.18 251.81,128.86 251.68,128.73 251.3,128.73 251.18,128.86 251.18,133.18
+NVVDDS on BOTTOM: 258.67,125.17 259.05,125.17 259.18,125.05 259.18,122.25 259.05,122.13 258.8,122.13 258.41,122.51 258.41,123.4 258.54,123.52 258.54,125.05
+NVVDDS on BOTTOM: 251.3,139.91 251.68,139.91 251.81,139.78 251.81,136.86 251.68,136.73 251.3,136.73 251.18,136.86 251.18,139.78
+NVVDDS on BOTTOM: 245.59,125.3 245.84,125.3 246.2,124.95 246.2,122.23 246.07,122.1 245.49,122.1 245.33,122.25 245.33,122.63 245.51,122.81 245.51,125.23
+NVVDDS on BOTTOM: 248.38,139.91 248.89,139.91 249.02,139.78 249.02,136.99 248.89,136.86 248.51,136.86 248.38,136.99
+NVVDDS on BOTTOM: 261.46,125.17 261.84,125.17 261.97,125.05 261.97,124.92 261.84,124.79 261.84,124.54 261.97,124.41 261.97,123.65 261.84,123.52 261.84,123.14 261.97,123.02 261.97,122.89 261.84,122.76 261.84,122.51 261.97,122.38 261.97,122.25 261.84,122.13 261.59,122.13 261.34,122.38 261.34,125.05
+NVVDDS on BOTTOM: 253.84,125.17 254.22,125.17 254.35,125.05 254.35,122.13 254.22,122 253.97,122 253.59,122.38 253.59,124.92
+NVVDDS on BOTTOM: 248.38,125.17 248.76,125.17 249.02,124.92 249.02,124.54 248.89,124.41 248.89,122.25 248.76,122.13 248.51,122.13 248.38,122.25
+NVVDDS on BOTTOM: 248.38,132.92 248.76,132.92 249.02,132.67 249.02,132.29 248.89,132.16 248.89,129.31 248.69,129.11 248.43,129.11 248.38,129.16
+NVVDDS on BOTTOM: 255.87,139.91 256.26,139.91 256.38,139.78 256.38,136.99 256.26,136.86 255.87,136.86 255.75,136.99 255.75,139.78
+NVVDDS on BOTTOM: 239.81,102.38 240.13,102.7 240.13,105.11 240.51,105.49 240.51,107.65 239.62,108.54 232,108.54 231.24,107.78 224.89,107.78 223.74,108.92 218.92,108.92 218.28,108.28 217.65,108.28 217.52,108.16 217.52,104.35 220.95,100.92 238.98,100.92 239.81,101.74
+NVVDDS on BOTTOM: 258.67,139.91 259.05,139.91 259.18,139.78 259.18,139.65 259.05,139.53 259.05,136.99 258.92,136.86 258.67,136.86 258.54,136.99 258.54,139.78
+NVVDDS on BOTTOM: 245.71,132.92 245.84,132.92 246.22,132.54 246.22,132.29 246.1,132.16 246.1,129.49 245.71,129.11 245.61,129.11 245.54,129.19 245.54,129.37 245.59,129.42 245.59,132.79
+NVVDDS on BOTTOM: 255.75,132.92 256.26,132.92 256.38,132.79 256.38,129.24 256.26,129.11 255.87,129.11 255.62,129.37 255.62,132.79
+NVVDDS on BOTTOM: 261.46,139.91 261.84,139.91 261.97,139.78 261.97,136.86 261.84,136.73 261.46,136.73 261.34,136.86 261.34,139.78
+NVVDDS on BOTTOM: 251.18,125.17 251.56,125.17 251.81,124.92 251.81,122.38 251.56,122.13 251.3,122.13 251.05,122.38 251.05,125.05
+NVVDDS on BOTTOM: 253.33,139.91 253.72,139.91 253.84,139.78 253.84,136.99 253.72,136.86 253.33,136.86 253.21,136.99 253.21,139.78
+NVVDDS on BOTTOM: 255.87,125.17 256.26,125.17 256.38,125.05 256.38,122.25 256.26,122.13 255.87,122.13 255.62,122.38 255.62,124.92
+NVVDDS on IN03: 220.19,107.52 238.22,107.52 238.6,107.14 238.6,102.57 238.22,102.19 220.19,102.19 219.81,102.57 219.81,107.14
+NVVDDS on IN08: 219.93,111.08 219.93,101.3 221.58,99.65 274.29,99.65 276.07,101.43 276.07,125.43 270.1,131.4 245.59,131.4 244.83,130.64 244.83,123.02 243.43,121.62 243.43,120.98 242.41,119.97 242.41,118.82 241.65,118.06 226.92,118.06 ; 1 cut-out
+NVVDDS on IN10: 225.39,152.1 228.57,155.27 235.55,155.27 245.35,145.48 245.35,144.14 247.62,141.86 247.62,141.18 247.75,141.05 248.76,141.05 249.4,140.41 263.11,140.41 263.24,140.29 263.24,122.63 262.1,121.49 250.92,121.49 250.16,120.73 250.16,117.81 249.52,117.17 242.03,117.17 242.03,104.35 239.36,101.68 220.95,101.68 219.93,102.7 219.93,112.22 220.57,112.86 221.33,112.86 221.58,113.11 221.58,118.32 220.57,119.33 220.57,140.41 214.85,146.13 214.85,154.26 215.23,154.64 218.41,154.64 219.68,153.37 222.47,153.37 223.74,152.1 ; 6 cut-outs
+PEX_VDD on BOTTOM (solid shape): 215.62,151.72 215.36,151.46 213.2,151.46 212.95,151.72 212.95,154.13 213.2,154.38 215.62,154.38
+PEX_VDD on TOP: 213.2,151.34 213.46,151.08 217.52,151.08 217.9,151.46 217.9,152.99 217.77,153.11 215.74,153.11 214.85,154 213.33,154 213.2,153.88
+PEX_VDD on TOP: 221.46,151.97 223.24,151.97 223.49,151.72 223.49,150.57 223.36,150.45 221.58,150.45 221.33,150.7 221.33,151.84
+PEX_VDD on TOP: 243.43,138.26 243.81,137.87 243.81,135.97 243.43,135.59 242.92,135.59 242.67,135.33 242.67,135.08 242.54,134.95 242.29,134.95 242.16,135.08 242.16,135.46 242.03,135.59 241.78,135.59 241.52,135.84 241.52,138 241.78,138.26
+PEX_VDD on BOTTOM: 241.78,138.13 243.3,138.13 243.43,138 243.43,135.72 243.05,135.33 241.4,135.33 241.14,135.59 241.14,137.49
+PEX_VDD on BOTTOM: 221.46,151.72 223.11,151.72 223.24,151.59 223.24,150.83 223.11,150.7 221.58,150.7 221.46,150.83
+PEX_VDD on BOTTOM: 217.14,131.02 220.44,131.02 220.57,130.89 220.57,128.98 220.44,128.86 217.14,128.86 216.89,129.11 216.89,130.76
+PEX_VDD on IN08: 222.73,131.14 220.82,129.24 216.38,129.24 215.87,129.75 215.87,133.43 213.71,135.59 213.71,151.21 213.33,151.59 213.33,154.89 214.09,155.65 219.81,155.65 220.19,155.27 224.25,155.27 225.78,153.75 225.78,144.61 228.7,141.68 242.29,141.68 244.44,139.53 244.44,131.52 243.68,130.76 238.22,130.76 237.84,131.14 ; 2 cut-outs
+V_BL_LED on BOTTOM: 189.43,199.95 189.43,198.58 189.17,198.33 188.69,198.33 188.56,198.2 188.56,197.18 188.44,197.06 187.04,197.06 186.79,196.8 186.66,196.8 186.41,196.55 185.52,196.55 185.39,196.42 184.88,196.42 184.75,196.29 184.75,194.01 184.89,193.87 188.93,193.87 189.05,193.75 191.23,193.75 191.64,194.16 191.64,198.12 191.21,198.56 191.21,199.95 191.15,200 189.48,200
+VGA_CORE on TOP: 247.24,129.82 248.18,129.82 249.02,128.98 249.02,128.71 248.71,128.4 248.71,127.94 248.94,127.71 248.94,127.36 248.66,127.08 248.66,126.72 249.09,126.29 249.09,126.06 248.69,125.66 248.69,125.15 248.56,125.02 247.8,125.02 247.59,124.82 247.59,124.59 247.26,124.26 247.26,123.73 247.59,123.4 247.59,122.61 247.9,122.3 248.03,122.3 248.03,121.72 247.97,121.67 247.7,121.67 247.64,121.72 247.64,122.13 247.49,122.28 247.29,122.28 246.96,122.61 246.96,123.55 246.86,123.65 246.86,124.39 247.49,125.02 247.49,125.63 247.16,125.96 247.16,126.22 247.57,126.62 247.57,127.08 247.42,127.23 247.31,127.23 247.11,127.44 247.11,127.56 247.59,128.04 247.59,128.35 247.06,128.88 247.06,129.65
+VGA_CORE on TOP: 254.3,124.97 254.63,124.97 254.76,124.84 254.76,122.51 254.43,122.18 254.43,121.8 254.35,121.72 254.07,121.72 254.02,121.77 254.02,122.36 254.15,122.48 254.15,122.86 254.12,122.89 254.12,124.79
+VGA_CORE on TOP: outline of 122 points within 252.7,121.69 261.72,139.65
+VGA_CORE on TOP: 251.38,128.53 251.73,128.53 251.81,128.45 251.81,125.25 251.71,125.15 251.38,125.15 251.23,125.3 251.23,128.38
+VGA_CORE on TOP: 257.17,140.36 257.53,140.36 257.65,140.24 257.65,137.49 258.29,136.86 258.29,136.3 258.41,136.17 258.8,136.17 258.92,136.05 258.92,135.84 258.72,135.64 258.54,135.64 258.29,135.39 258.29,134.93 258.39,134.83 258.41,134.83 258.49,134.75 258.77,134.75 258.87,134.65 258.87,134.34 258.77,134.24 258.44,134.24 258.31,134.12 258.31,133.58 258.49,133.4 258.72,133.4 258.95,133.18 258.95,133.02 258.85,132.92 258.62,132.92 258.08,133.46 257.73,133.46 257.65,133.38 257.65,132.41 257.45,132.21 257.12,132.21 257.04,132.29 257.04,140.24
+VGA_CORE on TOP: 245.89,129.21 246.2,129.21 246.3,129.11 246.3,128.73 246.48,128.55 246.48,127.87 246.27,127.66 246.27,127.36 246.45,127.18 246.45,126.5 246.35,126.39 246.35,125.94 246.43,125.86 246.43,125.1 246.4,125.07 246.12,125.07 246.02,125.17 246.02,125.68 245.74,125.96 245.74,126.24 246.02,126.52 246.02,127.11 245.74,127.38 245.74,127.66 246.04,127.97 246.04,128.4 245.69,128.76 245.69,129.01
+VGA_CORE on TOP: 252.85,139.65 253.11,139.65 253.18,139.58 253.18,137.21 253.08,137.11 252.85,137.11 252.67,137.29 252.67,139.47
+VGA_CORE on TOP: outline of 170 points within 213.2,122.38 273.91,188.55 ; 1 cut-out
+VGA_CORE on TOP: 255.75,136.86 256.1,136.86 256.15,136.81 256.15,133.02 256,132.87 255.65,132.87 255.57,132.95 255.57,133.38 255.7,133.51 255.7,134.19 255.62,134.27 255.62,134.75 255.67,134.8 255.67,135.56 255.62,135.61 255.62,136.17 255.7,136.25 255.7,136.81
+VGA_CORE on TOP: 261.21,133.23 261.21,133.05 261.46,132.79 261.72,132.79 261.84,132.92 261.84,133.15 261.49,133.51 261.41,133.51 261.36,133.56 261.36,134.04 261.72,134.39 261.72,134.65 261.36,135 261.36,135.49 261.39,135.51 261.49,135.51 261.72,135.74 261.72,136.07 261.39,136.4 261.39,136.83 261.36,136.86 260.98,136.86 260.98,136.33 261.16,136.15 261.16,135.82 260.9,135.56 260.9,134.9 261.08,134.73 261.08,134.29 260.9,134.12 260.9,133.53
+VGA_CORE on BOTTOM: outline of 159 points within 212.95,120.86 273.15,189.18 ; 1 cut-out
+VGA_CORE on IN03: outline of 285 points within 213.84,122.08 273.4,188.04
+VGA_CORE on IN05: 273.27,180.04 271.62,178.39 251.43,178.39 250.54,177.5 245.08,177.5 244.19,178.39 241.02,178.39 240.51,177.88 234.92,177.88 234.41,178.39 233.01,178.39 231.62,176.99 231.62,156.42 231.63,156.41 231.63,155.78 239.88,147.53 242.41,147.53 244.83,145.11 244.83,144.35 247.87,141.3 259.81,141.3 261.21,139.91 261.84,139.91 262.99,138.76 262.99,123.27 261.84,122.13 245.59,122.13 245.21,122.51 245.21,132.41 243.94,133.68 234.03,133.68 232.38,135.33 226.16,135.33 222.6,138.89 222.6,168.61 213.33,177.88 213.33,187.02 214.85,188.55 272.13,188.55 273.27,187.4 ; 2 cut-outs
+VGA_CORE on VCC06: 246.71,120.73 245.46,121.98 245.46,132.65 244.17,133.94 236.29,133.94 232.36,137.87 223.72,137.87 221.46,140.14 221.46,169.6 213.71,177.35 213.71,189.69 272.15,189.69 273.4,188.44 273.4,180.14 272.15,178.9 233.16,178.9 232,177.73 232,155.3 240.15,147.15 242.31,147.15 244.44,145.01 244.44,144.37 246.75,142.07 263.39,142.07 264.76,140.69 264.76,121.98 263.52,120.73 ; 2 cut-outs
+VGA_CORE on VCC07: 232.11,113.86 231.47,114.51 205.81,114.51 205.46,114.87 205.46,140.94 206.47,141.96 206.47,164.19 208.12,165.84 208.12,191.62 209.76,193.26 209.77,193.25 222.35,193.25 222.73,192.87 222.73,188.93 223.49,188.17 229.59,188.17 230.6,187.15 245.21,187.15 245.71,186.64 251.05,186.64 251.68,187.28 257.4,187.28 258.8,185.88 277.46,185.88 279.5,183.85 279.5,179.28 282.16,176.61 284.07,176.61 284.32,176.36 284.32,152.73 277.46,145.88 277.46,114.74 273.8,111.08 271.24,111.08 268.19,108.03 234.67,108.03 232.11,110.58 ; 6 cut-outs
+VGA_CORE on IN08: 242.41,141.94 244.83,139.53 244.83,132.03 244.95,131.91 282.42,131.91 284.2,133.68 284.2,174.7 279.5,179.4 279.5,183.98 277.46,186.01 213.96,186.01 213.46,185.5 213.46,178.01 213.52,177.94 213.52,172.86 215.62,170.77 218.41,170.77 222.47,166.7 222.47,158.32 227.3,153.5 227.3,144.73 230.09,141.94 ; 2 cut-outs
ADIN_1 on TOP: 26.51,36.91 25.37,35.77 22.96,35.77 22.7,35.51 22.7,28.15 23.08,27.77 29.05,27.77 30.32,26.5 34.39,26.5 34.64,26.75 34.64,39.07 34.51,39.2 33.75,39.2 32.23,37.67 27.66,37.67 26.89,36.91
ALW_B+ on TOP: 36.55,19.76 36.42,19.89 36.42,21.92 36.04,22.3 36.04,24.97 36.29,25.23 40.61,25.23 43.21,27.83 46.64,27.83 47.72,28.91 48.61,28.91 48.74,29.04 54.83,29.04 54.96,28.91 54.96,25.99 54.33,25.35 51.79,25.35 51.53,25.61 51.53,26.88 51.4,27 48.36,27 46.58,25.23 45.44,25.23 45.18,24.97 45.18,21.29 45.05,21.16 43.53,21.16 43.4,21.03 43.4,20.15 43.28,20.02 38.83,20.02 38.58,19.76
ALW_B+ on BOTTOM: 44.8,24.84 44.42,25.23 44.42,28.27 45.05,28.91 51.91,28.91 52.42,28.4 52.42,25.61 52.04,25.23 48.48,25.23 48.1,24.84
AMP_SPK_R+ on TOP: 265.91,37.29 266.36,36.83 266.57,36.83 266.57,36.3 266.49,36.22 265.63,36.22 264.93,36.92 264.93,38.83 265.02,38.92 265.73,38.92 265.91,38.74
AMP_SPK_R- on TOP: 267.43,37.8 267.43,37.11 267.51,37.04 267.51,36.78 267.43,36.71 266.9,36.71 266.11,37.49 266.11,38.74 266.29,38.92 267.2,38.92 267.38,39.09 267.71,39.09 267.89,38.92 267.89,38.26
APDIN on TOP: 32.48,14.81 31.72,14.05 24.61,14.05 24.35,14.3 24.35,20.02 24.61,20.27 31.34,20.27 32.48,19.13
APDIN on BOTTOM: 24.99,22.94 24.48,22.43 24.48,14.43 24.73,14.18 29.56,14.18 30.32,14.94 32.61,14.94 32.99,15.32 32.99,22.43 32.48,22.94
B+ on TOP: outline of 189 points within 48.86,10.24 180.06,205.95
B+ on TOP: 218.79,110.44 218.41,110.06 218.41,105.36 217.9,104.85 217.9,99.65 218.54,99.01 218.54,95.2 219.43,94.31 219.43,89.87 219.04,89.49 219.04,88.22 219.81,87.46 219.81,84.53 219.55,84.28 217.65,84.28 217.39,84.53 217.39,93.42 215.49,95.33 215.49,101.68 215.11,102.06 215.11,106.25 215.36,106.51 215.36,111.08 215.11,111.33 215.11,112.73 215.36,112.98 218.03,112.98 218.79,112.22
B+ on TOP: 258.29,44.22 258.08,44.02 255.21,44.02 254.99,44.25 254.99,45.55 255,45.56 255,46.17 255.24,46.41 257.04,46.41 258.29,45.16
B+ on BOTTOM: outline of 243 points within 77.69,29.92 267.56,190.71 ; 1 cut-out
B+ on BOTTOM: 180.31,196.17 180.31,194.14 180.18,194.01 178.02,194.01 177.9,194.14 177.9,195.28 178.28,195.66 178.66,195.66 179.17,196.17
B+ on IN03: 148.56,205.95 148.56,201.88 149.07,201.37 168.63,201.37 168.88,201.63 168.88,205.69 168.63,205.95
B+ on IN05: 150.08,205.95 168.75,205.95 168.88,205.82 168.88,200.99 168.75,200.87 150.46,200.87 149.7,201.63 149.7,205.57
B+ on VCC07: 138.02,184.99 138.02,195.1 141.43,195.23 144.21,197.19 144.34,197.32 144.34,197.4 145.07,198.82 145.36,200.39 145.37,200.39 145.37,204.5 145.65,205.2 146.35,205.48 150.35,205.48 150.59,204.8 150.83,205.48 151.62,205.48 151.86,204.8 152.1,205.48 152.89,205.48 153.13,204.8 153.37,205.48 154.16,205.48 154.4,204.8 154.64,205.48 155.43,205.48 155.67,204.8 155.91,205.48 156.7,205.48 156.94,204.8 157.18,205.48 157.97,205.48 158.21,204.8 158.45,205.48 168.71,205.48 169.13,205.06 169.13,198.96 168.63,198.45 164.62,198.45 164.31,198.6 164.01,198.45 161.41,198.45 154.84,191.88 154.39,191.81 154.32,191.36 147.95,184.99
B+ on IN08: 168.72,197.53 162.12,197.53 157.2,192.61 154.02,192.61 153.51,192.1 153.51,183.85 148.69,179.02 148.69,177.37 126.97,155.65 126.72,155.65 126.72,117.68 109.19,100.16 108.3,100.16 104.49,96.35 104.49,94.69 102.71,92.92 99.66,92.92 96.36,89.61 96.36,84.92 95.09,83.65 95.09,80.22 94.08,79.2 94.08,71.71 91.28,68.91 84.25,68.91 83.77,69.39 83.77,73.5 83.73,73.55 83.73,90.82 99.41,106.51 104.49,106.51 109.95,111.97 109.95,114.63 115.54,120.22 115.54,165.94 135.22,185.63 135.22,192.48 136.49,193.75 141.75,193.75 142.19,194.2 143.28,194.2 146.15,197.06 146.15,205.18 146.91,205.95 168.63,205.95 168.88,205.69 168.88,197.69 ; 1 cut-out
B+ on IN10: 168.75,205.95 146.02,205.95 145.26,205.18 145.26,197.31 141.45,193.5 139.8,193.5 137,190.71 137,184.74 137.26,184.48 145.26,184.48 146.02,185.25 146.02,190.33 156.31,200.61 157.96,200.61 158.97,201.63 168.24,201.63 168.88,202.26 168.88,205.82
B+_1.0VG on TOP (solid shape): 214.36,169.76 214.36,168.49 213.96,168.1 210.66,168.1 210.41,168.35 210.41,169.75 210.67,170.02 214.1,170.02
B+_1.0VG on BOTTOM (solid shape): 215.63,169.61 215.63,168.9 215.57,168.84 215.57,167.54 215.5,167.48 213.72,167.48 213.34,167.86 210.78,167.86 210.54,168.1 210.54,169.75 210.79,170.01 215.23,170.01
B+_1.05VP on TOP: 262.1,47.45 262.1,46.18 261.95,46.04 261.62,46.04 261.51,45.93 261.51,45.33 261.44,45.26 261.2,45.26 261.08,45.14 261.08,42.88 260.8,42.6 259.23,42.6 259.05,42.78 259.05,45.29 258.8,45.55 258.29,45.55 258.03,45.8 258.03,47.32 258.29,47.58 261.97,47.58
B+_1.8VP on BOTTOM (solid shape): 118.59,138.25 121.39,138.25 122.21,137.42 122.21,134.31 120.31,134.31 119.55,135.07 118.59,135.07 118.58,135.08 118.34,135.08 118.08,135.33 118.08,138 118.33,138.26 118.58,138.26
B+_1.8VP on TOP: 118.21,137.11 119.86,137.11 120.11,136.86 120.11,135.59 119.98,135.46 118.21,135.46 118.08,135.59 118.08,136.99
B+_2.5VP on TOP: 214.04,115.73 212.34,115.73 212.21,115.85 212.21,117.63 212.52,117.94 213.96,117.94 214.35,118.32 214.35,119.59 214.47,119.71 216.12,119.71 217.14,118.7 217.14,116.28 217.65,115.78 217.65,113.87 217.52,113.74 216,113.74 215.87,113.87 215.87,116.16 215.62,116.41 214.73,116.41
B+_2.5VP on BOTTOM: 215.62,119.84 215.74,119.71 215.74,117.81 215.49,117.55 214.35,117.55 214.22,117.68 214.22,118.06 214.47,118.32 214.47,119.59 214.73,119.84
B+_GPU_ALL on BOTTOM (solid shape): 233.78,83.77 245.46,83.77 247.04,82.2 249.52,82.2 249.52,82.18 253.59,82.18 253.59,82.2 257.07,82.2 257.53,81.74 257.53,79.71 257.14,79.33 249.52,79.33 248.64,80.22 244.7,80.22 244.06,80.85 236.19,80.85 235.81,80.47 228.95,80.47 228.57,80.85 228.57,82.63 228.95,83.01 229.97,83.01 230.09,83.14 230.09,84.15 230.22,84.28 233.27,84.28
B+_GPU_ALL on IN08 (solid shape): 241.78,82.5 257.27,82.5 257.65,82.12 257.65,79.96 257.53,79.84 248.76,79.84 248.25,80.34 240.89,80.34 240.25,80.98 229.59,80.98 229.46,81.11 229.46,83.65 229.59,83.77 240.51,83.77
B+_GPU_ALL on IN08 (solid shape): outline of 1212 points within 295.75,86.57 311.37,169.24
B+_GPU_ALL on TOP: 296.9,96.09 297.28,95.71 298.55,95.71 298.67,95.84 298.67,99.27 299.69,100.28 299.69,107.39 299.56,107.52 296.01,107.52 295.88,107.39 295.88,104.73 296.9,103.71
B+_GPU_ALL on TOP: 181.45,197.95 172.94,197.95 172.56,198.33 172.56,200.74 172.31,200.99 171.17,200.99 171.17,203.91 171.29,204.04 171.29,205.69 171.55,205.95 202.92,205.95 203.04,205.82 203.04,203.03 202.92,202.9 201.9,202.9 201.77,202.77 201.77,202.26 201.52,202.01 195.42,202.01 195.17,202.26 185.77,202.26 ; 1 cut-out
B+_GPU_ALL on BOTTOM: 296.13,107.27 296.13,105.62 296.01,105.49 296.01,103.71 296.26,103.46 299.31,103.46 300.07,104.22 300.07,107.01 299.69,107.39 296.26,107.39
B+_GPU_ALL on BOTTOM: 296.13,97.87 296.13,97.23 296.01,97.11 296.01,94.82 296.13,94.69 297.66,94.69 298.67,95.71 298.67,99.14 298.04,99.77 296.9,99.77 296.77,99.65 296.77,98.5
B+_GPU_ALL on IN03: 270.86,205.95 271.62,205.18 271.62,204.42 272.13,203.91 272.13,202.39 272.89,201.63 273.78,201.63 273.91,201.5 273.91,197.82 276.58,195.15 282.04,195.15 284.07,197.18 285.08,197.18 286.48,198.58 292.83,198.58 296.7,194.71 297.97,194.71 298.29,195.02 308.07,195.02 310.23,192.87 310.23,173.94 309.21,172.93 309.21,164.8 308.96,164.54 305.91,164.54 304.01,166.45 304.01,169.75 301.34,172.42 301.34,181.05 303.12,182.83 303.12,186.77 299.75,190.14 299.69,190.14 298.99,190.83 294.86,190.83 293.09,192.61 286.74,192.61 283.43,189.31 276.45,189.31 271.62,194.14 270.23,194.14 269.59,194.77 269.59,200.1 268.83,200.87 221.84,200.87 221.58,200.61 211.3,200.61 211.04,200.87 206.22,200.87 205.96,201.12 198.85,201.12 197.45,199.72 184.88,199.72 182.85,197.69 173.58,197.69 172.18,199.09 172.18,205.57 172.56,205.95 ; 2 cut-outs
B+_GPU_ALL on IN05: 201.65,205.95 201.77,205.82 201.77,201.63 201.01,200.87 190.22,200.87 189.2,199.85 186.53,199.85 185.14,198.45 172.82,198.45 171.93,199.34 171.93,205.44 172.44,205.95
B+_GPU_ALL on IN05: 290.55,108.92 294.74,108.92 296.13,107.52 299.05,107.52 299.18,107.39 299.18,99.65 298.8,99.27 298.8,97.65 298.67,97.36 298.8,97.08 298.8,96.88 298.67,96.6 298.8,96.32 298.8,92.99 298.61,92.79 298.61,85.99 296.39,83.77 296.39,81.74 295.88,81.23 285.08,81.23 282.1,78.25 270.16,78.25 270.07,78.15 254.13,78.15 253.59,78.69 253.59,82.38 254.35,83.14 278.73,83.14 282.29,86.69 282.29,89.61 283.43,90.76 285.21,90.76 287.37,92.92 287.37,100.92 289.91,103.46 289.91,108.28 ; 2 cut-outs
B+_GPU_ALL on VCC06: 169.77,205.44 201.65,205.44 201.9,205.18 201.9,200.23 201.14,199.47 185.71,199.47 184.75,198.52 171.1,198.52 169.64,199.98 169.64,205.31
B+_GPU_ALL on VCC07: 170.15,205.44 201.65,205.44 202.03,205.06 202.03,198.45 200.88,197.31 189.2,197.31 187.17,199.34 185.14,199.34 184.25,198.45 170.28,198.45 169.64,199.09 169.64,204.93
B+_GPU_ALL on IN08: 171.42,205.95 201.39,205.95 201.65,205.69 201.65,203.53 201.52,203.41 198.6,203.41 197.84,204.17 176.63,204.17 175.74,203.28 175.74,201.25 175.48,200.99 171.8,200.99 171.29,201.5 171.29,205.82
B+_GPU_ALL on IN10: outline of 295 points within 172.31,95.84 310.23,205.95 ; 2 cut-outs
BAT_R on BOTTOM: 94.46,17.35 94.72,17.09 96.91,17.09 97.02,16.97 99.79,16.97 100.43,17.61 100.43,21.8 98.9,23.32 94.84,23.32 94.46,22.94
CHASSIS1_GND on TOP: 2,93.93 2.13,94.06 6.95,94.06 7.59,93.42 13.3,93.42 15.21,95.33 15.21,106.25 13.81,107.65 13.81,112.09 13.05,112.86 8.1,112.86 7.21,111.97 1.24,111.97 1.11,112.09 1.11,113.62 1.24,113.74 1.37,113.74 1.75,114.13 14.45,114.13 16.35,112.22 16.35,108.16 17.11,107.39 17.11,94.95 14.57,92.41 5.56,92.41 4.16,91.01 2.13,91.01 2,91.14
CHASSIS1_GND on GND02, GND04, GND09, GND11: 18.4,91.01 16.88,92.54 0.79,92.54 0.79,93.75 0.93,94.1 1.28,94.24 10.61,94.24 12.19,94.04 11.99,95.62 11.99,100.55 11.99,100.66 11.98,100.66 11.75,101.12 11.29,101.35 11.28,101.36 11.18,101.36 10.99,101.36 10.99,104.74 11.18,104.74 11.28,104.74 11.29,104.75 11.75,104.98 11.98,105.44 11.99,105.44 11.99,105.55 11.99,110.48 12.19,112.06 10.61,111.86 1.28,111.86 0.93,112 0.79,112.35 0.79,114.64 0.93,114.99 1.28,115.13 2.51,115.13 2.51,114.74 3.25,114 17.73,114 22.83,108.9 22.83,91.16 22.68,91.01
CHASSIS1_GND on VCC06, VCC07: 12.49,100.76 12.47,100.78 12.14,101.45 11.5,101.83 11.5,104.27 12.14,104.65 12.47,105.32 12.49,105.34 12.49,110.22 12.55,112.42 10.36,112.37 1.3,112.37 1.3,114.63 2.63,114.63 3.25,114 17.73,114 22.83,108.9 22.83,91.16 22.68,91.01 18.4,91.01 16.88,92.54 1.3,92.54 1.3,93.73 10.36,93.73 12.55,93.68 12.49,95.88 ; 1 cut-out
CHG_PAHSE on TOP: 109.57,5.41 110.21,6.05 110.21,12.4 109.7,12.91 101.82,12.91 101.57,12.65 101.57,8.97 102.71,8.97 103.09,8.59 103.09,6.94 104.62,5.41
CPU_B+ on TOP: 152.88,187.91 152.75,188.04 152.75,188.42 153.26,188.42 153.26,189.18 152.75,189.18 152.75,189.69 153.26,189.69 153.26,190.45 152.75,190.45 152.75,192.48 153.26,192.48 153.26,193.37 152.75,193.37 152.75,193.75 153.26,193.75 153.26,194.52 152.75,194.52 152.75,195.41 153.26,195.91 156.05,195.91 156.43,195.53 159.48,195.53 159.93,195.09 165.89,195.09 165.96,195.15 170.02,195.15 170.78,194.39 179.55,194.39 181.07,192.87 194.53,192.87 195.04,192.36 203.42,192.36 203.68,192.1 210.54,192.1 210.79,191.85 210.79,186.77 211.81,185.75 211.81,176.36 213.2,174.96 213.2,171.15 212.95,170.89 210.66,170.89 210.28,171.28 210.28,183.34 209.27,184.36 209.27,188.93 208.5,189.69 169.03,189.69 168.6,190.12 167.99,190.12 167.66,190.45 167.3,190.45 166.97,190.12 166.21,190.12 166.01,190.33 165.68,190.33 165.04,189.69 157.45,189.69 157.07,189.31 157.07,188.62 156.86,188.41 155.37,188.41 154.88,187.91
CPU_B+ on BOTTOM: 152.62,191.85 157.78,191.85 157.8,191.88 162.3,191.88 162.48,191.7 162.48,189.87 162.17,189.56 162.17,188.78 162.07,188.67 159.94,188.67 159.55,189.06 157.44,189.06 156.78,188.4 155.82,188.4 154.32,186.9 152.88,186.9 151.99,187.79 151.99,191.21
CPU_B+ on BOTTOM: 210.92,173.43 214.09,173.43 214.35,173.18 214.35,171.15 213.96,170.77 211.04,170.77 210.79,171.02 210.79,173.31
CPU_B+ on BOTTOM: 179.67,191.88 183.89,191.88 184.07,191.7 184.07,189.87 183.76,189.56 183.76,188.75 183.71,188.7 181.4,188.7 180.56,189.54 179.7,189.54 179.55,189.69 179.55,191.75
CPU_B+ on BOTTOM: 190.47,191.88 194.69,191.88 194.86,191.7 194.86,189.87 194.56,189.56 194.56,188.78 194.48,188.7 192.2,188.7 191.37,189.53 190.72,189.53 190.34,189.91 190.34,191.75
CPU_B+ on BOTTOM: 205.48,188.75 205.48,189.56 205.79,189.87 205.79,191.7 205.61,191.88 201.11,191.88 200.78,191.54 200.78,190.07 201.29,189.57 202.19,189.57 203.1,188.65 205.38,188.65
CPU_B+ on BOTTOM: 168.88,191.88 173.1,191.88 173.27,191.7 173.27,189.87 172.97,189.56 172.97,188.8 172.84,188.68 170.56,188.68 169.72,189.51 169.26,189.51 168.8,189.97 168.8,191.8
CPU_B+ on BOTTOM: 165.07,197.31 165.07,194.9 165.96,194.01 170.02,194.01 170.66,194.64 170.66,197.69 170.02,198.33 166.09,198.33
CPU_B+ on IN08: 197.2,190.33 197.2,184.74 195.8,183.34 154.91,183.34 154.15,184.1 154.15,191.72 154.4,191.98 195.55,191.98
CPU_B+ on IN10: 208.5,188.29 208.5,184.86 204.31,180.67 155.54,180.67 153.89,182.32 153.89,191.09 157.45,194.64 165.32,194.64 165.96,195.28 170.02,195.28 172.31,192.99 172.56,192.99 173.32,192.23 196.82,192.23 197.45,191.6 200.76,191.6 201.01,191.85 207.11,191.85 207.74,191.21 207.74,189.06
CPU_CORE on TOP: outline of 88 points within 153.7,137.98 197.33,178.92 ; 4 cut-outs
CPU_CORE on BOTTOM: 172.31,139.65 172.31,139.91 172.44,140.03 176.58,140.03 176.92,139.84 177.26,140.03 177.42,140.03 177.85,139.75 178.28,140.03 180.94,140.03 181.33,139.83 181.71,140.03 183.74,140.03 183.99,139.78 184.63,139.78 185.01,139.4 185.01,138.51 184.75,138.26 172.18,138.26 172.05,138.38 172.05,139.4
CPU_CORE on BOTTOM: 171.8,151.34 171.8,154.89 171.29,155.4 171.29,158.96 171.19,159.06 171.19,161.81 171.04,161.96 179.81,161.96 180.11,162.26 180.69,162.26 180.69,158.83 182.21,157.31 182.21,156.9 182.49,156.62 182.49,150.65 182.26,150.42 171.93,150.42 171.81,150.54 171.81,151.32 ; 2 cut-outs
CPU_CORE on BOTTOM: 171.19,161.81 170.72,162.28 170.05,162.28 169.96,162.37 169.96,162.78 169.72,163.02 159.39,163.02 159.37,163.04 158.58,163.04 156.94,164.67 156.94,166.7 155.16,168.48 155.16,170.89 153.77,172.29 153.77,175.34 154.53,176.1 159.86,176.1 161.13,174.83 161.13,168.35 161.26,168.23 164.5,168.23 164.52,168.2 164.79,168.2 165.2,168.61 165.2,172.55 164.31,173.43 164.31,174.96 165.45,176.1 173.07,176.1 174.09,175.09 174.09,170.13 174.57,169.65 177.03,169.65 177.26,169.88 177.26,172.42 176.5,173.18 176.5,175.09 177.52,176.1 185.52,176.1 186.41,175.21 186.41,168.48 186.91,167.97 188.69,167.97 189.71,168.99 189.71,175.85 189.96,176.1 197.07,176.1 197.33,175.85 197.33,171.91 196.44,171.02 196.44,165.94 195.14,164.64 189.04,164.64 187.74,165.94 187.74,166.01 187.17,166.58 182.6,166.58 182.21,166.2 182.21,163.78 180.25,161.81
CPU_CORE on IN03: 173.81,140.92 174.82,139.91 181.33,139.91 182.34,140.92 182.47,140.92 182.72,141.18 182.72,151.34 181.71,152.35 181.71,157.94 181.58,158.07 156.81,158.07 155.8,157.05 155.8,142.45 157.45,140.8 168.75,140.8 168.88,140.92
CPU_CORE on IN05: 174.09,140.92 175.1,139.91 181.2,139.91 181.96,140.67 182.21,140.67 182.47,140.92 182.47,141.18 182.34,141.3 182.34,150.83 181.71,151.46 181.71,158.96 180.56,160.1 180.56,164.8 182.6,166.83 196.57,166.83 197.07,167.34 197.07,175.7 196.7,176.07 154.62,176.07 154.4,175.85 154.4,141.81 155.29,140.92
CPU_CORE on VCC06: 162,138 161.64,138.36 161.64,165.54 158.47,168.71 158.47,182.47 159.84,183.85 200.78,183.85 201.77,182.85 201.77,168.08 200.52,166.83 185.66,166.83 181.96,163.13 181.96,160.38 182.85,159.49 182.85,155.93 185.14,153.64 185.14,150.17 184.25,149.28 184.25,145.9 184.75,145.39 184.75,138.61 184.14,138
CPU_CORE on VCC07: 170.28,138.26 170.28,138.49 169.62,139.14 169.44,139.14 169.26,139.32 169.26,142.52 169.51,142.78 169.51,151.79 170.02,152.3 170.02,154.82 169.51,155.33 169.51,156.44 169.64,156.57 169.64,156.9 160.48,166.07 143.35,166.07 143.35,171.17 147.14,174.96 152.86,174.96 155.78,177.88 197.2,177.88 197.2,172.9 195.95,171.66 192.14,171.66 181.58,161.09 181.58,160.88 181.71,160.76 181.71,158.42 181.73,158.4 181.73,158.37 182.44,157.66 182.44,152.2 181.71,151.47 181.71,150.09 182.47,149.33 182.47,140.31 182.87,139.91 184.9,139.91 185.01,139.8 185.01,138.61 184.65,138.26
CPU_CORE on IN08: 195.8,179.78 196.82,178.77 196.82,155.02 194.34,152.54 186.37,152.54 185.21,151.39 185.21,149.76 183.1,147.65 183.1,140.29 184.5,138.89 184.5,137.87 183.87,137.24 166.21,137.24 165.32,138.13 165.32,144.1 158.21,151.21 158.21,158.32 154.66,161.88 154.66,178.01 156.43,179.78
CPU_CORE on IN10: 161.64,162 161.64,138.89 162.4,138.13 183.99,138.13 184.5,138.64 184.5,139.27 183.74,140.03 183.74,149.3 181.71,151.34 181.71,161.88 183.55,163.72 183.61,163.72 184.31,164.42 193.26,164.42 197.84,168.99 197.84,178.9 197.07,179.66 154.27,179.66 152.24,177.63 152.24,171.4
EC_AGND on TOP: 36.65,52.71 37.1,52.71 37.21,52.61 37.21,52.07 37.36,51.92 37.54,51.92 37.64,51.82 37.64,51.39 37.51,51.26 36.27,51.26 36.16,51.36 36.16,51.69 36.49,52.02 36.49,52.56
EDP_VDD_EN_N on BOTTOM: 209.39,193.88 209.39,193.37 209.65,193.12 210.15,193.12 210.41,192.87 210.66,192.87 210.79,192.99 210.79,193.25 210.03,194.01 209.52,194.01
FBVDDQ_PH1 on BOTTOM: 291.43,105.87 291.43,102.19 291.31,102.06 287.24,102.06 286.61,102.7 286.61,105.62 287.88,106.89 291.56,106.89 291.69,106.76 291.69,106.12
FBVDDQ_PH2 on BOTTOM: 289.66,90.38 290.16,90.88 290.16,92.66 290.55,93.04 291.43,93.04 291.56,93.17 291.56,96.6 291.43,96.73 287.24,96.73 287.18,96.66 286.16,96.66 285.72,96.22 285.72,90.88 286.23,90.38
GPU_B+ on BOTTOM (solid shape): 216,204.8 216,204.3 216.38,203.91 218.54,203.91 218.66,203.79 218.66,201.37 218.49,201.2 218.49,200.41 218.38,200.31 215.28,200.31 215.11,200.49 215.11,201.5 214.98,201.63 214.98,204.8 215.11,204.93 215.87,204.93
GPU_B+ on BOTTOM (solid shape): 252.7,204.8 252.7,204.17 253.05,203.81 255.06,203.81 255.16,203.71 255.16,201.3 255.06,201.2 255.06,200.41 254.96,200.31 252.11,200.31 251.68,200.74 251.68,204.8 251.81,204.93 252.57,204.93
GPU_B+ on BOTTOM (solid shape): 240.51,204.8 240.51,204.17 240.86,203.81 242.87,203.81 242.97,203.71 242.97,201.17 242.87,201.07 242.87,200.41 242.77,200.31 240.02,200.31 240.01,200.32 239.53,200.32 239.36,200.49 239.36,204.93 239.49,205.06 240.25,205.06
GPU_B+ on BOTTOM (solid shape): 264.64,204.68 264.64,204.42 265.25,203.81 267.25,203.81 267.35,203.71 267.35,201.3 267.25,201.2 267.25,200.41 267.15,200.31 264.05,200.31 263.62,200.74 263.62,204.68 263.75,204.8 264.51,204.8
GPU_B+ on BOTTOM (solid shape): 228.06,204.68 228.06,204.04 228.32,203.79 230.14,203.79 230.17,203.81 230.68,203.81 230.78,203.71 230.78,201.3 230.68,201.2 230.68,200.41 230.58,200.31 227.5,200.31 227.22,200.59 227.17,200.59 227.17,204.68 227.3,204.8 227.93,204.8
GPU_B+ on TOP: 227.3,204.93 228.06,204.93 228.19,204.8 228.19,204.04 228.32,203.91 230.73,203.91 230.86,203.79 230.86,202.52 230.6,202.26 230.6,201.5 230.22,201.12 227.55,201.12 227.17,201.5 227.17,204.8
GPU_B+ on TOP: 239.62,204.8 240.38,204.8 240.51,204.68 240.51,204.04 240.63,203.91 243.05,203.91 243.17,203.79 243.17,201.88 242.41,201.12 239.87,201.12 239.49,201.5 239.49,204.68
GPU_B+ on TOP: 210.28,201.63 206.09,201.63 204.95,202.77 204.19,202.77 203.8,203.15 203.8,205.95 210.41,205.95 210.66,205.69 210.66,202.01
GPU_B+ on TOP: 216.12,204.04 217.77,204.04 218.03,203.79 218.54,203.79 218.66,203.66 218.66,202.77 218.16,202.26 218.16,201.5 217.9,201.25 215.11,201.25 214.73,201.63 214.73,204.8 214.85,204.93 215.74,204.93 215.87,204.8 215.87,204.3
GPU_B+ on TOP: 252.06,204.8 252.19,204.68 252.19,204.3 252.32,204.17 255.11,204.17 255.24,204.04 255.24,201.88 254.6,201.25 251.56,201.25 251.3,201.5 251.3,204.68 251.43,204.8
GPU_B+ on TOP: 263.88,204.8 264.64,204.8 264.76,204.68 264.76,204.17 265.02,203.91 267.18,203.91 267.3,203.79 267.3,201.76 266.8,201.25 264.38,201.25 263.75,201.88 263.75,204.68
GPU_B+ on IN05: 211.68,205.95 212.19,205.44 223.11,205.44 223.49,205.06 225.14,205.06 225.39,205.31 235.68,205.31 235.94,205.06 237.46,205.06 237.71,205.31 259.43,205.31 259.68,205.06 261.59,205.06 262.1,205.57 266.16,205.57 266.42,205.31 268.19,205.31 269.08,204.42 269.08,191.6 267.94,190.45 214.35,190.45 211.81,192.99 211.81,194.9 211.42,195.28 209.77,195.28 206.85,198.2 203.17,198.2 202.53,198.83 202.53,205.69 202.79,205.95
GPU_B+ on VCC06: 269.21,205.48 269.21,195.02 267.94,193.75 210.92,193.75 207.11,197.56 203.17,197.56 202.41,198.33 202.41,205.18 202.71,205.48
GPU_SWN1 on BOTTOM (solid shape): 267.63,197.23 267.63,196.04 267.76,195.91 268.7,195.91 270.48,194.14 271.11,194.14 271.62,193.63 271.62,190.33 271.24,189.94 267.18,189.94 266.92,190.2 266.92,191.34 266.8,191.47 266.29,191.47 266.03,191.21 266.03,189.82 265.91,189.69 261.72,189.69 261.59,189.82 261.59,194.01 262.35,194.77 262.35,196.8 262.86,197.31 267.56,197.31
GPU_SWN2 on BOTTOM (solid shape): 255.44,197.23 255.44,196.04 255.57,195.91 256.38,195.91 258.03,194.26 259.18,194.26 259.43,194.01 259.43,190.2 259.18,189.94 255.11,189.94 254.86,190.2 254.86,191.34 254.73,191.47 254.1,191.47 253.84,191.21 253.84,189.82 253.59,189.56 249.65,189.56 249.4,189.82 249.4,194.26 249.52,194.39 250.03,194.39 250.41,194.77 250.41,197.06 250.67,197.31 255.37,197.31
GPU_SWN3 on BOTTOM (solid shape): 243.25,197.23 243.25,196.04 243.38,195.91 244.32,195.91 245.97,194.26 247.11,194.26 247.24,194.14 247.24,190.33 246.98,190.07 242.79,190.07 242.67,190.2 242.67,191.34 242.54,191.47 241.9,191.47 241.78,191.34 241.78,190.07 241.4,189.69 237.33,189.69 237.21,189.82 237.21,193.75 237.97,194.52 237.97,197.06 238.22,197.31 243.17,197.31
