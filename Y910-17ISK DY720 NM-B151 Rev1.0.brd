# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VBAT: length 97.1
  TOP w0.254: v1(87.13,3) 87.13,3.57 PR212.2 ; PR207.2 110.57,22.95 111.09,22.43 v1(111.09,22.3)
  TOP w0.508: PR205.1 88.23,14.49 v1(88.23,13.54)
  IN05 w0.254: v1(87.13,3) 87.28,3.15 87.28,4.31 83.15,8.43 83.15,14.97 84.27,16.08 86.58,16.08 92.3,21.8 105.86,21.8 106.24,22.18 110.97,22.18 v1(111.09,22.3)
  IN05 w0.508: v1(96.49,6.05) 96.49,18.78 97.6,19.89 105.25,19.89 105.89,20.53 111.6,20.53 112.24,21.16 112.24,22.81 110.71,24.34 v1(109.57,24.34)
  IN08 w0.508: v1(91.41,23.07) 88.74,20.4 88.74,18.24 88.23,17.73 v1(88.23,13.54)
  BOTTOM w0.508: PD202.2 95.6,6.3 95.85,6.05 v1(96.49,6.05)
  vias: v1(100.68,25.1) v1(100.68,24.34) v1(101.44,25.1) v1(101.44,24.34) v1(102.46,25.1) v1(102.46,24.34) v1(103.22,25.1) v1(103.22,24.34) v1(104.11,25.1) v1(104.11,24.34) v1(104.87,25.1) v1(104.87,24.34) v1(105.63,25.1) v1(105.63,24.34) v1(106.4,25.1) v1(106.4,24.34) v1(107.16,25.1) v1(107.16,24.34) v1(107.92,25.1) v1(107.92,24.34) v1(108.81,25.1) v1(108.81,24.34) v1(109.57,25.1) v2(110.46,24.34)
VCC0V9_CIO: length 1.8
  BOTTOM w0.203: v2(52.52,86.38) 52.2,86.06 U2005.R12 v2(51.87,86.38) ; U2005.R9 52.2,87.41 v2(52.5,87.71) 52.2,88.01 U2005.R8
VCC0V9_DP: length 6
  TOP w0.254: C2076.1 50.66,88.42 v2(50.57,88.33)
  TOP w0.305: C2074.1 49.79,86.52 v2(49.92,86.38)
  BOTTOM w0.203: U2005.V11 v2(53.17,87.03) 52.85,86.71 U2005.T11 ; U2005.T12 52.85,86.06 v2(53.17,86.38) U2005.V12 53.31,85.87 53.31,85.6 U2005.V13 ; U2005.L12 50.24,86.06 v2(49.92,86.38) 50.15,86.61 50.15,86.61 U2005.L11 ; U2005.M6 v2(50.57,88.33) U2005.L6 ; v2(50.57,87.68) U2005.M8
  vias: v2(49.92,87.68)
VCC0V9_LVR_OUT: length 10.3
  TOP w0.305: v2(49.27,87.03) 49.16,87.14 C2111.1 47.53,87.14 47.19,87.48 46.15,87.48 C2110.1
  TOP w0.356: C2109.1 45.21,84.2 v2(45.21,85.6) 45.21,87.18 45.54,87.51 C2110.1
  BOTTOM w0.178: U2005.F18 48.3,83.46 v2(47.97,83.13) ; 48.62,83.13 48.95,83.46 U2005.H18 ; U2005.J11 49.59,86.71 v2(49.27,87.03)
  BOTTOM w0.203: v2(49.27,87.03) U2005.H11
VCC0V9_PCIE:
  vias: v2(49.92,82.48) v2(49.92,82.48) v2(50.57,84.43) v2(50.57,83.78) v2(50.57,83.13)
VCC0V9_SVR: length 2.1
  TOP w0.305: v2(49.27,87.68) 48.79,88.16 C2091.1
  BOTTOM w0.203: U2005.J9 49.59,87.36 v2(49.27,87.68) ; U2005.L9 v2(50.57,87.03) U2005.M9
  vias: v1(40.48,97.11) v1(40.48,96.47) v1(40.48,95.84) v1(41.12,97.11) v1(41.12,96.47) v1(41.12,95.84) v2(47.97,85.73) v2(47.97,85.08) v2(48.62,85.73) v2(48.62,85.08)
VCC0V9_USB: length 2.4
  TOP w0.254: C2073.1 51.94,83.85 v2(51.87,83.78) 51.87,83.37 C2072.1
  BOTTOM w0.203: U2005.R15 52.04,84.6 52.04,84.27 U2005.R16 52.2,84.11 v2(51.87,83.78)
VCC1V8A_TBTA_LDO: length 5
  BOTTOM w0.254: C2121.1 28.54,69.96 v2(28.67,70.08) 29.79,71.2 30.32,71.2 30.96,71.83 31.2,71.83 U2007.K1
VCC1V8D_TBTA_LDO: length 12.8
  TOP w0.203: v2(36.93,71.83) 36.96,71.87 C2118.1
  TOP w0.254: v2(33.78,80.06) 33.5,80.06 R2077.1
  IN10 w0.203: v2(36.93,71.83) 36.93,72.09 36.29,72.72 36.29,76.66 35.1,77.85 35.1,79.68 34.72,80.06 v2(33.78,80.06)
  BOTTOM w0.203: v2(36.93,71.83) 36.93,72.22 36.26,72.88 U2007.A2
VCC3V3_ANA_PCIE: length 1
  TOP w0.305: C2107.1 49.89,83.81 v2(49.92,83.78)
  BOTTOM w0.203: U2005.L16 50.25,84.11 v2(49.92,83.78)
VCC3V3_ANA_USB2: length 1
  TOP w0.305: v2(49.92,84.43) 49.61,84.43 C2108.1
  BOTTOM w0.178: v2(49.92,84.43) U2005.J16
VCC3V3_FLASH: length 59.3
  TOP w0.305: v2(32.86,71.45) 33.29,71.02 C2127.1 33.48,71.26 33.7,71.48 33.8,71.48 R2068.2 R2070.2
  TOP w0.356: v1(52.88,99.14) 53.73,99.14 C2055.1 54.36,99.05 C2100.1 ; v1(52.88,99.14) R2020.2 ; v1(52.88,99.14) 53.06,98.96 R2019.2 R2018.2 R2017.2 ; v2(33.73,78.82) 33.67,78.77 R2078.1
  IN03 w0.508: v1(39.72,98.89) 38.83,98 38.83,85.68 37.56,84.41 35.02,84.41 32.86,82.25 32.86,79.58 33.62,78.82 v2(33.73,78.82)
  IN08 w0.508: v1(39.72,98.89) 40.61,99.77 52.42,99.77 52.88,99.32 v1(52.88,99.14)
  IN10 w0.508: v2(32.86,71.45) 32.86,71.83 31.59,73.1 31.59,76.69 v2(33.73,78.82)
  BOTTOM w0.178: U2007.G1 33.22,72.35 33.22,71.81 v2(32.86,71.45)
  BOTTOM w0.508: v1(52.88,99.14) 53.06,99.32 U2012.8
VCC3V3_LC: length 12
  TOP w0.356: v1(53.82,94.72) 53.84,94.69 53.84,93.78 R2013.2 R2012.2 R2014.2 R2011.2 ; C2081.1 v2(52.52,88.33)
  IN08 w0.254: 53.06,90.12 52.52,89.59 v2(52.52,88.33)
  IN08 w0.356: v1(53.82,94.72) 53.82,93.3 52.55,92.03 52.55,91.27 53.06,90.76 53.06,90.12
  BOTTOM w0.178: U2005.R6 v2(52.52,88.33)
VCC3V3_S0: length 1
  TOP w0.356: v2(51.87,85.73) 51.89,85.72 C2151.1
  BOTTOM w0.254: v2(51.87,85.73) U2005.R13
  vias: v2(54.45,85.12) v2(55.34,85.09)
VCC3V3_S0_SYS: length 2.1
  TOP w0.305: v2(48.63,87.69) 48.48,87.84 C2084.1
  TOP w0.356: v1(42.29,89.74) 42.29,90.72 C2083.1
  BOTTOM w0.254: v2(48.63,87.69) 48.95,87.37 U2005.H9
  vias: v1(41.12,89.61) v1(41.63,90) v1(41.75,89.36) v1(43.02,90) v1(43.53,89.61) v1(43.73,75.01) v1(43.73,74.37) v1(43.73,73.74) v1(44.37,75.01) v1(44.37,74.37) v1(44.37,73.74) v1(60.8,82.5) v1(61.44,81.87) v2(51.25,84.43) v2(53.18,83.19) v2(53.78,83.78)
VCC3V3_SX_SYS: length 21.7
  TOP w0.203: 27.37,78.09 U2011.6
  TOP w0.305: 27.37,78.09 v2(27.37,77.8) v2(27.37,76.25)
  TOP w0.356: R2091.2 31.64,71 v2(32.1,71.45) 32.1,70.69 32.96,69.83 34.89,69.83 35.38,70.31 v2(35.71,70.31) 35.83,70.18 R2098.2
  IN10 w0.305: v2(27.37,76.25) 28.16,75.46 28.16,72.72 29.43,71.45 v2(32.1,71.45)
  BOTTOM w0.254: C2124.1 36.29,70.44 35.68,71.05 35.68,72.32 35.75,72.38 U2007.B1 ; v2(32.1,71.45) 32.1,71.61 32.63,72.14 32.63,72.27 U2007.H1
  BOTTOM w0.356: v2(35.71,70.31) 35.73,70.31 35.91,70.13 C2124.1
VCC3V3_SX_SYS_AR: length 44.1
  TOP w0.254: R2282.2 60.93,95.02 v2(60.93,95.96)
  TOP w0.305: C2082.1 47.78,88.52 v2(47.97,88.33)
  TOP w0.356: R2024.2 v1(63.42,95.46) 63.42,95.71 63.11,96.02 60.98,96.02 v2(60.93,95.96) 60.55,96.35 57.94,96.35 ; R2056.2 57.94,94.89 58.14,94.69 R2023.2 ; R2034.2 R2036.2 51.73,94.06 R2037.2 R2026.2 52.93,95.08 v1(53.18,95.33)
  TOP w0.508: R2056.2 57.94,96.35 57.69,96.6 57.11,96.6 56.53,97.18 55.92,97.18 55.47,96.73 54.71,96.73 54.25,96.27 R2028.2 53.69,95.84 v1(53.18,95.33)
  IN03 w0.305: v1(62.96,88.47) 62.33,89.11 62.33,90.99 62.72,91.38 62.72,94.76 v1(63.42,95.46)
  IN05 w0.508: v1(51.91,91.9) 51.91,91.01
  IN08 w0.508: v1(53.18,95.33) 53.18,93.81 51.91,92.54 v1(51.91,91.9)
  BOTTOM w0.203: v2(47.97,88.33) 47.99,88.33 48.3,88.02 U2005.F8
  BOTTOM w0.254: R2066.2 60.62,91.52 62.03,91.52 62.33,91.22 62.33,88.98 62.83,88.47 v1(62.96,88.47)
  BOTTOM w0.356: R2053.2 54.02,96.8 53.18,95.96 v1(53.18,95.33)
VCC3V3_TBT_SX: length 9.9
  TOP w0.356: v1(28.67,67.77) 28.67,67.85 29.23,68.41 R2069.1 ; v2(32.23,73.36) 32.14,73.45 C2128.1
  IN08 w0.508: v2(32.23,73.36) 32.23,72.85 30.45,71.07 29.56,71.07 28.67,70.18 v1(28.67,67.77)
  BOTTOM w0.254: v2(32.23,73.36) 32.33,73.36 32.75,72.94 U2007.H2
VCC5V0_SYS: length 10
  IN08 w0.508: v1(40.48,78.82) 40.48,78.57 39.97,78.06 33.37,78.06 32.75,77.44 v2(32.75,76.41)
  BOTTOM w0.254: U2007.H10 v2(32.75,76.41)
  vias: v1(40.48,80.09) v1(40.48,79.45) v1(41.63,80.12) v1(41.63,79.48) v1(41.63,78.85) v2(35.5,79.2) v2(35.5,78.64) v2(39.01,80.14) v2(39.09,79.3) v2(39.67,79.3) v2(39.67,78.74)
VCC20V0_SYS: length 1.6
  BOTTOM w0.089: C2119.1 38.4,75.33
  BOTTOM w0.097: 38.4,75.33 39.78,75.33 v2(39.85,75.26)
VCC_BOOT: length 2.8
  TOP w0.203: PR1189.2 131.16,188.42 129.99,189.6 PU1101.28
VCC_EN: length 4.2
  TOP w0.097: v1(121.38,194.77) 121.38,194.64 v2(121.76,194.26) 121.89,194.26 122.56,193.6 PU1101.2
  BOTTOM w0.097: PR1242.1 120.56,195.4 PC1159.2 121.11,194.5 v1(121.38,194.77)
VCC_ICCMAX: length 3.5
  TOP w0.203: PU1101.36 130.02,192.8
  TOP w0.254: PR1191.2 132.61,193.53 v2(131.74,193.53) 131.24,193.53 130.51,192.8 130.02,192.8
VCC_PROG: length 3.8
  TOP w0.203: PU1101.10 122.48,190.4 121.15,189.07 121.15,188.52 120.92,188.29 PR1187.2
VCC_RTCEXT_CAP: length 2.4
  TOP w0.254: v3(234.92,53.67) 235.1,53.67 235.43,53.34 235.43,52.61 235.22,52.4 C209.2
  BOTTOM w0.254: U2.BA26 235.47,53.3 235.1,53.67 v3(234.92,53.67)
VCCIO_BST: length 3.5
  BOTTOM w0.203: PU1204.5 132.25,150.3 132.38,150.17
  BOTTOM w0.381: PR1225.1 133.92,149.72 133.7,149.51 133.04,149.51 132.38,150.17
VCCIO_EN: length 213.8
  IN05 w0.091: v1(84.17,34.62) 83.59,34.04 76.11,34.04 75.15,35 61.31,35 59.79,33.48 58.64,33.48 54.73,37.39 54.73,41.84 52.57,44 52.57,46.16 51.53,47.2 v1(50.9,47.2)
  IN08 w0.091: v1(84.17,34.62) 82.01,36.78 82.01,48.47 81.25,49.23 81.25,52.02 79.98,53.29 79.98,60.53 78.96,61.55 78.96,65.48 78.33,66.12 77.69,66.12 76.3,67.52 76.3,69.83 76.98,70.51 76.98,77.01 77.36,77.39 77.36,81.54 77.95,82.12 77.95,89.23 79.06,90.35 79.32,90.35 80.23,91.27 80.23,98.56 81.5,99.83 87.22,99.83 97.33,109.93 101.44,109.93 103.35,111.84 103.35,114 109.7,120.35 109.7,125.43 111.86,127.59 v1(114.78,127.59)
  IN10 w0.091: v1(114.78,127.59) 131.29,127.59 134.65,130.95 134.65,132.22 139.67,137.24 139.67,140.85 v1(135.4,145.11)
  BOTTOM w0.097: PU1204.28 135.36,152.16 135.48,152.28 PC1225.1 R520.2 R537.2 136.09,150.22 135.78,149.91 R51.1 136.24,149.15 136.24,148.03 136.11,147.91 136.11,145.82 v1(135.4,145.11) ; v1(50.9,47.2) 51.23,47.53 R841.1
VCCIO_GND: length 7.6
  BOTTOM w0.203: PU1204.19 132.25,155.88 v1(132.38,156.01) ; v3(135.4,154.36) 135.4,154.23 134.93,153.76 PU1204.24
  BOTTOM w0.356: v1(132.38,156.01) 132.58,156.21 PC1280.2 ; PC1222.1 134.54,158.02 v3(134.13,158.42) 133.65,157.94 PR1224.2 ; PC1272.2 v1(137.92,152.48) 137.71,152.28 PC1225.2 ; PR1232.1 137.94,154.13 137.94,154.77 v1(137.87,154.84)
  vias: v2(135.38,156.04)
VCCIO_GSNS: length 3.5
  BOTTOM w0.203: PU1204.23 133.85,155.07 134.03,155.25 135.15,155.25 135.4,154.99 PR1202.2 PR1229.2
VCCIO_LP_: length 2.1
  TOP w0.254: v1(133.52,150.14) 133.98,150.6 PR1220.2
  BOTTOM w0.203: PU1204.2 133.45,150.21 v1(133.52,150.14)
VCCIO_PWRGD: length 452.9
  TOP w0.097: v1(135.12,151.44) 135.71,150.85 PR1221.2
  IN05 w0.091: v1(114.02,32.85) 111.52,32.85 110.68,32 99.46,32 97.56,30.11 94.66,30.11 93.67,29.12 80.66,29.12 80.36,29.42 74.52,29.42 71.6,26.5 64.36,26.5 62.81,28.04 57.66,28.04 56.63,29.08 55.68,29.08 50.26,34.5 50.26,38.56 49.63,39.2 v1(49.12,39.2)
  IN08 w0.091: v1(173.83,195.41) 177.26,195.41 178.28,194.39 184.88,194.39 185.14,194.64 185.14,195.28 185.9,196.04 192.12,196.04 192.37,195.79 195.04,195.79 196.69,194.14 196.69,193.39 199.95,190.13 199.95,183.93 198.73,182.71 198.73,176.73 200.38,175.09 200.38,167.21 201.53,166.06 201.53,158.95 204.89,155.58 204.89,151.41 198.85,145.37 198.85,130.51 192.88,124.54 192.88,117.05 201.01,108.92 201.01,85.17 201.65,84.53 201.65,59.85 199.03,57.23 199.03,46.33 197.35,44.66 195.35,44.66 194.91,45.1 194.91,45.67 193.01,47.58 189.2,47.58 188.46,46.84 171.48,46.84 168.98,49.35 119.36,49.35 113.13,43.11 113.13,33.73 v1(114.02,32.85)
  IN10 w0.091: v1(135.12,151.44) 134.84,151.72 134.84,170.89 135.73,171.78 147.67,171.78 150.46,174.58 150.46,178.9 152.62,181.05 152.62,191.6 154.15,193.12 156.31,193.12 158.08,194.9 163.55,194.9 164.43,195.79 165.32,195.79 165.83,196.29 169.9,196.29 171.29,194.9 173.32,194.9 v1(173.83,195.41)
  BOTTOM w0.097: R521.1 47.47,40.97 47.72,41.23 48.1,41.23 48.31,41.02 48.31,40.01 v1(49.12,39.2) 49.63,39.2 50.44,40.01 R837.2 ; PU1204.1 133.85,150.7 134.18,150.37 134.89,150.37 135,150.47 135,151.31 v1(135.12,151.44)
VCCIO_SLEW: length 3.1
  BOTTOM w0.203: 133.88,156.09 133.65,156.09 133.05,155.49 PU1204.21
  BOTTOM w0.356: 133.88,156.09 134.34,156.09 134.54,156.29 PC1222.2
VCCIO_SW: length 3.9
  BOTTOM w0.508: PC1271.2 133.78,146.54 131.96,148.35 PL1201.1
  vias: v2(128.21,147.02)
VCCIO_TRIP: length 5.1
  BOTTOM w0.203: v2(132.58,158.58) PR1226.2 132.86,157.66 133.08,157.44 133.08,156.98 133.24,156.82 PR1224.1 133.65,156.59 132.65,155.6 PU1204.20
VCCIO_VIN:
  vias: v1(129.64,156.54) v1(129.64,155.65) v1(129.64,154.89) v2(128.62,156.8)
VCCIO_VREF: length 2.6
  BOTTOM w0.203: PU1204.26 135.45,152.96 135.52,153.03
  BOTTOM w0.356: 135.52,153.03 135.63,153.14 PR1231.1 136.11,153.22 PC1272.1
VCCIO_VREFIN: length 2.8
  BOTTOM w0.203: PU1204.25 135.17,153.36 135.34,153.53
  BOTTOM w0.356: 135.34,153.53 135.86,154.05 PR1231.2 136.09,154.11 PR1232.2
VCCIO_VSNS: length 4.4
  BOTTOM w0.203: PU1204.22 133.45,155.28 133.8,155.63 134.89,155.63 135.43,156.16 PR1201.1 PR1227.2
VCCIOP:
  vias: v2(138.15,142.95)
VCCSENSE_NVVDDS: length 104.6
  IN08 w0.254: v1(207.11,101.43) 207.23,101.55 207.23,106.41 207.71,106.89 208.38,106.89 209.14,107.65 209.14,112.96 208.5,113.59 204.67,113.59 204.19,113.11 200.25,113.11 194.79,118.57 194.79,122.51 200.88,128.6 200.88,144 206.98,150.1 206.98,151.08 207.36,151.46 208.12,151.46 v1(208.25,151.59)
  BOTTOM w0.2: G2.BM45 235.76,143.84 233.81,143.84 225.2,152.45 223.87,152.45 223.34,152.99 219.04,152.99 217.14,151.08 209.77,151.08 209.39,151.46 208.38,151.46 v1(208.25,151.59)
  BOTTOM w0.254: v1(207.11,101.43) 207.23,101.3 208,101.3 208.88,102.19 209.47,102.19 PR3437.2
VCCSENSE_VGA: length 132.8
  TOP w0.254: PR1473.2 298.7,181.44 299.05,181.44 299.44,181.05 v2(299.69,181.05) 300.07,181.05 300.45,180.67 300.45,178.64 300.2,178.39 299.18,178.39 296.9,176.1 288.77,176.1 v1(288.64,176.23)
  IN10 w0.254: v1(224.16,154.09) 224.5,153.75 224.86,153.75 226.79,155.69 226.79,177.15 228.92,179.28 234.57,179.28 235.2,178.64 237.3,178.64 239.46,180.8 247.08,180.8 247.84,181.56 250.57,181.56 251.46,180.67 256.35,180.67 256.73,180.29 258.51,180.29 259.15,180.93 259.65,180.93 261.56,182.83 263.4,182.83 266.19,180.04 269.26,180.04 269.87,180.65 273.22,180.65 274.59,182.02 278.3,182.02 v1(278.48,182.2) 278.66,182.02 281.45,182.02 282.04,181.44 282.67,181.44 282.98,181.74 284.91,181.74 286.15,180.5 286.15,177.96 288.01,176.1 288.51,176.1 v1(288.64,176.23)
  BOTTOM w0.15: 236.79,144.32 236.44,144.32 236.09,144.67
  BOTTOM w0.2: G2.BK45 237.14,143.97 236.79,144.32 ; 236.09,144.67 234.2,144.67 225.04,153.83 224.42,153.83 v1(224.16,154.09)
  BOTTOM w0.254: PR3530.2 278.3,182.38 v1(278.48,182.2)
VCCSFR_OC_EN: length 2.1
  TOP w0.097: PU1254.2 190.47,129.04 PR1258.1 PC1226.1
VCCST_SFR_ENABLE_EN: length 2.7
  TOP w0.097: PR1317.2 PC1316.1 202.79,152.61 202.23,153.17 PU1308.2
VCCSTG_EN: length 4
  TOP w0.097: PR1253.1 206.52,153.47 PC1227.1 207.79,153.9 v2(207.79,154.38) 207.79,155.22 207.31,155.71 PU1252.2
VDD18_GPU: length 2.9
  TOP w0.254: C2218.1 247.69,117.1 v3(248.23,117.1)
  TOP w0.356: C2214.1 248.08,117.81 v3(248.23,117.66)
  BOTTOM w0.356: C2217.1 v1(234.52,112.75) ; C2220.1 v1(232.89,113.36)
  vias: v1(221.33,120.35) v1(222.09,120.35) v1(222.85,120.98) v1(222.85,120.35) v2(219.93,119.21) v3(244.64,120.52) v3(244.64,119.83) v3(245.94,120.52) v3(245.99,119.77) v3(246.84,120.52) v3(246.79,119.77) v3(248.04,120.52) v3(248.09,119.77) v3(248.94,120.52) v3(248.89,119.77) v3(250.14,120.52) v3(250.19,119.77)
VDDQ_FB_R: length 4.4
  TOP w0.254: PR441.1 105.28,91.77 105.33,91.72 PR408.1 PC413.1
  TOP w0.381: v2(106.88,93.32) 106.73,93.17 PR440.1 105.96,92.74 105.76,92.54 PR408.1
VDDQ_PWRGD: length 120.5
  TOP w0.097: PR411.1 107.67,87.96 v1(107.92,88.22) 108.17,88.22 108.64,88.69 PU401.10
  IN05 w0.091: v1(36.29,60.28) 37.18,61.17 39.76,61.17 43.02,57.9 45.22,57.9 46.34,59.02 52.28,59.02 53.31,57.99 53.31,55.45 55.47,53.29 55.72,53.29 58.64,50.37 58.64,49.48 59.53,48.59 67.03,48.59 67.79,47.83 72.23,47.83 73.11,46.96 89.49,46.96 90.27,46.18 97,46.18 v1(97.12,46.31)
  IN08 w0.091: v1(107.92,88.22) 108.22,87.92 108.22,71.37 102.71,65.87 102.71,65.36 100.43,63.07 99.66,63.07 98.01,61.42 98.01,52.78 97.12,51.9 v1(97.12,46.31)
  BOTTOM w0.097: R257.2 v1(36.29,60.28)
VDDQ_VTT_EN: length 139.6
  TOP w0.097: v1(108.55,95.71) 108.21,95.37 U56.4 107.64,95.01 107.37,94.75 R49.1 ; PU401.7 108.15,89.89 v1(107.92,90.12) 107.67,89.87 PC439.2
  IN05 w0.091: v1(96.87,30.94) 93.82,30.94 93.44,30.56 85.06,30.56 84.39,29.89 81.05,29.89 80.87,30.07 74.16,30.07 71.34,27.26 64.74,27.26 63.22,28.78 58.01,28.78 57.03,29.76 56.59,29.76 51.21,35.15 51.21,39.72 50.21,40.72 v1(48.74,40.72)
  IN08 w0.091: v1(96.87,30.94) 96.34,30.94 95.98,31.3 95.98,32.08 93.52,34.54 93.52,39.47 94.94,40.89 95.65,40.89 96.68,41.93 96.68,45.86 96.61,45.93 96.61,51.89 97.63,52.91 97.63,61.42 98.01,61.8 98.01,63.71 103.86,69.55 103.86,87.07 104.62,87.84 104.62,90.01 105.37,90.76 107.28,90.76 v1(107.92,90.12) 107.92,91.27 107.79,91.39 107.79,92.15 108.17,92.54 108.17,93.17 108.55,93.55 v1(108.55,95.71)
  BOTTOM w0.097: R839.2 48.74,41.56 v1(48.74,40.72)
VSSSENSE_NVVDDS: length 104.7
  IN08 w0.254: v1(208.25,150.96) 208.12,151.08 207.61,151.08 207.36,150.83 207.36,149.86 201.26,143.76 201.26,128.35 195.17,122.25 195.17,118.82 200.5,113.49 203.93,113.49 204.41,113.97 208.68,113.97 209.52,113.14 209.52,107.49 208.53,106.51 207.87,106.51 207.61,106.25 207.61,101.17 207.36,100.92 207.23,100.92 v1(207.11,100.79)
  BOTTOM w0.2: v1(208.25,150.96) 208.38,151.08 209.27,151.08 209.65,150.7 217.27,150.7 219.17,152.61 223.11,152.61 223.62,152.1 225.07,152.1 233.65,143.52 235.63,143.52 235.88,143.27 G2.BM44
  BOTTOM w0.254: v1(207.11,100.79) 207.23,100.92 208.15,100.92 209.04,101.81 209.6,101.81 PR3436.2
VSSSENSE_VGA: length 133.2
  TOP w0.254: v1(288.64,175.47) 288.89,175.72 297.05,175.72 299.34,178.01 300.36,178.01 300.96,178.61 v2(300.96,179.15) 300.96,180.8 300.2,181.56 299.56,181.56 299.31,181.82 298.52,181.82 PR1472.2
  IN10 w0.254: v1(224.16,153.2) 224.33,153.37 225.01,153.37 227.17,155.53 227.17,176.99 229.08,178.9 234.41,178.9 235.05,178.26 237.46,178.26 239.62,180.42 247.24,180.42 248,181.18 250.41,181.18 251.3,180.29 256.19,180.29 256.57,179.91 258.67,179.91 259.3,180.55 259.81,180.55 261.72,182.45 263.24,182.45 266.03,179.66 269.46,179.66 270.02,180.22 273.32,180.22 274.67,181.56 278.35,181.56 v1(278.48,181.44) 278.61,181.56 281.27,181.56 281.78,181.05 282.83,181.05 283.13,181.36 284.75,181.36 285.77,180.34 285.77,177.78 287.83,175.72 288.39,175.72 v1(288.64,175.47)
  BOTTOM w0.15: G2.BL45 236.39,143.97 236.01,144.34
  BOTTOM w0.2: 236.01,144.34 234.06,144.34 224.95,153.45 224.42,153.45 v1(224.16,153.2)
  BOTTOM w0.254: PR3529.2 278.4,181.51 v1(278.48,181.44)
1.05G_FB: length 3.6
  BOTTOM w0.254: PU702.4 218.02,167.14 PR721.1 PC721.2 218.28,165.99 PR719.1
1.05G_LX: length 1.5
  TOP w0.508: v3(214.03,164.35) 214.41,163.97 PC712.2
203_RAMP: length 3.8
  TOP w0.203: PU1101.9 122.27,190.8 122.17,190.7
  TOP w0.381: 122.17,190.7 v2(121.77,190.29) 121.52,190.05 PR1196.2 120.64,190.02 PC1152.2
203_VCC: length 2
  TOP w0.203: PU1101.7 122.52,191.6 122.27,191.85
  TOP w0.381: 122.27,191.85 v1(122.02,191.85) v1(121.38,191.85)
  vias: v2(121.61,190.66)
81203_RDY: length 7.1
  TOP w0.097: PU1101.6 122.65,192 122.04,192.61 v1(121.61,192.61) 121.33,192.61 PR1241.2
  BOTTOM w0.097: PR1240.2 118.59,192.23 118.69,192.13 119.73,192.13 120.21,192.61 v1(121.61,192.61)
+CORE_PLLVDD: length 3
  TOP w0.381: R35.1 233.27,128.98 232.89,128.6 232.89,127.21
  vias: v2(234.67,122)
+CORE_PLLVDD_GPU: length 61.1
  TOP w0.254: C698.1 260.85,141.3 v3(260.64,141.52)
  TOP w0.356: C2415.1 254.2,120.65 v3(254.34,120.52) ; C697.1 243.79,129.26 v3(243.3,129.75) 242.67,129.75 242.39,129.47 C2416.1
  TOP w0.406: C2416.1 241.14,129.24 240.76,128.86 v2(239.36,128.86) 238.86,128.86 238.55,129.16 235.92,129.16 R35.2
  IN03 w0.356: v3(245.3,122.61) 245.27,122.61 244.44,123.44 244.44,128.98 243.68,129.75 v3(243.3,129.75)
  IN05 w0.381: v3(245.3,122.61) 245.3,122.03 246.1,121.24 253.61,121.24 v3(254.34,120.52) 255.44,121.62 262.86,121.62 263.49,122.25 263.49,123.27 263.41,123.36 263.41,139.36 262.22,140.54 261.61,140.54 v3(260.64,141.52)
  BOTTOM w0.254: G2.BB24 243.3,129.68 v3(243.3,129.75) ; v3(260.64,141.52) 260.64,141.62 G2.U42 ; v3(254.34,120.52) 254.09,120.27 G2.AF11
+FB_PLL_AVDD: length 48.1
  TOP w0.356: v3(264.24,138.82) 263.83,139.22 C692.1 ; v3(248.94,141.52) 248.87,141.45 C686.1 ; v3(264.18,124.21) 263.89,123.92 C691.1 ; v3(259.44,120.52) 259.81,120.89 C690.1
  IN03 w0.406: v3(264.18,124.21) 263.75,123.78 263.75,122.51 262.35,121.11 244.44,121.11 244.19,121.36 244.19,121.82 243.38,122.63 236.95,122.63 236.44,123.14 236.44,123.65 232.25,127.84 v1(228.82,127.84)
  BOTTOM w0.254: G2.L38 264.34,138.82 v3(264.24,138.82) ; v2(227.05,126.7) 227.43,127.08 227.93,127.08 228.7,127.84 v1(228.82,127.84) ; G2.L17 264.34,124.37 v3(264.18,124.21) ; G2.V11 259.44,120.42 v3(259.44,120.52)
  BOTTOM w0.3: G2.AN42 249.19,141.77 v3(248.94,141.52)
+FB_PLLVDD: length 1.6
  TOP w0.097: C687.1 223.36,127.4 v2(223.36,128.35)
+GVDD_AMP: length 3.2
  TOP w0.254: U8.8 266.81,33.95
  TOP w0.305: 266.81,33.95 R325.1 266.01,33.56 265.96,33.61 C340.1
+IFP_IOVDD: length 9.4
  TOP w0.356: C1396.1 v1(218.41,127.71)
  BOTTOM w0.203: v3(242.49,128.27) G2.BC23 242.19,128.57
  BOTTOM w0.25: G2.BB20 243.14,126.22 v3(243.24,126.22)
  BOTTOM w0.254: v3(242.49,126.17) 242.19,126.47 G2.BC20 ; G2.BB23 243.13,128.32 v3(243.24,128.32) ; v3(242.49,127.47) G2.BC21 ; v3(243.24,124.12) 243.14,124.12 G2.BB17 ; G2.BB21 243.31,127.17 v3(243.33,127.18) ; G2.BC15 242.19,122.97 v3(242.49,123.27) ; v3(242.49,125.37) G2.BC18 ; v3(242.49,124.07) G2.BC17 ; G2.BB15 243.14,123.22 v3(243.34,123.22)
  BOTTOM w0.356: C1395.1 v1(225.01,127.84) ; C2443.1 229.22,124.14 v1(229.46,123.9) 229.69,124.14 C1394.1 ; C2444.1 v1(224.12,127.84) ; C1407.1 v1(226.3,124.67)
  vias: v1(217.14,127.71) v1(217.77,127.71) v1(219.04,127.71) v1(219.68,127.71) v1(220.31,127.71)
+IFPAB_PLLVDD: length 8
  TOP w0.356: v3(241.79,127.47) 241.88,127.37 C1343.1 241.52,126.83 241.4,126.95 238.86,126.95 v2(238.48,127.33) 238.3,127.16 235.54,127.16 R41.2
  BOTTOM w0.254: G2.BD21 v3(241.79,127.47)
+IFPCD_PLLVDD: length 8
  TOP w0.356: R36.2 236.58,124.84 v2(240.38,124.84) 241.4,124.84 241.47,124.77 C701.1 241.76,125.34 v3(241.79,125.37)
  BOTTOM w0.254: v3(241.79,125.37) G2.BD18
+IFPEF_PLLVDD: length 5.1
  TOP w0.356: R37.2 v2(238.98,122.63) 240,122.63 240.11,122.74 C702.1 241.38,122.74 241.79,123.15 v3(241.79,123.27)
  BOTTOM w0.254: G2.BD15 241.49,122.97 v3(241.79,123.27)
+NVVDDS: length 25.9
  TOP w0.229: C595.1 246.69,130.32 v3(245.99,129.62)
  TOP w0.356: v3(253.79,122.62) v3(253.79,123.32) ; v3(245.99,132.42) 245.99,132.18 245.59,131.78 PC1811.1 245.59,131.65 245.99,131.25 v3(245.99,131.02)
  TOP w0.381: v3(261.54,131.02) 261.54,130.88 C592.1 261.54,129.76 v3(261.54,129.62) ; v3(253.69,132.42) 253.69,132.19 C594.1 ; v3(255.89,131.02) 255.75,131.16 C593.1 255.75,132.28 v3(255.89,132.42)
  IN05 w0.381: v1(208.63,104.47) 213.63,104.47 213.96,104.8 214.9,104.8 215.67,104.04 216.45,104.04 219.43,107.01 v1(220.47,107.01)
  BOTTOM w0.25: G2.AG29 253.69,132.47 v3(253.69,132.42) 253.69,132.37 G2.AG28 G2.AG27
  BOTTOM w0.254: G2.AF24 254.09,129.32 v3(253.79,129.62) 254.09,129.92 G2.AF25 G2.AF26
  BOTTOM w0.381: v1(208.63,104.47) 208.71,104.4 PR3435.2
  vias: v1(216,154.38) v1(216,153.75) v1(216.63,154.38) v1(216.63,153.75) v1(217.27,154.38) v1(217.27,153.75) v1(217.9,154.38) v1(217.9,153.75) v1(220.47,105.74) v1(221.33,107.01) v1(221.33,105.74) v1(222.22,107.01) v1(222.22,105.74) v1(222.98,107.01) v1(222.98,105.74) v1(223.74,107.01) v1(223.74,105.74) v1(224.51,107.01) v1(224.51,105.74) v1(225.17,107.01) v1(225.17,105.74) v1(225.8,107.01) v1(225.93,105.74) v1(226.64,107.01) v1(226.66,105.74) v1(226.79,103.46) v1(226.79,102.7) v1(227.43,107.01) v1(227.43,105.74) v1(228.19,107.01) v1(228.19,105.74) v1(228.95,107.01) v1(228.98,105.74) v1(229.81,107.01) v1(229.84,105.74) v1(230.63,107.01) v1(230.63,105.74) v1(231.62,103.46) v1(231.62,102.57) v1(231.9,107.01) v1(231.9,105.74) v1(232.38,103.46) v1(232.38,102.57) v1(233.14,106.51) v1(233.17,105.74) v1(234.41,106.51) v1(234.44,105.74) v1(235.71,107.01) v1(235.71,105.74) v1(236.62,107.01) v1(236.62,105.74) v1(236.95,104.98) v1(236.95,104.22) v1(236.95,103.46) v1(236.95,102.7) v1(237.36,107.01) v1(237.36,105.74) v1(238.37,107.01) v1(238.37,105.74) v2(224.89,106.38) v3(245.36,140.12) v3(245.99,138.72) v3(245.96,124.72) v3(245.96,123.32) v3(246.01,122.62) v3(248.79,139.42) v3(248.79,138.72) v3(248.79,137.32) v3(248.79,132.42) v3(248.79,131.02) v3(248.79,129.62) v3(248.79,124.72) v3(248.76,123.32) v3(248.79,122.62) v3(251.54,123.32) v3(251.59,139.42) v3(251.59,138.72) v3(251.59,137.32) v3(251.59,133.07) v3(251.59,132.42) v3(251.59,131.02) v3(251.59,129.62) v3(251.59,128.97) v3(251.59,124.72) v3(251.58,122.58) v3(253.64,138.73) v3(253.66,139.43) v3(253.69,137.32) v3(253.79,124.72) v3(255.89,139.42) v3(255.89,138.72) v3(255.89,137.32) v3(255.89,129.62) v3(255.89,124.72) v3(255.89,123.32) v3(255.89,122.62) v3(258.69,139.42) v3(258.72,138.72) v3(258.69,137.32) v3(258.69,132.42) v3(258.69,131.02) v3(258.69,129.62) v3(258.69,124.72) v3(258.69,123.32) v3(258.67,122.63) v3(261.49,139.42) v3(261.52,138.72) v3(261.52,137.32) v3(261.49,132.42) v3(261.49,124.72) v3(261.49,123.32) v3(261.49,122.62)
+PEX_VDD: length 9.4
  TOP w0.356: R1008.2 211.68,156.61 211.68,154.26 212.19,153.75 v1(213.84,153.75)
  BOTTOM w0.254: v3(242.49,137.97) 242.19,137.67 G2.BC36 ; G2.BD33 241.49,135.57 v3(241.79,135.87) ; v3(241.79,137.97) 241.49,137.67 G2.BD36 ; v3(243.24,135.82) 243.14,135.82 G2.BB33 ; v3(242.49,135.87) 242.19,135.57 G2.BC33 ; v3(243.24,136.72) 243.13,136.72 G2.BB35 ; G2.BC35 v3(242.49,136.67) ; G2.BB36 243.14,137.92 v3(243.24,137.92)
  vias: v1(213.84,153.11) v1(213.84,152.48) v1(213.84,151.84) v1(214.47,153.75) v1(214.47,153.11) v1(214.47,152.48) v1(214.47,151.84) v1(217.14,129.75) v1(217.77,129.75) v1(218.41,129.75) v1(219.04,129.75) v1(219.68,129.75) v1(220.31,129.75) v1(222.35,151.21) v1(222.98,151.21) v2(215.23,151.97)
+RTC_VCC: length 2.4
  TOP w0.508: v1(82.22,20.74) 82.09,20.6 R570.2
  BOTTOM w0.508: JRTC1.1 v1(82.22,20.74)
+V_BL_LED:
  vias: v2(191.1,194.9)
+V_CPU_VREF_CA: length 57.2
  IN08 w0.508: v1(151.59,138.45) 151.41,138.45 150.72,139.14 149.83,139.14 149.58,138.89 149.58,135.11 150.41,134.27 150.41,130.33 147.16,127.08 147.16,124.64 162.72,109.08 v1(162.72,94.57)
  BOTTOM w0.254: U1.BN13 151.27,138.77 v1(151.59,138.45)
  BOTTOM w0.457: C172.2 v1(162.72,94.57) R90.1
+V_CPU_VREF_DQ_CHA: length 1.2
  TOP w0.102: TP124.1 150.36,138.51 v1(150.29,138.45)
  BOTTOM w0.254: U1.BP13 150.62,138.77 v1(150.29,138.45)
+V_CPU_VREF_DQ_CHB: length 97
  IN08 w0.508: v1(166.47,59.13) 165.96,59.13 164.69,60.4 164.69,63.5 163.8,64.39 163.8,66.12 162.02,67.9 162.02,73.1 161.39,73.74 161.39,108.77 146.12,124.03 146.12,127.87 149.32,131.07 149.32,133.89 148.77,134.45 147.42,134.45 146.53,135.33 146.53,137.87 147.16,138.51 147.91,138.51 v1(148.11,138.31)
  BOTTOM w0.254: U1.BR13 149.61,138.49 149.1,138.49 148.95,138.64 148.51,138.64 148.18,138.31 v1(148.11,138.31)
  BOTTOM w0.457: R94.1 166.72,58.88 v1(166.47,59.13) 166.34,59.01 C175.2
+V_DIM_VREF_CA_CHA: length 34
  TOP w0.254: JDIMM2.164 173.65,89.31 173.96,89.61 v1(174.4,89.61)
  IN08 w0.508: v1(172.5,94.64) 173.32,93.82 173.32,90.38 174.09,89.61 v1(174.4,89.61) 174.85,89.61 175.48,88.98 175.48,77.42 176.12,76.79 v1(176.44,76.79)
  BOTTOM w0.254: v1(176.44,76.79) 175.93,76.79 175.32,77.4 JDIMM1.164
  BOTTOM w0.457: v1(172.5,94.64) 172.37,94.52 C54.2 C173.2 C37.1 C70.1 R91.2 C38.2 R89.1 164.69,94.52 R90.2
+V_DIM_VREF_CA_CHB: length 32.4
  TOP w0.254: JDIMM4.164 173.85,75.75 173.71,75.9 173.71,76.53 173.45,76.79 v1(172.5,76.79)
  IN08 w0.508: v1(172.5,76.79) 174.34,74.95 174.34,67.64 175.48,66.5 v1(175.48,64.34) 175.48,59.9 176.12,59.26 v1(176.12,59.13)
  BOTTOM w0.254: JDIMM3.164 175.55,64.41 v1(175.48,64.34)
  BOTTOM w0.457: R94.2 168.52,58.8 R93.1 R95.2 C103.2 C176.2 C104.1 C120.2 C136.1 175.79,58.8 v1(176.12,59.13)
+VGA_CORE: length 316.7
  TOP w0.254: PR907.2 283.61,181.05 283.05,180.5 v1(283.05,180.22) ; PR3532.2 v1(283.86,182.88) ; PR1013.2 283.66,186.06 280.95,186.06 280.13,185.25 v1(280.13,184.99) ; PR914.2 283.86,178.44 v1(283.18,177.75) ; PR1006.2 283.48,188.67 279.88,188.67 279.12,187.91 279.12,186.01 v1(278.99,185.88)
  TOP w0.356: C2336.1 262.98,127.61 v3(262.89,127.52)
  TOP w0.381: 263.3,134.52 263.51,134.3 C2392.1 ; 263.3,134.52 v3(262.85,134.52) ; 263.3,134.52 263.51,134.73 C2385.1 ; R1012.2 291.5,172.23 v1(291.31,172.42)
  IN05 w0.381: v1(291.31,172.42) 283.43,172.42 283.08,172.77 283.08,175.24 281.68,176.64 281.68,181.26 279.52,183.42 272.82,183.42
  IN08 w0.254: v1(223.87,189.06) 224,189.18 230.09,189.18 231.36,187.91 245.59,187.91 246.1,187.4 250.67,187.4 251.43,188.17 257.65,188.17 259.18,186.64 278.61,186.64 278.99,186.26 v1(278.99,185.88) ; v1(272.64,189.06) 272.79,189.21 280.11,189.21 281.78,187.53 281.78,184.99 280.26,183.47 280.26,179.78 281.66,178.39 283.21,178.39 283.43,178.16 283.43,178.01 v1(283.18,177.75) ; v1(260.45,189.06) 260.57,189.18 270.1,189.18 271.37,190.45 273.65,190.45 273.91,190.2 281.53,190.2 283.69,188.04 283.69,184.48 282.93,183.72 282.93,180.34 v1(283.05,180.22) ; v1(283.86,182.88) 283.86,183.14 284.32,183.59 285.47,183.59 285.59,183.72 285.59,187.4 281.78,191.21 274.67,191.21 274.29,191.6 269.84,191.6 268.7,190.45 250.29,190.45 249.65,189.82 248.51,189.82 v1(248.38,189.69) ; v1(236.06,189.06) 236.19,189.18 246.35,189.18 246.98,188.55 250.16,188.55 250.92,189.31 258.16,189.31 259.81,187.66 279.5,187.66 280.39,186.77 280.39,185.25 v1(280.13,184.99)
  BOTTOM w0.25: G2.R30 v3(261.49,133.17) ; G2.AC30 v3(255.89,133.17) ; G2.R31 261.79,134.22 v3(261.49,134.52) 261.79,134.81 G2.R32 261.79,134.87 ; G2.W30 v3(258.69,133.17) ; 256.19,134.17 G2.AC31 256.19,134.22 v3(255.89,134.52) 256.19,134.81 G2.AC32 ; G2.AC34 256.19,136.21 v3(255.89,135.92) 256.19,135.62 G2.AC33
  BOTTOM w0.254: v1(223.87,189.06) 218.03,189.06 217.82,188.84 PL1001.2 ; v1(236.06,189.06) 235.94,189.18 230.35,189.18 230.01,188.84 PL1811.2 ; v1(272.64,189.06) 272.51,189.18 267.05,189.18 266.58,188.72 PL902.2 ; v1(260.45,189.06) 260.32,189.18 254.86,189.18 254.39,188.72 PL901.2 ; v1(248.38,189.69) 247.87,189.69 247.49,189.31 242.67,189.31 242.2,188.84 PL1810.2
  BOTTOM w0.356: PR3530.1 277.29,183.72 273.53,183.72 273.02,183.21
  vias: v1(214.47,184.86) v1(214.47,184.1) v1(214.47,183.34) v1(214.47,182.58) v1(215.23,184.86) v1(215.23,184.1) v1(215.23,183.34) v1(215.23,182.58) v1(215.36,181.94) v1(215.74,181.44) v1(216.38,181.44) v1(216.38,172.16) v1(216.76,180.8) v1(217.14,181.44) v1(217.52,180.8) v1(217.52,179.53) v1(217.52,178.77) v1(217.52,178.01) v1(217.52,177.24) v1(217.52,176.61) v1(217.9,181.44) v1(218.28,180.8) v1(218.28,179.53) v1(218.28,178.77) v1(218.28,178.01) v1(218.28,177.24) v1(218.28,176.61) v1(218.66,181.44) v1(218.92,180.8) v1(219.3,181.44) v1(220.06,181.44) v1(220.44,184.86) v1(220.44,184.1) v1(220.44,183.34) v1(220.44,182.58) v1(221.2,184.86) v1(221.2,184.1) v1(221.2,183.34) v1(221.2,182.58) v1(221.97,184.86) v1(221.97,184.1) v1(221.97,183.34) v1(221.97,182.58) v1(222.6,185.63) v1(222.6,184.86) v1(222.6,184.1) v1(222.6,183.34) v1(223.24,185.63) v1(223.24,184.86) v1(223.24,184.1) v1(223.87,185.63) v1(223.87,184.86) v1(223.87,184.1) v1(224.25,160.23) v1(224.25,159.46) v1(224.25,158.7) v1(224.51,185.63) v1(224.51,184.86) v1(224.51,184.1) v1(225.01,160.23) v1(225.01,159.46) v1(225.01,158.7) v1(225.14,184.1) v1(225.65,185.63) v1(225.9,184.74) v1(225.9,183.98) v1(225.9,183.21) v1(226.66,184.74) v1(226.66,183.98) v1(226.66,183.21) v1(226.66,182.45) v1(227.43,184.74) v1(227.43,183.98) v1(227.43,183.21) v1(227.43,182.45) v1(227.81,181.31) v1(228.32,162.51) v1(228.32,161.75) v1(228.32,160.99) v1(228.44,181.31) v1(229.08,181.31) v1(229.08,162.51) v1(229.08,161.75) v1(229.08,160.99) v1(229.48,178.26) v1(229.48,177.63) v1(229.48,176.99) v1(229.48,176.36) v1(229.84,181.31) v1(230.6,181.31) v1(231.36,181.31) v1(231.36,155.02) v1(232,181.31) v1(232.63,184.74) v1(232.63,183.98) v1(232.63,183.21) v1(232.63,182.45) v1(233.4,184.74) v1(233.4,183.98) v1(233.4,183.21) v1(233.4,182.45) v1(234.16,184.74) v1(234.16,183.98) v1(234.16,183.21) v1(234.16,182.45) v1(234.92,184.74) v1(234.92,183.98) v1(234.92,183.34) v1(235.68,184.74) v1(235.68,183.98) v1(235.68,183.34) v1(236.44,184.74) v1(236.44,183.98) v1(236.44,183.34) v1(237.33,184.74) v1(238.09,184.74) v1(238.09,183.98) v1(238.09,183.21) v1(238.86,184.74) v1(238.86,183.98) v1(238.86,183.21) v1(238.86,182.45) v1(239.62,184.74) v1(239.62,183.98) v1(239.62,183.21) v1(239.62,182.45) v1(239.87,181.31) v1(240.51,181.31) v1(241.14,181.31) v1(241.78,181.31) v1(242.41,181.31) v1(243.05,181.31) v1(243.81,181.31) v1(244.83,184.74) v1(244.83,183.98) v1(244.83,183.21) v1(244.83,182.45) v1(245.59,184.74) v1(245.59,183.98) v1(245.59,183.21) v1(245.59,182.45) v1(246.35,184.74) v1(246.35,183.98) v1(246.35,183.21) v1(246.35,182.45) v1(247.24,185.5) v1(247.24,184.74) v1(247.24,183.98) v1(248,185.5) v1(248,184.74) v1(248,183.98) v1(248.76,185.5) v1(248.76,184.74) v1(248.76,183.98) v1(249.52,185.5) v1(249.52,184.74) v1(249.52,183.98) v1(250.29,184.74) v1(250.29,183.98) v1(250.29,183.21) v1(251.05,184.74) v1(251.05,183.98) v1(251.05,183.21) v1(251.81,184.74) v1(251.81,183.98) v1(251.81,183.21) v1(251.81,182.45) v1(252.45,181.31) v1(253.08,181.31) v1(253.72,181.31) v1(254.48,181.31) v1(255.24,181.31) v1(256,181.31) v1(256.64,181.31) v1(257.02,184.74) v1(257.02,183.98) v1(257.02,183.21) v1(257.02,182.45) v1(257.14,181.82) v1(257.4,181.05) v1(257.78,184.74) v1(257.78,183.98) v1(257.78,183.21) v1(257.78,182.45) v1(258.16,181.82) v1(258.16,181.05) v1(258.54,184.74) v1(258.54,183.98) v1(258.54,183.21) v1(258.54,182.45) v1(259.18,184.74) v1(259.18,183.98) v1(259.18,183.21) v1(259.18,182.45) v1(259.94,185.5) v1(259.94,184.74) v1(259.94,183.98) v1(259.94,183.21) v1(260.7,185.5) v1(260.7,184.74) v1(260.7,183.98) v1(260.7,183.21) v1(261.46,185.5) v1(261.46,184.74) v1(261.46,183.98) v1(262.48,184.86) v1(262.48,184.1) v1(262.48,183.34) v1(263.24,184.86) v1(263.24,184.1) v1(263.24,183.34) v1(264,184.86) v1(264,184.1) v1(264,183.34) v1(266.29,181.44) v1(266.29,180.67) v1(267.05,181.44) v1(267.05,180.67) v1(267.81,181.44) v1(267.81,180.67) v1(268.57,180.67) v1(269.08,184.86) v1(269.08,184.1) v1(269.08,183.34) v1(269.08,182.58) v1(269.08,181.82) v1(269.72,181.82) v1(269.84,184.86) v1(269.84,184.1) v1(269.84,183.34) v1(269.84,182.58) v1(270.61,184.86) v1(270.61,184.1) v1(270.61,183.34) v1(270.61,182.58) v1(270.61,181.82) v1(271.37,184.86) v1(271.37,184.1) v1(271.37,183.34) v1(271.37,182.58) v1(272,184.1) v1(272,183.34) v1(272,182.58) v1(272.77,182.58) v2(223.74,168.48) v3(234.67,149.56) v3(235.3,148.8) v3(235.49,146.42) v3(235.68,150.07) v3(235.68,149.3) v3(236.19,148.54) v3(236.32,150.07) v3(236.32,149.3) v3(236.95,149.3) v3(236.95,148.54) v3(236.89,146.42) v3(237.59,147.12) v3(238.29,146.42) v3(238.99,144.32) v3(239.69,145.02) v3(240.39,144.32) v3(241.09,145.02) v3(241.09,142.22) v3(241.09,140.87) v3(241.79,144.32) v3(241.79,142.92) v3(241.78,142.19) v3(241.89,146.47) v3(243.19,142.92) v3(243.17,142.19) v3(243.24,138.82) v3(243.89,145.07) v3(243.89,140.82) v3(244.59,142.92) v3(244.69,143.67) v3(245.33,142.93) v3(245.29,140.82) v3(245.99,135.92) v3(245.99,134.52) v3(245.99,133.17) v3(245.99,128.87) v3(245.98,127.52) v3(245.98,126.12) v3(246.69,140.82) v3(246.84,135.22) v3(247.39,139.42) v3(247.39,138.72) v3(247.39,137.32) v3(247.39,135.92) v3(247.39,134.52) v3(247.39,133.12) v3(247.39,132.42) v3(247.39,131.02) v3(247.39,129.62) v3(247.39,128.92) v3(247.38,127.52) v3(247.38,126.12) v3(247.38,124.72) v3(247.38,123.32) v3(247.39,122.62) v3(248.79,135.92) v3(248.79,134.52) v3(248.79,133.17) v3(248.79,128.87) v3(248.78,127.52) v3(248.78,126.12) v3(250.19,139.42) v3(250.19,138.72) v3(250.19,137.32) v3(250.19,135.92) v3(250.19,135.22) v3(250.19,134.52) v3(250.19,133.12) v3(250.19,132.42) v3(250.19,131.02) v3(250.19,129.62) v3(250.19,128.92) v3(250.18,127.52) v3(250.18,126.12) v3(250.19,124.72) v3(250.19,123.32) v3(250.19,122.62) v3(251.54,135.92) v3(251.54,135.22) v3(251.54,134.52) v3(251.58,127.52) v3(251.58,126.12) v3(252.42,123.32) v3(252.44,122.62) v3(252.99,139.42) v3(252.99,138.72) v3(252.99,137.32) v3(252.99,133.12) v3(252.99,132.42) v3(252.99,131.02) v3(252.99,129.62) v3(252.99,128.92) v3(254.52,139.42) v3(254.52,138.72) v3(254.49,133.12) v3(254.54,132.42) v3(254.54,131.02) v3(254.54,129.62) v3(254.49,128.92) v3(254.49,124.72) v3(254.49,123.32) v3(254.49,122.62) v3(255.89,128.87) v3(255.94,127.52) v3(255.93,126.82) v3(255.94,126.12) v3(257.29,139.42) v3(257.29,138.72) v3(257.29,137.32) v3(257.29,135.92) v3(257.29,134.52) v3(257.29,133.12) v3(257.34,132.42) v3(257.34,131.02) v3(257.29,129.62) v3(257.34,128.92) v3(257.29,127.52) v3(257.29,126.82) v3(257.29,126.12) v3(257.29,124.72) v3(257.29,123.32) v3(257.29,122.62) v3(258.69,135.92) v3(258.69,134.52) v3(258.69,128.87) v3(258.69,127.52) v3(258.69,126.12) v3(260.09,139.42) v3(260.09,138.72) v3(260.09,137.32) v3(260.09,135.92) v3(260.09,134.52) v3(260.09,133.12) v3(260.09,132.42) v3(260.09,131.02) v3(260.09,129.62) v3(260.09,128.92) v3(260.09,127.52) v3(260.09,126.12) v3(260.09,124.72) v3(260.09,123.32) v3(260.09,122.62) v3(260.64,126.82) v3(261.49,135.92) v3(261.49,128.87)
+VID_PLLVDD_GPU_1: length 17.8
  TOP w0.356: C696.1 241.22,120.6 v3(241.79,121.17)
  TOP w0.508: v1(226.66,121.62) 226.59,121.69 R33.2
  IN08 w0.381: v3(241.79,121.17) 241.79,121.12 241.27,120.6 236.95,120.6 236.32,121.24 227.05,121.24 v1(226.66,121.62)
  BOTTOM w0.254: G2.BD12 241.79,121.17 v3(241.79,121.17)
+VID_PLLVDD_GPU_2: length 23.1
  TOP w0.356: v3(242.92,120.87) 242.92,120.83 242.7,120.6 C695.1
  TOP w0.508: R34.2 225.14,122.19 v1(225.14,121.36)
  IN08 w0.381: v3(242.92,120.87) 242.18,120.13 242.18,119.23 241.27,118.32 228.82,118.32 225.78,121.36 v1(225.14,121.36)
  BOTTOM w0.254: v3(242.92,120.87) 242.19,120.87 G2.BC12
+VSTBY0_EC: length 5.2
  BOTTOM w0.356: 31.97,47.4 v2(31.97,47.76) 31.97,49.22 32.27,49.52 U5.A1
  BOTTOM w0.457: R232.2 C238.1 C239.2 31.41,46.84 31.97,47.4
+VTT_REFP: length 2.8
  TOP w0.254: v2(108.81,92.03) 109.24,92.46 PC410.1 110.06,92.22 PU401.4
AC_CHARGED_LED_W: length 144.4
  TOP w0.097: R184.1 v1(4.44,167.77)
  IN08 w0.089: 33.24,58.63 33.88,57.99 35.15,57.99 v2(35.68,57.46)
  IN08 w0.091: v1(4.44,167.77) 5.13,167.77 8.73,164.16 8.73,145.88 14.57,140.03 14.57,133.94 13.69,133.05 13.69,125.77 14.51,124.95 14.51,123.08 19.27,118.32 21.94,118.32 33.24,107.01 33.24,91.01 19.53,77.3 19.53,73.36 23.08,69.8 23.08,67.9 24.35,66.63 24.35,64.98 26.26,63.07 32.1,63.07 33.12,62.06 33.12,58.75 33.24,58.63
  BOTTOM w0.076: 35.53,56.21 35.53,55.67 35.28,55.42 U5.M7
  BOTTOM w0.097: v2(35.68,57.46) 35.53,57.31 35.53,56.21
AC_CHARGING_LED_A: length 144.5
  TOP w0.097: R191.1 v1(6.27,168.43)
  IN08 w0.089: v2(35.28,54.94) 36.04,55.71 36.04,57.99 35.78,58.25 34.13,58.25 33.75,58.63
  IN08 w0.091: 33.75,58.63 33.37,59.01 33.37,62.31 32.35,63.33 26.33,63.33 24.61,65.05 24.61,66.75 23.4,67.96 23.4,70.12 19.78,73.74 19.78,76.91 33.62,90.76 33.62,101.65 34.77,102.8 34.77,106.12 14.96,125.94 14.96,140.06 9.11,145.9 9.11,165.59 v1(6.27,168.43)
  BOTTOM w0.089: U5.K7 v2(35.28,54.94)
AC_PRESENT: length 234.3
  TOP w0.097: R142.1 239.24,48.59 239.62,48.97 v3(240.13,48.97)
  IN05 w0.091: v1(43.4,46.82) 46.58,46.82 47.02,46.37 47.96,46.37 53.21,41.13 53.21,36.76 58.01,31.96 66.26,31.96 68.68,29.54 70.45,29.54 73.25,32.34 76.04,32.34 76.55,32.85 77.93,32.85 78.73,32.04 79.52,32.04 80.07,32.59 86.18,32.59 86.96,33.37 111.12,33.37 111.46,33.71 115.1,33.71 115.54,33.27 118.25,33.27 v1(118.71,33.73)
  IN08 w0.091: v1(118.71,33.73) 118.71,33.99 117.77,34.93 117.77,36.48 119.38,38.09 119.38,40.41 122.65,43.68 142.35,43.68 146.07,39.96 v1(149.58,39.96)
  IN10 w0.091: v3(240.13,48.97) 239.49,48.97 238.86,48.34 237.71,48.34 234.41,45.04 225.65,45.04 225.14,45.55 216.89,45.55 214.85,47.58 214.85,48.59 213.89,49.56 209.47,49.56 208.25,48.34 205.58,48.34 202.03,44.78 153.26,44.78 149.9,41.43 149.9,40.28 v1(149.58,39.96)
  BOTTOM w0.097: U2.BB15 241.24,52.63 241.02,52.4 241.02,49.86 v3(240.13,48.97) ; D5.2 v1(43.4,46.82)
AC_PRESENT_R: length 6.6
  BOTTOM w0.076: U5.C12 37.78,50.91 38.04,50.66 38.42,50.66
  BOTTOM w0.097: 38.42,50.66 39.47,49.61 39.47,48.21 40.23,47.45 v2(40.84,47.45) 41.28,47.45 D5.1
ACDET: length 6.5
  TOP w0.097: PR203.2 PR206.1 79.17,11.69 79.42,11.44 80.74,11.44 80.94,11.64 PC223.1 81.63,11.89 v2(82.32,11.2) 82.52,11 PU201.1
ACOK: length 84.5
  TOP w0.097: PU201.2 82.13,10.6 v3(82.01,10.72)
  IN05 w0.091: v1(29.69,43.26) 30.96,43.26 34.74,39.48 38.48,39.48 39.09,40.08 39.34,40.08 40.23,40.97 46.65,40.97 48.86,38.76 49.17,38.76 50.01,37.93 50.01,34.37 55.65,28.73 56.53,28.73 57.44,27.82 62.65,27.82 64.23,26.24 71.72,26.24 74.39,28.91 v1(79.6,28.91)
  IN08 w0.091: v1(79.6,28.91) 79.54,28.91 79.22,28.59 79.22,18.11 81.12,16.21 81.12,11.61 v3(82.01,10.72)
  BOTTOM w0.097: R245.2 R248.1 v1(29.69,43.26) v2(29.1,43.26)
ACOK_R: length 7.6
  BOTTOM w0.097: R248.2 C71.1 31.41,44.22 v2(32.36,45.17) 33.12,45.93 33.12,47.65 33.62,48.16 33.62,48.85 33.77,49 U5.A4
ADAPTER_ID: length 167.9
  TOP w0.089: v3(30.45,56.47) 30.53,56.39 PC108.1
  TOP w0.097: PQ101.1 80.88,94.07 81.17,94.36 PR107.1 80.54,95.84 78.58,95.84 78.33,95.58 v1(78.33,94.95)
  IN05 w0.091: v2(35.3,52.91) 34.92,52.53 34.64,52.53 33.88,53.29 33.88,55.32 34.39,55.83 37.92,55.83 39.69,54.05 40.86,54.05 41.11,53.81 45.56,53.81 49.64,49.74 52.42,49.74 55.34,46.82 55.34,45.42 57.25,43.51 57.25,41.23 57.88,40.59 58.39,40.59 60.29,42.5 68.17,42.5 69.57,41.1 75.92,41.1 v1(77.06,42.24)
  IN08 w0.089: v2(35.3,52.91) 34.92,52.53 34.5,52.53 33.62,53.41 33.62,56.09 33.24,56.47 v3(30.45,56.47)
  IN08 w0.091: v1(78.33,94.95) 78.07,94.95 76.42,93.3 76.42,91.52 76.04,91.14 76.04,90.35 77.19,89.21 77.19,82.36 76.71,81.89 76.71,79.18 76.26,78.73 75.12,78.73 74.61,78.22 74.61,68.19 77.44,65.36 77.44,50.75 77.06,50.37 v1(77.06,42.24)
  IN10 w0.089: v3(30.45,56.47) 30.2,56.21 30.2,46.69
  IN10 w0.091: 30.2,46.69 30.2,46.05 29.81,45.67 29.31,45.67 29.05,45.42 29.05,40.08 31.08,38.05 31.08,26.75 v1(31.97,25.86)
  BOTTOM w0.089: v2(35.3,52.91) 35.68,52.53 36.16,52.53 U5.F9
  BOTTOM w0.097: JDCIN1.5 30.52,24.65 31.08,24.08 PD101.1 31.55,24.42 31.97,24.84 v1(31.97,25.86)
ADIN_1: length 218.5
  TOP w0.203: v1(79.09,95.33) PR106.1
  TOP w0.356: v1(77.44,13.29) 77.57,13.16 PR203.1
  TOP w0.508: PD201.2 95.42,3.96 95.09,3.64 v1(94.58,3.64)
  IN05 w0.356: v1(77.44,13.29) 77.57,13.41 80.23,13.41 80.74,12.91 80.74,8.08 81.63,7.19 81.63,3.38 80.94,2.7 79.65,2.7 v1(78.71,3.64)
  IN08 w0.203: v1(79.09,95.33) 78.84,95.58 73.88,95.58 71.6,93.3 71.6,81.87 70.96,81.23 70.96,78.44 71.85,77.55 71.85,68.15 72.87,67.14 72.87,61.93 74.39,60.4 74.39,59.13 73.88,58.63 71.22,58.63 70.33,57.74 70.33,54.31 72.36,52.28 72.36,47.83 74.77,45.42 74.77,40.04 72.74,38.01 72.74,25.1 74.92,22.91 74.92,19.66 76.4,18.19 76.4,14.96 76.68,14.68 76.68,14.05 v1(77.44,13.29)
  IN10 w0.508: v1(26,29.04) 25.75,28.78 25.75,23.19 22.19,19.64 22.19,9.86 29.05,3 47.85,3 50.9,6.05 59.79,6.05 62.07,3.76 68.92,3.76 69.94,4.78 71.34,4.78 73.12,3 78.07,3 v1(78.71,3.64) 80.05,3.64 80.3,3.89 81.76,3.89 82.9,5.03 93.19,5.03 v1(94.58,3.64)
  vias: v2(27.15,32.46)
ALL_SYS_PWRGD: length 6.6
  BOTTOM w0.076: 36.53,47.59 36.52,47.6 36.52,50.16 U5.B9
  BOTTOM w0.097: 36.53,47.59 36.53,47.34 v2(36.93,46.93) 37.28,46.59 37.28,45.22 C246.2 R260.1
ALL_SYS_PWRGD_PMIC: length 282.8
  TOP w0.097: v1(41.28,38.69) 41.63,38.69 42.01,39.07 43.15,39.07 44.42,37.8 v2(53.56,37.8) v1(56.48,37.8)
  IN03 w0.091: v1(92.68,38.31) 91.41,38.31 87.73,34.62 87.35,34.62 86.71,33.99 83.03,33.99 78.96,38.05 71.72,38.05 68.13,41.64 61.4,41.64 58.9,44.15 v1(58.14,44.15) ; v1(118.84,195.79) 118.33,195.28 118.33,194.64 117.24,193.55 117.24,191.73 116.94,191.43 116.94,187.4 117.57,186.77 117.57,182.32 119.48,180.42 v1(119.48,176.23)
  IN08 w0.091: v1(92.68,38.31) 92.68,43.71 92.13,44.26 92.13,59.72 94.46,62.06 96.87,62.06 97.51,62.69 97.51,63.58 103.35,69.42 103.35,89.49 106.78,92.92 106.78,94.44 107.41,95.08 107.41,95.84 121.64,110.06 138.91,110.06 142.97,114.13 142.97,132.29 140.11,135.14 140.11,138.83 138.15,140.8 138.15,147.78 137.13,148.8 137.13,150.07 v1(137.89,150.83)
  IN10 w0.091: v1(137.89,150.83) 137,150.83 136.62,150.45 134.59,150.45 133.95,151.08 133.95,156.54 133.32,157.18 128.49,157.18 127.1,158.58 127.1,168.61 v1(119.48,176.23) ; v1(56.48,37.8) 55.47,38.81 55.47,41.74 57.88,44.15 v1(58.14,44.15)
  BOTTOM w0.097: R843.1 54.5,48.09 56.74,48.09 58.14,46.69 v1(58.14,44.15) ; v1(118.84,195.79) 119.22,195.41 PR1242.2 ; R538.2 R56.1 41.8,38.99 41.5,38.69 v1(41.28,38.69)
ALL_SYS_PWRGD_PMIC_R: length 2.7
  BOTTOM w0.097: R300.2 43.66,39.32 42.72,40.26 R538.1 42.83,40.45 U61.4
ALW_B+:
  vias: v1(45.05,26.24) v1(45.05,25.61) v1(45.69,26.24) v1(45.69,25.61) v1(46.32,26.24) v1(46.32,25.61) v1(47.85,27.89) v1(47.85,27.13) v1(48.61,27.89) v1(48.61,27.26) v1(49.37,27.89) v1(49.37,27.26) v2(39.47,24.21)
AMON: length 80.8
  TOP w0.097: v3(77.95,9.39) 78.11,9.22 79.04,9.22 PC218.2 PR213.1
  IN05 w0.091: v1(77.06,34.5) 76.3,35.26 61.18,35.26 59.66,33.73 58.76,33.73 54.95,37.55 54.95,42.38 52.8,44.53 52.8,46.31 51.4,47.7 48.67,47.7 47.78,48.59 45.82,48.59 43.86,50.54 42.98,50.54 42.01,51.51 v2(40.99,51.51)
  IN08 w0.091: v3(77.95,9.39) 77.85,9.49 77.85,12.48 78.33,12.96 78.33,14.05 77.9,14.48 77.9,14.94 76.8,16.03 76.8,18.95 76.04,19.71 76.04,31.96 77.06,32.97 v1(77.06,34.5)
  BOTTOM w0.097: v2(40.99,51.51) 40.27,51.51 39.93,51.86 39.51,51.86 38.95,52.41 U5.F13
AMP_GAIN/FSW: length 3.5
  TOP w0.097: R328.1 266.36,32.59 R325.2 266.45,32.67 266.95,32.67 267.51,33.23 267.51,33.35 267.61,33.45 U8.9
AMP_MONO: length 2.8
  TOP w0.254: U9.14 280.8,45.77 281.02,45.55 v1(281.02,44.91)
  BOTTOM w0.254: R335.2 281.32,45.22 v1(281.02,44.91)
AMP_PD_N_R: length 44.3
  TOP w0.097: v1(272.38,52.66) 273.43,53.7 276.35,53.7 277.08,54.44 R330.2 ; R338.1 280.56,26.29 v1(280.26,25.99) 280,25.99 279.72,26.27 D19.2 278.86,26.27 278.75,26.17 R323.1 277.92,26.17 277.13,26.95 U8.27
  IN10 w0.091: v1(272.38,52.66) 272.38,51.51 274.54,49.36 274.54,43.39 273.4,42.24 273.4,39.7 275.05,38.05 277.97,38.05 279.62,36.4 279.62,32.46 280.51,31.58 280.51,29.16 279.62,28.27 279.62,26.62 v1(280.26,25.99)
AMP_SPK_L+: length 6.3
  TOP w0.254: 277.34,35.95 U8.45
  TOP w0.508: R68.2 v2(279.62,37.62) 279.62,36.22 278.99,35.59 C354.1 277.97,35.59 277.61,35.95 277.34,35.95
AMP_SPK_L-: length 5.2
  TOP w0.254: 277.54,36.83 277.42,36.95 U8.47
  TOP w0.508: R69.2 278.35,38.43 278.89,37.9 278.89,36.71 278.63,36.45 C353.1 278.02,36.45 277.64,36.83 277.54,36.83
AMP_SPK_R+: length 2.5
  TOP w0.254: 267.13,35.97 267.14,35.95 U8.4
  TOP w0.508: 267.13,35.97 266.62,36.48 C351.1
  vias: v2(265.12,37.52)
AMP_SPK_R-: length 1.2
  TOP w0.254: 267.31,36.95 U8.2
  TOP w0.508: 267.3,36.96 267.31,36.95
  vias: v2(266.8,37.52)
APDIN:
  vias: v1(24.81,19.13) v1(24.86,17.86) v1(24.86,16.59) v1(24.86,15.32) v1(24.86,14.43) v1(25.7,19.13) v1(26.13,15.32) v1(26.13,14.43) v1(27.4,15.32) v1(27.4,14.43) v1(28.67,17.86) v1(28.67,15.32) v1(29.94,17.86) v1(29.94,15.32) v1(31.21,19.13) v1(31.21,18.11) v1(31.21,17.22) v1(31.21,16.34) v1(31.21,15.32) v1(32.1,19.13) v1(32.1,18.11) v1(32.1,17.22) v1(32.1,16.34) v1(32.1,15.32) v2(25.88,16.97) v2(28.93,16.46) v2(30.2,19.51)
AR_HOLD_RST_N: length 49.2
  IN10 w0.089: v2(38.2,48.34) 38.7,48.85 38.7,49.1 38.32,49.48 33.12,49.48 31.97,50.63 31.97,54.18 33.88,56.09 36.67,56.09 37.43,56.85 37.43,58.63 ; 35.81,80.72 36.67,79.86 36.67,73.23 37.31,72.6 37.31,68.91
  IN10 w0.091: 37.31,68.91 37.31,66.25 37.69,65.87 37.69,63.96 37.43,63.71 37.43,58.63 ; v1(34.39,82.15) 35.81,80.72
  BOTTOM w0.076: U5.B12 38.02,50.16 38.02,49.8
  BOTTOM w0.097: v1(34.39,82.15) 35.35,81.18 R2103.1 ; 38.02,49.8 38.58,49.25 38.58,48.72 v2(38.2,48.34)
ASGATE: length 2.5
  TOP w0.254: 83.79,12.78 84.04,12.78 84.59,12.24 PU201.30
  TOP w0.356: PR202.2 83.28,13.29 83.79,12.78
AUD_AZACPU_SCLK: length 6.8
  TOP w0.097: v2(190.09,150.57) 190.6,150.57 v1(190.72,150.45) 190.8,150.37 R2291.1
  IN08 w0.091: v1(190.72,150.45) 190.47,150.45 190.34,150.32 186.99,150.32 v1(186.37,149.7)
  BOTTOM w0.097: U1.G27 186.37,149.77 v1(186.37,149.7)
AUD_AZACPU_SDO: length 1.4
  TOP w0.097: R2292.1 185.86,149.05 v1(185.72,148.91)
  BOTTOM w0.102: U1.G25 186.05,148.59 v1(185.72,148.91)
B+: length 41.8
  TOP w0.203: v1(80.61,18.49) 80.49,18.37 80.49,17.92 PR232.2
  TOP w0.254: v1(48.86,29.67) 48.86,30 49.39,30.52 PR201.2
  IN03 w0.254: v1(80.61,18.49) 80.49,18.62 80.49,19.64 78.84,21.29 75.69,21.29 69.22,27.77 57.88,27.77 56.1,29.54 50.39,29.54 49.88,29.04 48.86,29.04 48.74,29.16 48.74,29.54 v1(48.86,29.67)
  vias: v1(85.44,69.29) v1(85.57,69.93) v1(85.69,70.56) v1(85.82,71.2) v1(86.08,69.29) v1(86.2,69.93) v1(86.33,70.56) v1(86.46,71.2) v1(86.71,71.83) v1(89.38,32.46) v1(89.38,31.32) v1(90.01,32.46) v1(90.01,31.32) v1(91.79,32.46) v1(91.79,31.32) v1(92.43,32.46) v1(92.43,31.32) v1(93.95,35.64) v1(93.95,34.75) v1(94.58,32.46) v1(94.71,35.64) v1(94.71,34.75) v1(95.22,35.26) v1(138.02,188.04) v1(139.03,188.04) v1(139.41,186.77) v1(140.3,188.04) v1(140.68,186.77) v1(140.68,185.5) v1(141.57,188.04) v1(141.95,186.77) v1(141.95,185.5) v1(142.84,188.04) v1(143.22,186.77) v1(143.22,185.5) v1(143.99,188.04) v1(144.5,186.77) v1(144.5,185.5) v1(145,188.04) v1(145.51,186.77) v1(145.51,185.5) v1(145.51,42.88) v1(145.51,42.24) v1(146.15,42.88) v1(146.15,42.24) v1(146.91,42.88) v1(146.91,42.24) v1(147.54,42.88) v1(147.54,42.24) v1(150.59,205.18) v1(150.59,204.17) v1(150.59,203.15) v1(151.86,205.18) v1(151.86,204.17) v1(151.86,203.15) v1(153.13,205.18) v1(153.13,204.17) v1(153.13,203.15) v1(154.4,205.18) v1(154.4,204.17) v1(154.4,203.15) v1(155.67,205.18) v1(155.67,204.17) v1(155.67,203.15) v1(156.94,205.18) v1(156.94,204.17) v1(156.94,203.15) v1(158.21,205.18) v1(158.21,204.17) v1(158.21,203.15) v1(165.32,205.06) v1(165.96,205.06) v1(165.96,204.3) v1(165.96,203.53) v1(166.59,205.06) v1(166.59,204.3) v1(166.59,203.53) v1(167.23,205.06) v1(167.23,204.3) v1(167.23,203.53) v1(167.86,205.06) v1(167.86,204.3) v1(167.86,203.53) v1(168.5,205.06) v1(168.5,204.3) v1(168.5,203.53) v1(178.15,195.15) v1(178.79,195.15) v1(179.7,194.95) v1(217.65,84.79) v1(218.28,84.79) v1(218.92,84.79) v1(219.55,84.79) v1(255.37,44.91) v1(255.37,44.28) v1(256.13,44.91) v1(256.13,44.28) v1(256.89,44.91) v1(256.89,44.28) v2(106.9,121.75) v2(111.86,110.57)
B+_1.0VG:
  vias: v1(213.71,168.74) v1(213.84,169.37) v2(213.25,169.68)
B+_1.05VP:
  vias: v2(259.4,42.8)
B+_1.8VP:
  vias: v1(118.84,136.73) v1(119.6,136.73) v2(121.2,136.73)
