# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCF135_1P0: length 0.5
  BOTTOM w0.305: v3(239.49,65.92) 239.42,65.99 U2.R19
  vias: v2(243.5,67.26)
+VCCFHV_2P8: length 20.2
  IN08 w0.356: v1(253.33,64.21) 251.81,62.69 248.25,62.69 247.49,61.93 247.49,61.29 246.6,60.4 244.56,60.4 244.54,60.43 243.46,60.43 243.44,60.4 240.76,60.4 240.38,60.02 240.38,59.26 240.1,58.98 237.79,58.98 v3(237.59,58.78)
  BOTTOM w0.254: v3(237.59,58.78) 237.87,58.49 U2.AL22
  BOTTOM w0.457: R204.2 v1(253.33,64.21)
+VCCIO: length 122.3
  TOP w0.508: v1(184.29,149.71) 184.29,149.01 185.01,148.29 185.01,146.13 185.39,145.75
  IN03 w0.508: v1(135.91,158.42) 136.24,158.09 136.24,149.3 137.64,147.91 137.64,140.92 136.11,139.4 131.16,139.4 130.65,138.89 v1(130.65,138)
  IN08 w0.508: v1(196.57,131.27) 198.17,132.88 198.17,148.37 200.25,150.45 200.25,153.62 199.99,153.88 v1(199.99,162.51)
  BOTTOM w0.097: U1.J17 185.01,141.91 ; U1.J17 184.38,141.91 ; U1.J17 184.38,142.53 ; U1.J17 185.01,142.53 ; 184.7,140.26 184.69,140.27 U1.J15 ; 185.03,141.12 U1.H16 ; U1.H16 185.66,141.74 ; U1.H16 185.03,141.74 ; U1.H16 185.66,141.12 ; U1.H15 185.66,140.33 ; U1.H15 185.66,140.96 ; U1.H15 185.03,140.33 ; U1.H15 185.03,140.96 ; 185.03,142.53 U1.H17 ; U1.H17 185.66,141.91 ; U1.H17 185.03,141.91 ; U1.H17 185.66,142.53 ; 185.76,142.5 U1.G17 185.76,141.94 ; U1.J16 185.01,141.12 ; U1.J16 184.38,141.12 ; U1.J16 184.38,141.74 ; U1.J16 185.01,141.74 ; U1.J15 184.38,140.96 ; U1.J15 185.01,140.96 ; U1.J15 185.01,140.33 ; U1.J15 184.54,140.49 184.35,140.49 ; 185.76,140.93 U1.G15 185.76,140.36
  BOTTOM w0.127: U1.J20 185.01,144.27 ; U1.J20 184.38,144.27 ; U1.J20 184.38,144.89 ; U1.J20 185.01,144.89 ; 185.03,143.48 U1.H19 ; U1.H19 185.66,144.11 ; U1.H19 185.66,143.48 ; U1.H19 185.03,144.11 ; U1.J21 185.01,145.68 ; U1.J21 184.38,145.68 ; U1.J21 185.01,145.06 ; U1.J21 184.38,145.06 ; 185.03,150.41 U1.H27 185.03,149.78 ; U1.J26 185.01,149.62 ; U1.J26 184.38,149.62 ; U1.J26 184.38,149 ; U1.J26 185.01,149 ; 185.76,144.08 U1.G19 185.76,143.51 ; U1.H20 185.66,144.27 ; U1.H20 185.03,144.89 ; U1.H20 185.03,144.27 ; U1.H20 185.66,144.89 ; 185.03,145.68 U1.H21 ; U1.H21 185.66,145.68 ; U1.H21 185.03,145.06 ; U1.H21 185.66,145.06 ; 184.38,149.78 U1.J27 ; U1.J27 184.38,150.41 ; U1.J27 185.01,149.78 ; U1.J27 185.01,150.41 ; 185.76,145.65 U1.G21 185.76,145.09 ; U1.J19 185.01,144.11 ; U1.J19 184.38,143.48 ; U1.J19 184.38,144.11 ; U1.J19 185.01,143.48 ; 185.03,149.62 U1.H26 185.03,149
  BOTTOM w0.203: PR1201.2 135.43,157.94 v1(135.91,158.42)
  BOTTOM w0.254: v1(171.28,138.28) 171.17,138.28 170.88,137.98 U1.AG12
  BOTTOM w0.457: v1(196.57,131.27) 196.44,131.27 192.17,127 R1.1
  BOTTOM w0.508: C311.2 202.66,162.35 202.66,160.61 198.47,156.42 195.17,156.42 191.23,160.35 R2.2
  vias: v1(127.48,138) v1(127.48,137.24) v1(127.48,136.48) v1(127.48,135.72) v1(127.48,134.95) v1(128.37,138) v1(128.37,137.24) v1(128.37,136.48) v1(128.37,135.72) v1(128.37,134.95) v1(129.13,138) v1(129.13,137.24) v1(129.13,136.48) v1(129.13,135.72) v1(129.13,134.95) v1(129.89,138) v1(129.89,137.24) v1(129.89,136.48) v1(129.89,135.72) v1(129.89,134.95) v1(130.65,137.24) v1(130.65,136.48) v1(130.65,135.72) v1(130.65,134.95) v1(184.1,145.37) v1(184.14,144.58) v1(184.13,143.79) v1(184.1,142.22) v1(184.1,141.43) v1(184.1,140.8) v1(203.8,163.4) v1(203.8,162.77) v1(203.8,162.13) v1(204.44,163.4) v1(204.44,162.77) v1(204.44,162.13) v1(205.07,163.4) v1(205.07,162.77) v1(205.07,162.13) v1(205.07,161.5) v2(127.48,138.64)
+VCCMPHY_1P0:
  vias: v2(240.38,76.15) v3(235.3,64.85) v3(235.99,66.17) v3(236.06,64.85) v3(237.33,65.92) v3(238.37,65.92)
+VCCPDSW_3P3: length 2.4
  BOTTOM w0.203: v3(235.94,53.67) 236.11,53.67 U2.BA24
  BOTTOM w0.508: R206.1 238.86,44.78 v1(238.09,44.02)
+VCCPFUSE_3P3:
  vias: v2(249.6,49.41)
+VCCPHVC_3P3: length 0.9
  BOTTOM w0.254: v3(245.59,57.74) 245.99,57.33 U2.AN5
  vias: v2(247.14,58.12)
+VCCPRIM_1P0: length 10.5
  BOTTOM w0.254: v3(239.11,59.52) 239.11,59.44 U2.AJ20 ; U2.AC23 v3(237.59,62.56) 237.21,62.94 U2.AA23 237.22,62.96 v3(237.59,63.33) 237.21,63.71 U2.Y23 237.56,64.09 v3(237.59,64.09) ; U2.AA28 235.25,63.33 v3(235.3,63.33) 235.43,63.2 235.43,63.19 U2.AA26 ; U2.AA28 235.27,62.56 v3(235.3,62.56) 235.3,62.54 U2.AC26 ; U2.AA28 234.54,63.3 v3(234.54,63.33) ; U2.AA28 234.54,62.61 v3(234.54,62.56) 234.54,62.53 U2.AC28 ; U2.AJ23 237.21,59.13 v3(237.59,59.52) 237.98,59.12 U2.AJ21 ; U2.Y25 v3(236.04,64.12) ; v3(235.3,61.04) 235.66,61.4 U2.AE26 ; U2.AJ25 235.97,58.63 v3(235.94,58.63) ; v3(237.59,61.04) 237.59,61.03 U2.AE23
  vias: v1(268.07,67.14) v1(268.07,65.74) v1(268.7,67.14) v1(268.7,65.74) v1(269.34,67.14) v1(269.34,65.74) v1(269.97,67.14) v1(269.97,65.74) v1(270.61,67.14) v1(270.61,65.74)
+VCCPRTC_3P3: length 1.1
  BOTTOM w0.254: v3(237.18,54.03) 237.33,53.88 237.33,53.79 U2.BA22
  vias: v2(236.49,53.7)
+VCCPRTCPRIM_3P3: length 14.4
  TOP w0.356: C226.1 C227.2 237.97,52.91 v3(238.48,53.42)
  IN05 w0.254: v3(238.48,53.42) 238.35,53.55 236.82,53.55 236.57,53.29 236.57,52.02 236.19,51.64 236.19,50.37 236.39,50.17 236.39,49.53 238.09,47.83 238.09,46.36 238.73,45.72 v1(238.73,45.47)
  BOTTOM w0.254: U2.BA20 238.6,53.3 v3(238.48,53.42)
  BOTTOM w0.457: v1(238.73,45.47) 239.19,45.93 R222.2
+VCCPUSBDSW_3P3: length 0.8
  BOTTOM w0.305: U2.W15 241.01,63.81 240.63,63.43 v3(240.63,63.33)
  vias: v1(251.68,64.21) v2(248.69,64.34)
+VCCSA: length 13.7
  TOP w0.305: C934.1 182.82,153.02 v1(183.01,153.22)
  BOTTOM w0.203: U1.K30 184.19,152.19 184.19,152.89 U1.K31 184.07,153.02 184,153.02 v1(183.8,153.22) ; 182.62,153.54 U1.M32 ; v1(183.01,153.22) 183.08,153.22 U1.L32 ; U1.M29 182.62,150.93 v1(182.57,150.89)
  BOTTOM w0.254: U1.M30 U1.M29 ; U1.M35 182.94,155.17 v1(183.01,155.17) 183.08,155.17 U1.L35 ; 182.94,154.52 U1.M34 ; 182.94,154.52 v1(183.01,154.52) ; 182.94,154.52 182.94,154.52 U1.M33 ; U1.L36 183.08,155.82 v1(183.01,155.82) 182.94,155.82 U1.M36 ; U1.K30 U1.K29 184.44,151.54 U1.J30 ; 184.52,155.17 v1(184.59,155.17) ; 184.52,155.17 U1.K35 ; 184.52,155.17 U1.K34 ; v1(183.01,153.22) 183.34,152.89 U1.L31 ; 184.52,153.87 U1.K33 ; 184.52,153.87 U1.K32 ; 184.52,153.87 v1(184.59,153.87) ; PR1172.1 183.23,161.5 v1(183.36,161.62) ; v1(183.01,153.87) 182.94,153.87 182.62,153.54 ; 183.08,157.12 U1.L38 ; 183.08,157.12 v1(183.01,157.12) ; 183.08,157.12 U1.L37
  BOTTOM w0.305: U1.M31 182.69,152.89 v1(183.01,153.22)
  vias: v1(202.03,175.34) v1(202.03,174.58) v1(202.03,173.69) v1(202.03,172.8) v1(202.03,171.91) v1(204.19,172.67) v1(204.19,171.66) v1(204.19,170.77) v1(204.19,169.88) v1(204.19,168.99) v1(206.6,175.34) v1(206.6,174.58) v1(206.6,173.69) v1(206.6,172.8) v1(206.6,171.91) v2(203.93,174.07)
+VCCSFR_OC: length 2.6
  TOP w0.305: C950.2 154.68,138.47 v1(154.82,138.33)
  TOP w0.381: C951.2 186.38,137.11 v1(186.37,137.1)
  BOTTOM w0.203: U1.BH13 154.5,138.63 v1(154.82,138.33)
  BOTTOM w0.305: v1(186.37,137.1) 186.05,137.43 U1.G11
  vias: v1(197.58,134.06) v1(197.58,133.3) v2(199.23,133.05)
+VCCVDDQ_CLK: length 1.3
  TOP w0.356: C949.1 177.03,137.95 v1(176.77,137.69)
  BOTTOM w0.254: v1(176.77,137.69) 176.48,137.98 U1.Y12
+VDD33_LAN: length 7.8
  TOP w0.203: 48.93,65.93 48.76,65.76 U6.1
  TOP w0.356: R282.2 v1(48.48,69.8)
  TOP w0.381: Q35.2 52.67,73.23 v2(52.85,73.05) 53.23,72.67 R477.2 53.23,71 52.42,70.18 v1(52.42,69.93) ; v1(49.25,66.25) 48.93,65.93
  TOP w0.457: v1(52.42,69.93) 52.52,69.83 R275.1
AGND: length 61.3
  TOP w0.203: U7.30 291.61,31.41 292.07,31.41 292.32,31.15 292.32,30.05 v1(292.45,29.92) ; U7.42 291.97,36.21 292.32,36.56 292.32,37.42 v1(292.83,37.93) ; v1(287.47,28.09) 287.27,28.3 287.27,29.08 287.53,29.35 U7.20
  TOP w0.254: v1(299.03,35.18) 299.14,35.18 299.69,34.62 299.69,30.43 299.18,29.92 299.18,28.15 v1(299.2,28.12) 299.2,26.39 v2(298.97,26.15) 298.67,25.86 297.53,25.86 v1(297.02,26.37) 297.02,30.81 298.03,31.82 298.03,33.36 297.54,33.85 v1(297.51,33.85)
  TOP w0.356: v1(294.86,28.53) 294.56,28.83 C315.2 ; C317.2 v1(294.18,27.33) ; v1(299.03,35.18) 299.01,35.18 v1(297.66,36.53) 296.07,36.53 J3.2 295.56,36.85 295.24,36.53 v1(295.12,36.53)
  TOP w0.457: v1(292.83,37.93) 293.11,38.2 C307.2 C306.1 293.11,40.19 292.88,40.41 291.54,40.41 291.33,40.21 C309.2 ; R315.2 290.82,26.32 v1(290.55,26.59) 290.32,26.59 C301.1 C300.1
  IN03 w0.254: v1(299.03,35.18) 299.01,35.18 v1(297.66,36.53) v1(295.12,36.53)
  BOTTOM w0.254: v1(294.86,24.46) 295.9,25.5 299.54,25.5 299.72,25.32 JIO1.70 ; JIO1.63 v1(299.2,28.12) ; JIO1.73 298.46,24.12 v1(297.15,22.81) ; v1(299.44,22.81) 299.55,22.92 JIO1.76
  BOTTOM w0.356: R317.2 v1(294.86,24.46)
  BOTTOM w0.457: v1(290.55,26.59) 290.27,26.59 C327.1 C326.1
  BOTTOM w0.508: v1(297.66,36.53) 297.63,36.5 R316.2
  vias: v1(291.43,30.43) v2(294.74,29.42)
GND: length 3574
  TOP w0.089: 29.43,80.72 C2139.2
  TOP w0.152: C701.2 242.89,125.1 242.89,125.19 242.89,125.2 242.89,125.54 242.89,125.54 v3(242.89,125.77)
  TOP w0.178: C1343.2 242.89,127.03 242.89,127.26 242.9,127.28 242.9,127.66 242.89,127.68 v3(242.89,127.87)
  TOP w0.203: D60.1 14.69,82.44 v1(14.78,82.35) ; C1020.2 173.72,138 v1(174.03,137.69) ; C619.2 250.59,140.86 v3(250.59,141.87) ; v1(14.4,75.9) 14.05,76.24 D67.1 ; v1(138.34,85.8) 138.27,85.87 138.27,86.43 138.15,86.55 JDIMM2.30 ; v1(26.26,80.22) 26.26,80.09 26.67,79.68 U2011.3 ; C2093.2 46.34,85.97 46.69,86.33 v2(46.69,86.36) ; v3(256.89,141.87) 256.89,141.15 C2357.2 ; v1(179.51,137.69) 179.74,137.69 180.34,138.29 C1013.2 ; v1(46.96,61.42) 47.56,60.82 U6.27 ; D66.1 14.97,78 v1(15.11,78.13) ; v1(13.51,83.75) 14.14,83.75 D61.1
  TOP w0.254: JDIMM4.65 v1(147.1,64.6) 146.65,64.6 146.1,65.15 JDIMM4.61 ; v1(149.64,142.38) 149.64,142.01 149.12,141.48 R26.1 ; C1007.2 172.95,150.33 173.61,150.99 v1(173.61,151.01) ; 275.05,28.15 275.25,27.95 U8.29 ; v3(239.69,121.87) 239.69,121.64 R2208.2 ; v1(206.01,154.51) 206.02,154.52 206.02,155.13 PU1252.6 ; C2558.2 289,157.04 v3(288.9,156.94) ; v1(178.81,147.78) 179.06,148.03 C1086.1 ; v1(178.81,147.78) 178.56,148.03 C1088.1 ; v1(178.81,147.78) 178.51,147.48 C1089.1 178.28,146.93 C1059.1 ; v1(178.81,147.78) 179.12,147.48 C1087.1 179.38,147.44 C1061.1 ; R1021.1 263.8,144.11 v3(263.42,144.48) ; v1(271.75,9.1) 271.75,9.48 U24.A1 ; C1150.1 173.84,142.1 v1(174.06,142.32) ; Q85.4 v1(289.39,173.44) ; C2468.2 239.99,173.06 v3(240.08,173.15) ; v1(301.85,75.26) 301.98,75.26 302.47,75.76 U62.3 ; JDP1.5 v1(11.64,154.8) ; C2109.2 46.65,82.55 v2(46.72,82.48) ; v1(83.03,93.04) 82.76,92.77 PQ101.4 ; v1(302.36,77.93) 302.11,78.18 Q86.1 ; v1(292.32,76.41) 292.32,76.15 292.44,76.03 Q97.4 ; v2(46.67,84.43) 46.49,84.43 C2094.2 ; v1(110.97,90) 111.26,90.29 PU401.1 ; JDIMM4.181 178.1,65.05 177.64,64.6 v1(177.52,64.6) ; 273.02,10.72 U24.B1 v1(273.02,9.1) ; C2222.2 v1(299.18,77.68) ; C2562.2 290.86,145.38 v3(290.5,145.74) ; v1(300.96,172.16) 301.16,172.36 PU1610.3 ; PU605.12 78.08,48.6 v1(78,48.52) ; R2300.1 205.91,198.07 v1(205.81,198.07) 205.84,198.1 205.84,199.12 Q5.1 ; C220.2 240.68,62.82 240.38,62.82 v3(239.87,63.33) ; R2166.2 221.91,117.43 v1(221.66,117.17) ; R2206.2 293.71,112.17 v3(293.82,112.29) ; v1(11.65,162.09) 11.95,161.8 JDP1.19 ; R992.1 243.76,100.46 243.56,100.66 243.56,101.63 243.86,101.93 244.32,101.93 244.58,102.2 Q76.4 244.58,102.7 244.7,102.82 245.46,102.82 245.58,102.94 Q76.1 245.58,103.86 245.87,104.14 v1(245.87,105.24) 245.41,105.24 R989.1 ; C979.2 175.86,147.17 C1055.1 175.59,147.48 v1(175.28,147.78) ; v1(172.78,152.57) 172.82,152.53 C1151.1 ; v3(296.23,135.92) 295.52,136.63 C2564.2 ; JDIMM4.31 138.6,67.34 139.92,68.66 140.44,68.66 v1(140.57,68.79) ; C2484.2 250.23,177.83 v3(250.91,177.15) ; JDIMM4.19 135.6,65.23 134.97,64.6 v1(134.6,64.6) JDIMM4.15 ; v3(237.57,123.55) 237.21,123.9 R923.2 ; JDIMM4.247 v1(194.6,64.6) ; v1(194.6,64.6) 193.77,64.6 193.6,64.77 JDIMM4.243 ; v1(194.6,64.6) 194.94,64.6 195.6,65.26 JDIMM4.251 ; JDIMM4.9 v1(133.1,64.6) ; v1(11.53,147.78) 11.53,146.94 R2311.1 ; v1(291.56,79.2) 291.56,77.17 Q97.1 ; v3(236.88,173.15) 236.88,172.55 236.7,172.38 C2470.2 ; U8.3 269.77,36.45 269.84,36.53 ; JDIMM4.192 180.85,75.74 v1(181.39,76.28) ; C1134.1 175.03,148.03 v1(175.28,147.78) ; v2(49.27,85.08) 49.23,85.08 49.02,84.86 49.02,84.84 48.85,84.67 C2108.2 48.85,84.34 48.66,84.15 C2112.2 ; C1144.1 174.39,142.65 v1(174.06,142.32) ; Q90.1 294.24,173.81 294.48,173.56 v1(294.48,173.31) 294.48,173.05 294.73,172.81 Q90.4 ; JDIMM4.223 188.6,64.92 188.28,64.6 v1(188.05,64.6) ; U19.E5 U19.F5 71.1,9.74 v2(71.22,9.86) 71.6,9.48 U19.G5 U19.H5 ; v3(236.08,169.15) 236.24,169.31 C2467.2 ; v1(108.25,91.82) 108.2,91.88 107.69,91.88 PR413.2 ; JDIMM4.205 v1(184.1,64.6) 183.74,64.6 183.1,65.23 JDIMM4.201 ; Q94.1 301.73,83.76 v1(301.59,83.9) 301.42,83.72 C2680.2 ; v2(53.17,88.98) 52.71,89.45 C2081.2 ; v3(232.88,177.95) 232.4,177.48 C2455.2 C2449.2 ; Q91.1 296.39,73.1 v1(296.64,72.85) ; v1(179.74,76.28) 179.85,76.17 JDIMM4.188 ; v3(279.38,172.2) 280.15,172.97 C2533.2 ; C1368.2 75.03,3.99 v1(74.67,3.64) ; R2302.1 205.48,193.27 v1(205.46,193.25) ; v3(244.32,166.35) 244.5,166.17 C2461.2 ; R2196.2 269.45,170.68 v3(269.53,170.75) ; v3(297.83,128.72) 298.81,127.74 C2572.2 ; 274.92,36.4 274.98,36.45 U8.46 ; R994.1 v1(67.15,75.77) ; v3(292.23,113.88) 292.23,114.65 C2615.2 ; v3(240.49,119.17) 240.83,118.82 R921.2 ; v2(49.92,83.13) 49.83,83.23 C2107.2 ; JDIMM4.185 179.1,65.17 179.67,64.6 v1(180.1,64.6) JDIMM4.189 ; U8.10 269.82,32.95 v1(269.84,32.97) ; C2552.2 294.07,157.37 293.64,156.94 v3(292.9,156.94) ; C2545.2 289.55,145.09 v3(288.9,145.74) ; v3(15.08,157.18) D2019.3 D2019.8 ; v1(269.84,30.43) 269.82,30.45 U8.15 ; C1008.2 173.84,150.77 v1(173.61,151.01) ; C2498.2 258.07,177.18 v3(258.11,177.15) ; v1(174.06,142.32) 173.72,142.66 C1147.1 ; v1(174.06,142.32) 174.29,142.09 C1145.1 ; v1(303.37,55.45) 302.86,55.97 Q98.1 ; v3(260.51,170.75) 260.53,170.72 R2200.2 ; v1(175.28,147.78) 174.98,147.48 C1135.1 174.72,146.93 C1058.1 ; v1(175.28,147.78) 175.54,148.03 C1054.1 ; v3(235.28,166.75) 235.32,166.79 C2471.2 ; D2018.8 D2018.3 v3(15.13,153.78) ; JDIMM4.103 156.6,65.06 157.07,64.6 v1(157.32,64.6) 157.6,64.87 JDIMM4.107 ; R2054.2 56.56,88.04 56.2,87.68 v2(55.12,87.68) ; v2(71.22,8.33) 71.6,8.72 U19.G4 U19.F4 ; C2482.2 262.25,177.81 v3(262.11,177.95) ; C2560.2 292.09,148.95 v3(292.1,148.94) ; R2253.2 235.99,117.35 236.25,117.62 v3(237.14,117.62) ; v3(294.62,120.29) 294.98,120.29 295.52,120.83 R898.2 ; C2526.2 271.21,165.07 v3(271.13,165.15) ; v1(144.85,64.6) 145.1,64.85 JDIMM4.57 ; v1(67.03,61.93) 67.58,62.49 R425.1 ; Q101.1 287.89,171.9 288.13,171.66 v1(288.13,170.89) 288.14,170.9 Q101.4 ; v2(51.22,85.73) 51.22,85.98 C2102.2 50.89,86.31 50.64,86.31 C2090.2 ; v1(187.02,149.7) 187.5,149.22 R2292.2 ; JDIMM4.99 155.6,65.03 v1(155.16,64.6) ; R2082.2 63.42,90.45 v1(62.96,90) ; v1(60.68,88.9) 59.86,88.9 59.58,89.18 R2119.2 ; JDP1.2 v1(11.64,153.3) ; U63.3 v1(302.6,71.09) ; R934.1 245.21,51.51 244.7,51.01 244.7,50.45 245.33,49.81 245.33,49.1 246.22,48.21 246.6,48.21 v1(247.37,47.45) ; v3(294.63,130.32) 295.29,130.32 295.48,130.13 R899.2 ; JDIMM4.35 139.6,65.17 140.18,64.6 v1(140.6,64.6) JDIMM4.39 ; JDIMM2.234 191.15,88.77 191.36,88.98 v1(191.8,88.98) 192.15,88.63 JDIMM2.238 ; JDIMM4.1 v1(131.1,64.6) ; R868.2 295.4,155.67 295.06,155.34 v3(294.5,155.34) ; JDIMM2.73 148.9,77.83 148.62,77.55 v1(148.38,77.55) 147.9,78.03 JDIMM2.69 ; JDIMM4.85 v1(152.1,64.6) ; v1(171.96,140.47) 172.21,140.21 C915.2 ; C2556.2 296.24,152.62 v3(296.1,152.76) ; JDIMM2.206 184.15,88.69 183.87,88.98 v1(183.29,88.98) 183.15,88.84 JDIMM2.202 ; JDIMM4.235 v1(191.6,64.6) 192.12,64.6 192.6,65.08 JDIMM4.239 ; v3(247.03,58.75) 246.86,58.75 246.35,59.26 C225.1 ; JDIMM4.89 v1(153.1,64.6) ; JDIMM2.252 195.65,88.52 195.36,88.82 v1(195.36,88.98) ; Q75.4 201.26,129.12 201.08,129.3 201.08,130.32 201.65,130.89 203.8,130.89 v1(204.06,130.64) 204.06,130.18 R996.1 ; R1015.2 236.87,127.88 v3(237.01,127.75) ; JDIMM2.188 179.65,88.89 v1(179.74,88.98) ; v2(51.22,88.98) 51.67,88.53 C2076.2 C2089.2 51.67,87.6 51.76,87.51 C2101.2 51.44,87.25 v2(51.22,87.03) ; v3(262.26,170.2) 262.34,170.12 C2489.2 ; JDIMM2.260 197.65,88.65 197.33,88.98 v1(196.98,88.98) ; C1332.2 299.61,61.47 v1(300.07,61.93) 300.83,61.93 300.97,61.79 Q88.1 ; JDIMM4.5 v1(132.1,64.6) ; Q94.4 302.73,82.26 v1(302.36,82.63) ; JDIMM2.214 186.15,88.54 v1(186.6,88.98) 186.79,88.98 187.15,88.61 JDIMM2.218 ; 274.16,27.26 274.16,26.88 274.59,26.45 U8.26 ; C2685.2 206.04,124.59 Q100.1 205.32,124.93 205.07,125.18 v1(205.07,125.93) Q100.4 ; JHDMI1.2 v1(7.75,127.75) ; U9.4 281.39,52.27 ; v1(81.25,48.52) 81.08,48.69 PU605.18 ; JDIMM4.217 v1(187.1,64.6) 186.35,64.6 186.1,64.85 JDIMM4.213 ; JDIMM2.226 189.15,88.52 188.69,88.98 v1(188.5,88.98) 188.15,88.63 JDIMM2.222 ; JDIMM4.81 v1(151.1,64.6) 150.59,64.6 150.1,65.09 JDIMM4.77 ; v3(261.39,145.77) 261.58,145.57 R1023.2 ; v1(180.94,146.89) 181.16,146.68 C1060.1 ; v3(296.23,132.72) 296.16,132.78 C2586.2 ; C2612.2 296.37,117.47 v3(296.63,117.73) ; C2530.2 275.1,173.12 v3(275.13,173.15) ; R23.1 148.74,145.11 v3(148.31,145.55) ; R2211.2 249.91,170.02 C887.2 250.85,170.01 v3(250.91,169.95) ; v3(287.3,156.94) 287.17,157.06 C2551.2 ; C2478.2 v1(265.32,170.36) ; v2(55.12,88.98) 55.13,88.98 55.85,88.98 56.05,89.18 R2083.2 ; v3(299.3,145.74) 299.02,145.46 C2538.2 ; v1(9.8,83.34) 9.31,83.34 9,83.03 JTYPC1.1 ; C2490.2 255.27,173.39 v3(255.06,173.18) ; v3(279.33,164.75) 279.59,164.49 C2525.2 ; v3(289.03,139.92) 289.15,140.04 C2580.2 ; 274.8,29.67 275.18,29.67 275.46,29.95 U8.33 ; C2529.2 275.2,170.63 274.98,170.86 v3(274.98,171.1) ; JDIMM4.167 174.6,64.6 v1(174.47,64.47) ; v1(190.85,151.34) 190.9,151.29 R2291.2 ; C2683.2 v1(300.58,57.61) ; C2575.2 297.98,140.07 v3(297.83,139.92) ; JDIMM4.43 141.6,64.82 141.83,64.6 v1(142.6,64.6) JDIMM4.47 ; C2497.2 254.58,170.62 v3(255.06,171.1) ; v3(267.93,167.55) 267.89,167.58 C2534.2 ; R2216.1 232.51,172.11 v3(232.63,172) ; C2091.2 48.18,88.78 48.18,89.23 47.97,89.44 v2(47.97,89.63) ; U9.24 284.47,51.62 ; R2155.1 242.06,105.87 242.29,105.64 v1(242.41,105.64) ; v3(241.65,119.84) 241.8,119.69 C695.2 ; v1(53.44,10.37) 53.83,9.98 PQ1402.4 ; JDP1.8 v1(11.64,156.3) ; U9.8 281.46,49.67 ; U21.14 21.56,39.19 v1(21.31,39.45) ; C2080.2 53.93,88.22 v2(53.82,88.33) ; v1(11.65,160.3) JDP1.16 ; C2511.2 279.39,166.42 v3(279.33,166.35) ; v1(184.94,88.98) 185.15,88.77 JDIMM2.210 ; v3(267.93,165.95) 267.65,166.22 C2516.2 ; R660.1 243.76,116.74 v3(243.99,116.97) ; JDIMM4.69 v1(148.1,64.6) ; C1329.2 v1(301.14,59.77) 301.48,59.43 Q87.1 ; v1(208.62,162.13) 208.77,162.29 U2029.3 ; PC191.1 v1(298.67,174.58) ; v3(293.83,138.32) 293.75,138.39 R2207.2 ; JDIMM2.192 180.65,88.69 180.94,88.98 v1(181.39,88.98) 181.65,88.72 JDIMM2.196 ; Q86.4 v1(303.74,77.18) ; U23.B1 82.65,97.24 U23.A2 ; U23.B1 U23.C1 ; U23.B1 U23.A1 81.8,96.74 81.66,96.6 81.3,96.6 81.24,96.53 C626.2 ; PU401.3 v1(110.46,89.49) ; Q92.4 208.75,152.62 v1(208.25,153.11) ; R422.1 v1(76.55,72.09) ; R869.2 281.48,170.39 C1326.2 279.51,170.38 v3(279.33,170.2) ; v1(107.54,96.73) 107.7,96.56 U56.3 ; Q92.1 210.53,153.87 v1(210.66,154) ; v1(238.98,110.44) 239.29,110.14 R2151.1 ; JDIMM4.93 v1(154.1,64.6) ; v3(269.51,152.73) 270.28,151.97 274.29,151.97 274.99,151.27 274.99,150.46 R1026.1 ; U2028.3 208.34,200.27 208.88,199.72 v1(208.88,199.09) ; PQ1403.1 111.47,69.6 v1(112.09,68.97) ; v3(295.23,128.42) 295.41,128.42 C2571.2 296.15,127.68 C2569.2 ; U8.20 269.78,27.95 v1(269.84,27.89) ; C1342.2 v1(291.31,173.31) ; v1(208.12,112.22) 208.3,112.04 PC421.2 ; v3(255.19,129.62) 255.19,129.76 C593.2 ; v1(173.61,151.01) C984.2 ; v2(69.9,12.4) 70.07,12.4 U19.E10 ; JDIMM4.209 v1(185.1,64.6) ; v3(295.08,140.22) 295.57,140.71 R904.1 ; JHDMI1.11 v1(7.75,132.25) ; v1(171.83,147.09) 171.83,146.86 172.18,146.51 C1056.1 ; C2078.2 53.82,85.52 v2(53.82,85.73) ; H28.1 311,114.5 v1(311.12,114.38) ; JHDMI1.5 v1(11.2,129.25) ; PC809.2 v1(293.59,190.2) ; v3(288.23,136.72) 288.23,136.01 C2589.2 ; JDIMM2.230 190.15,88.98 v1(190.15,88.98) ; JDIMM4.23 v1(136.6,64.6) ; v1(274.92,32.97) 274.94,32.95 U8.39 277.32,32.95 277.46,33.1 v1(278.1,33.1) ; JDIMM4.73 v1(149.1,64.6) ; JDIMM4.51 v1(143.6,64.6) ; C2553.2 295.83,157.97 v3(294.9,157.04) ; JDIMM4.171 175.6,65.11 176.12,64.6 v1(176.6,64.6) JDIMM4.175 ; C1057.1 176.08,139.16 v1(175.86,138.94) ; JDIMM2.248 194.65,88.73 194.41,88.98 v1(193.71,88.98) 193.65,88.92 JDIMM2.244 ; R926.2 233.75,119.23 233.9,119.08 v3(234.28,119.08) ; PU605.17 v1(80.58,48.52) ; C2465.2 240.35,170.67 v3(239.93,171.1) ; v3(296.1,149.81) 295.36,149.07 C2557.2 ; JDIMM4.27 v1(137.6,64.6) ; C2686.2 v1(286.61,170.26) ; JDP1.11 v1(11.64,157.8) ; C496.1 76.42,70.56 v1(76.55,70.69) ; PU401.14 110.86,88.87 v1(110.97,88.98) ; R267.1 39.19,51.87 39.03,51.72 39.03,51.01 C237.1 ; PC1427.2 288.06,178.95 287.75,178.64 v1(287.37,178.64) ; v2(47.31,89.64) 46.65,90.3 R2048.1 ; C1330.2 v1(304.59,57.48) ; v3(240.88,166.75) 240.83,166.79 C2475.2 ; JDIMM4.193 v1(181.1,64.6) ; C2221.2 v1(284.96,174.2) ; C2532.2 271.25,169.27 v3(271.13,169.15) ; JHDMI1.8 v1(7.73,130.75) ; U9.3 281.4,52.92 ; Q85.1 v1(288.12,174.44) ; Q74.4 66.78,78.57 67.03,78.82 v1(67.48,78.82) 67.61,78.82 67.78,78.99 Q74.1 68.41,79.44 68.68,79.71 68.68,80.85 68.32,81.21 R1017.1 ; C2687.1 76.22,77.22 76.68,77.68 v1(76.93,77.68) ; v1(300.32,184.61) 300.32,184.81 299.89,185.25 PR820.1 ; R2153.1 242.11,110.16 v1(241.9,110.37) ; D49.3 v1(14.35,37.67) ; C907.2 244.47,170.01 v3(244.28,170.2) 245.03,170.96 R826.2 ; v3(258.91,169.15) 258.8,169.26 C2492.2 ; U24.A2 271.75,10.75 v1(271.37,10.37) ; JDIMM4.227 189.6,65.21 190.22,64.6 v1(190.6,64.6) JDIMM4.231 ; U9.19 284.55,48.37 ; U2027.3 204.45,199.74 204.16,199.44 v1(204.16,198.07) ; JHDMI1.17 v1(7.8,135.25) ; C2587.2 292.23,135.98 v3(292.23,136.72) ; v3(293.7,147.34) 293.59,147.22 R2194.2 ; JDIMM4.197 v1(182.1,64.6) ; v3(239.04,117.69) 239.04,118.06 R920.2 ; C2055.2 v1(53.82,97.74) ; v2(53.82,88.98) C2079.2
  TOP w0.305: v2(53.17,85.08) 53.05,85.21 C2077.2 ; JDIMM4.172 175.85,75.52 176.03,75.7 v1(176.44,75.7) 176.67,75.7 176.85,75.52 JDIMM4.176 ; C938.1 184.25,157.95 v1(184.15,158.04) ; v1(20.57,58.83) 20.52,58.88 D54.8 D54.3 17.7,58.88 17.06,58.25 v1(16.86,58.25) ; 172.36,140.87 v1(171.96,140.47) ; 172.36,140.87 C1133.1 ; 172.36,140.87 172.28,140.87 171.98,141.18 v1(171.93,141.18) 172.18,141.43 C1132.1 ; C928.2 185.8,136.99 186.37,136.41 v1(186.37,136.32) ; v1(15.26,149.51) C2701.2 15.26,147.45 v1(15.08,147.27) ; JDIMM4.244 193.85,76.14 v1(193.71,76.28) ; C1052.1 174.86,152.29 v1(175.14,152.57) 175.42,152.29 C1051.1 ; v1(155.61,77.5) 155.61,78.18 155.4,78.39 JDIMM2.99 ; v1(155.61,77.5) 154.92,77.5 154.35,76.93 JDIMM4.94 ; v1(155.61,77.5) 156.19,77.5 156.4,77.71 JDIMM2.103 ; JDIMM4.214 186.35,76.04 v1(186.6,76.28) 187.23,76.28 187.35,76.16 JDIMM4.218 ; JDIMM4.72 148.85,75.8 148.38,76.27 v1(148.38,76.28) 148.37,76.28 147.85,75.76 JDIMM4.68 ; v1(177.74,142.32) 177.49,142.57 C1142.1 ; v1(177.74,142.32) 177.44,142.01 C1143.1 ; v1(177.74,142.32) 178.05,142.01 C1141.1 ; v1(177.74,142.32) 178,142.57 C1140.1 ; JDIMM2.223 188.4,77.65 v1(188.5,77.55) 189.14,77.55 189.4,77.82 JDIMM2.227 ; C449.2 73.5,86 v1(73.5,86.57) ; JDIMM4.234 191.35,75.83 v1(191.8,76.28) 192.35,75.73 JDIMM4.238 ; C1107.1 172.5,154.24 v1(172.78,154.52) 173.06,154.24 C1106.1 ; C2168.1 82.52,87.46 v1(82.14,87.84) ; v1(155.74,139.59) 155.27,139.12 154.33,139.12 C950.1 ; v1(187.02,138.68) 186.48,138.68 C951.1 ; v1(82.14,86.57) 82.62,86.08 C2166.1 ; JDIMM4.206 184.35,75.69 v1(184.94,76.28) 185.35,75.87 JDIMM4.210 ; JDIMM2.52 143.65,89.28 143.99,89.61 v1(144.18,89.61) ; C2127.2 34.26,71.02 v2(34.56,71.33) ; JDIMM2.77 149.9,77.92 v1(150.27,77.55) 150.65,77.55 150.9,77.8 JDIMM2.81 ; v1(132.11,88.98) 133,88.98 133.15,88.83 JDIMM2.10 ; v1(132.11,88.98) 132.15,88.94 JDIMM2.6 ; v1(132.11,88.98) 131.54,88.98 131.15,88.59 JDIMM2.2 131.15,85.99 v1(131.1,85.93) ; v3(300.22,114.69) 300.24,114.71 C2610.2 ; v2(51.22,85.73) 51,85.51 C2097.2 50.14,85.51 v2(49.92,85.73) ; v1(190.15,77.55) 190.4,77.8 JDIMM2.231 ; v1(178.09,76.28) 177.85,76.04 JDIMM4.180 ; C1046.1 180.93,156.84 v1(180.65,157.12) 180.37,156.84 C1045.1 ; JDIMM2.30 138.15,88.8 v1(138.34,88.98) ; v2(46.69,88.98) 46.72,88.95 C2082.2 ; JDIMM2.86 152.15,88.95 v1(152.18,88.98) 153.13,88.98 ; v1(152.18,76.91) 153.45,76.91 153.9,77.37 JDIMM2.93 ; v1(183.29,76.28) 183.35,76.22 JDIMM4.202 ; v1(174.4,75.87) 174.4,75.82 ; 174.4,75.82 174.35,75.77 JDIMM4.166 ; 174.4,75.82 174.85,75.38 JDIMM4.168 ; JDIMM2.51 143.4,77.82 143.67,77.55 v1(144.18,77.55) 144.56,77.55 144.9,77.89 JDIMM2.57 ; C1105.1 182.01,149.89 v1(181.71,150.19) 181.45,149.94 C1104.1 ; C1014.2 174.58,143.67 v1(174.06,143.15) 173.48,143.72 C983.2 ; C974.2 v1(172.07,148.51) ; JDIMM4.56 144.85,76.75 144.69,76.91 v1(144.18,76.91) 143.67,76.91 143.54,76.79 143.54,75.77 143.85,75.46 JDIMM4.52 ; C947.1 C948.1 184.55,151.39 184.15,150.99 v1(184.15,150.91) 184.23,150.83 C944.1 ; JDIMM2.19 135.4,77.82 135.67,77.55 v1(136.18,77.55) 136.4,77.78 JDIMM2.23 ; C1093.1 C1092.1 174.29,140.47 v1(174.21,140.54) ; JDIMM2.48 142.65,88.6 v1(142.27,88.98) 141.91,88.98 141.65,88.73 JDIMM2.44 ; JDIMM4.10 133.35,76.5 133.76,76.91 v1(134.27,76.91) 134.65,76.91 134.78,76.79 134.78,75.9 134.35,75.47 JDIMM4.14 ; JTYPC1.A12 6.85,76.57 JTYPC1.B1 ; 174.4,77.65 174.58,77.83 175,77.83 175.4,78.24 JDIMM2.171 ; 174.4,77.65 v1(174.4,77.6) ; 174.4,77.65 JDIMM2.167 ; JDIMM2.180 177.65,88.55 v1(178.09,88.98) 178.4,88.98 178.65,88.73 JDIMM2.184 ; JDIMM2.36 139.65,88.67 139.96,88.98 140.34,88.98 140.37,89.01 v1(140.37,88.98) 140.65,88.7 JDIMM2.40 ; JDIMM2.98 155.15,88.72 155.42,88.98 v1(155.61,88.98) 156.18,88.98 ; C1153.1 181.2,152.1 180.73,152.57 v1(180.65,152.57) 180.56,152.48 C1148.1 ; C2495.2 250.68,164.12 v3(250.91,164.35) ; C1041.1 178.8,156.84 v1(179.08,157.12) 179.35,156.84 C1040.1 ; 145.88,88.98 145.65,88.75 JDIMM2.60 ; 145.88,88.98 145,88.98 144.65,88.63 JDIMM2.56 ; 145.88,88.98 v1(146.21,88.98) 146.65,88.54 JDIMM2.64 ; JDIMM4.26 137.35,76.06 137.57,76.28 v1(138.35,76.28) 138.35,76.27 138.35,76.26 JDIMM4.30 ; 153.13,88.98 153.15,88.96 JDIMM2.90 ; 153.13,88.98 154.02,88.98 154.15,88.85 JDIMM2.94 ; C2672.2 255,98.45 v3(254.87,98.32) ; JDIMM2.9 132.9,77.83 132.62,77.55 v1(132.11,77.55) ; JDIMM2.197 181.9,77.78 181.67,77.55 v1(181.39,77.55) 181.16,77.55 180.9,77.8 JDIMM2.193 ; v1(172.78,152.57) 172.75,152.55 C985.2 ; JDIMM2.31 138.4,77.62 138.35,77.56 v1(138.35,77.55) 137.57,77.55 137.4,77.72 JDIMM2.27 ; v3(300.1,149.74) 300.11,149.75 C2547.2 ; PC3407.2 300.83,97.36 v1(301.34,96.85) ; C2073.2 52.99,84.25 v2(53.17,84.43) ; C2095.2 47.73,84.43 v2(47.32,84.43) ; v1(177.5,150.94) 177.39,151.05 C1062.1 ; v1(73.88,73.49) 73.63,73.74 C526.2 ; JDIMM4.82 151.35,75.96 151.04,76.28 v1(150.27,76.28) 150.35,76.2 JDIMM4.78 ; v3(271.93,177.15) 272.03,177.25 C2513.2 ; C1019.2 178.89,138.67 v1(178.6,138.95) 178.99,139.34 C1091.1 C1090.1 ; JDIMM2.176 176.65,88.76 v1(176.44,88.98) 175.74,88.98 175.65,88.89 JDIMM2.172 ; C1018.2 183.13,142.36 v1(183.21,142.44) 183.19,142.46 C986.2 183.19,143.99 C1011.2 ; JDIMM2.189 179.9,77.71 v1(179.74,77.55) ; JDIMM2.68 147.65,88.83 147.8,88.98 v1(148.37,88.98) 148.65,88.7 JDIMM2.72 ; v3(250.91,169.95) v3(251.71,169.95) ; C1017.2 181.2,143.2 v1(181.16,143.15) 180.82,142.81 C1136.1 C1137.1 ; v1(157.89,77.5) 157.4,77.99 JDIMM2.107 ; JDIMM4.44 141.85,75.86 v1(142.27,76.28) 142.85,75.7 JDIMM4.48 ; C1015.2 177.34,143.61 v1(177.82,143.13) 178.26,143.57 C1016.2 ; C227.1 237.66,54.03 C228.2 ; v1(132.11,77.55) 131.48,77.55 130.9,78.13 JDIMM2.1 ; v1(132.11,77.55) 131.9,77.76 JDIMM2.5 ; C976.2 176.51,150.42 v1(175.93,151.01) ; C1152.1 178.8,154.24 v1(179.08,154.52) 179.08,154.52 179.35,154.24 C1053.1 ; JDIMM4.106 157.35,75.69 v1(157.89,76.23) ; v1(185.72,149.7) 185.58,149.7 185.52,149.65 C946.1 ; C2679.2 248.39,85.52 v3(247.67,85.52) ; JDIMM2.213 185.9,77.87 185.58,77.55 v1(184.94,77.55) 184.9,77.59 JDIMM2.209 ; JDIMM4.230 190.35,76.08 v1(190.15,76.28) 189.64,76.28 189.35,75.99 JDIMM4.226 ; C2504.2 250.91,165.95 v3(250.91,165.95) ; R2167.2 R2166.2 ; v1(188.5,76.28) 188.35,76.13 JDIMM4.222 ; v3(275.93,166.75) 275.13,166.75 C2510.2 ; C2614.2 291.43,117.97 v3(291.43,118.69) ; JDIMM2.43 141.4,77.78 141.64,77.55 v1(142.27,77.55) 142.4,77.68 JDIMM2.47 ; JDIMM2.106 157.15,88.77 156.94,88.98 156.18,88.98 ; JDIMM2.102 156.15,88.95 156.18,88.98 ; C1100.1 C1101.1 v1(180.94,146.89) ; C1047.1 176.43,156.84 v1(176.71,157.12) 176.99,156.84 C1048.1 ; C655.2 241.69,137.37 v3(241.09,137.97) ; C1102.1 C1103.1 175.43,140.75 v1(175.93,140.26) 176.5,140.83 C1099.1 C1098.1 ; v1(179.72,141.52) 180,141.8 C1139.1 C1138.1 ; PQ1402.1 55.97,8.98 v1(56.1,8.84) ; C2620.2 297.93,122.58 v3(298.63,121.88) ; C1149.1 181.72,154.24 v1(181.44,154.52) 181.16,154.24 C1108.1 ; JDIMM4.86 152.35,76.11 v1(152.18,76.28) 153.07,76.28 153.35,76 JDIMM4.90 ; v1(183.19,141.01) 183.17,141 C1010.2 ; JTYPC1.2 9.34,80.57 10,81.23 v1(10.38,81.23) ; C940.1 184.08,154.8 v1(183.8,154.52) 183.52,154.8 C939.1 ; PC1803.2 251.94,131.36 v3(252.29,131.02) ; JTYPC1.A1 6.85,82.07 JTYPC1.B12 ; C2613.2 295.49,114.07 v3(296.23,114.81) ; v1(151.6,151.84) 151.43,151.66 R27.2 ; JDIMM2.217 186.9,77.86 v1(186.6,77.55) ; JDIMM4.98 155.35,75.97 v1(155.61,76.23) 156.04,76.23 156.35,75.92 JDIMM4.102 ; v1(181.39,76.28) 181.85,75.82 JDIMM4.196 ; C1154.1 177.22,154.24 v1(177.5,154.52) 177.78,154.24 C1146.1 ; JDIMM2.89 152.9,77.77 152.69,77.55 v1(152.18,77.55) 151.9,77.83 JDIMM2.85 ; C1042.1 175.42,154.24 v1(175.14,154.52) 174.86,154.24 C1043.1 ; JDIMM4.18 135.35,76.09 135.54,76.28 v1(136.18,76.28) 136.35,76.11 JDIMM4.22 ; v1(179.74,76.28) 179.1,76.28 178.85,76.03 JDIMM4.184 ; JDIMM4.36 139.85,75.76 v1(140.37,76.28) 140.85,75.8 JDIMM4.40 ; 52.61,81.39 52.59,81.36 ; JDIMM2.168 174.65,88.73 v1(174.4,88.98) 174.15,88.73 JDIMM2.166 ; JDIMM2.39 140.4,77.58 v1(140.37,77.55) 139.73,77.55 139.4,77.88 JDIMM2.35 ; JDIMM4.248 194.85,75.77 v1(195.36,76.28) ; JDIMM2.18 135.15,88.73 134.91,88.98 v1(134.27,88.98) 134.15,88.86 JDIMM2.14 ; v2(46.72,87.03) 46.92,87.03 47.23,86.73 C2092.2 47.86,86.73 48.04,86.55 C2111.2 48.81,86.55 C2074.2 48.85,86.33 49.27,85.91 v2(49.27,85.73) ; JDIMM2.247 194.4,77.86 194.09,77.55 v1(193.71,77.55) 193.4,77.86 JDIMM2.243 ; JDIMM2.22 136.15,88.96 v1(136.18,88.98) 136.88,88.98 137.15,88.7 JDIMM2.26 ; JDIMM4.6 132.35,76.04 v1(132.11,76.28) 131.6,76.28 131.35,76.03 JDIMM4.2 ; C2693.1 v1(257.65,58.63) ; v3(245.29,137.32) 244.51,137.32 C657.2 ; JDIMM2.201 182.9,77.94 v1(183.29,77.55) 183.67,77.55 183.9,77.78 JDIMM2.205 ; v1(195.36,77.55) 195.4,77.59 JDIMM2.251 ; JDIMM4.252 195.85,75.76 196.37,76.28 v1(196.98,76.28) ; JDIMM2.239 192.4,77.78 192.17,77.55 v1(191.8,77.55) 191.63,77.55 191.4,77.78 JDIMM2.235 ; C2559.2 288.01,153.65 v3(288.1,153.74) ; C2512.2 275.29,168.35 v3(275.93,168.35) ; U2030.5 v1(17.11,146.76) ; JDIMM4.60 145.85,75.92 v1(146.21,76.28) 146.85,75.64 JDIMM4.64 ; v1(134.27,77.55) 134.4,77.68 JDIMM2.15 ; C987.2 172.24,147.5 v1(171.83,147.09) ; v1(179.67,140.85) 179.65,140.87 C1097.1 C1096.1 ; C437.1 67.1,92.36 v1(67.66,92.92) ; JDIMM2.82 151.15,88.8 150.97,88.98 v1(150.27,88.98) 150.15,88.86 JDIMM2.78 ; C1049.1 174.63,156.84 v1(174.35,157.12) 174.07,156.84 C1050.1 ; v1(81.38,84.15) 81.25,84.28 C2722.1 ; C2084.2 47.56,88.1 v2(47.32,88.33) ; v1(176.44,77.55) 176.4,77.58 JDIMM2.175 ; JDIMM2.61 145.9,78.13 145.69,77.92 145.69,77.18 145.96,76.91 v1(146.21,76.91) 146.72,76.91 146.9,77.1 JDIMM2.65 ; v1(81.38,87.84) 80.94,88.27 C2170.1 ; JDIMM2.181 177.9,77.73 v1(178.09,77.55) 178.59,77.55 178.9,77.86 JDIMM2.185 ; C1094.1 C1095.1 180.2,140.62 v1(179.78,140.2) 180.25,139.73 C1012.2 ; C512.1 v1(7.21,146)
  TOP w0.356: D23.1 v1(16.59,159.07) ; v3(244.07,177.95) 244.09,177.93 C2456.2 C2450.2 ; PC513.2 v1(267.3,43.77) ; C1361.1 64.66,7.37 v1(64.61,7.32) C1367.2 ; C2477.2 262.19,167.47 v3(262.11,167.55) ; v3(288.1,148.94) 288.04,149 C2550.2 ; v2(35.38,76.13) 35.43,76.08 R2062.1 ; v3(236.82,50.5) 237.18,50.5 C226.2 ; v2(36.42,71.83) 36.38,71.87 C2118.2 ; v3(249.49,133.12) 249.49,133.34 249.01,133.82 C2335.2 248.64,133.82 248.09,133.26 v3(248.09,133.12) ; v3(288.23,118.69) 288.14,118.6 C2617.2 ; R1001.1 301.64,75.47 v1(301.85,75.26) ; C2618.2 287.3,122.01 v3(287.43,121.89) ; C168.2 4.35,170.4 v1(4.39,170.36) ; v1(248.39,178.64) 248.39,177.89 C2479.2 ; PC677.2 274.54,69.17 v1(274.29,69.42) ; C696.2 240.3,120.91 240.63,121.24 241.06,121.24 v3(241.09,121.27) 241.11,121.27 241.65,121.81 241.65,122.25 242.03,122.63 C703.2 ; C2100.2 54.58,97.87 54.96,97.49 v1(55.21,97.49) ; v3(256.59,124.72) C2345.2 v3(256.59,126.12) ; PC3543.2 v1(295.37,190.2) ; C2499.2 258.82,165.06 v3(258.91,165.15) ; v1(173.33,140.14) 173.12,139.93 C1044.1 ; C2462.2 244.73,164.34 v3(244.32,164.75) ; C1341.2 210.79,156.16 v1(210.66,156.29) ; LD1.2 5.35,173.76 v1(5.43,173.76) ; C2485.2 250.11,175.55 v3(250.91,175.55) ; v2(32.25,74.13) 32.15,74.03 C2128.2 ; C227.1 238.09,54.05 v3(238.48,54.05) ; PR1419.2 PR1418.2 288.28,191.82 v1(288.26,191.85) ; C2387.2 251.07,137.14 v3(250.89,137.32) ; v3(250.89,133.12) C2327.2 v3(250.89,134.52) ; v1(79.22,46.05) 79.22,46.18 78.71,46.69 PR647.2 ; PC437.2 209.2,118 208.88,117.68 v1(208.88,117.63) ; v2(35.28,74.4) 35.38,74.3 R2086.1 ; C553.2 277.21,69.74 v1(277.21,69.42) ; 149.02,153.51 149.4,153.89 R30.1 ; 79.91,11.89 PC223.2 ; v3(240.88,169.15) 240.07,169.15 C2460.2 ; v3(271.13,173.15) 271.12,173.15 C2531.2 ; PR1416.2 PR1417.2 289.15,191.19 v1(289.15,191.85) ; v2(30.45,57.48) 31.29,57.48 PC108.2 ; v1(280,31.07) 280.64,31.07 280.97,31.4 C363.2 ; C554.2 280.77,70.01 v1(281.07,70.31) ; C1359.1 64.49,9.4 v1(64.49,10.27) ; v1(204.16,198.07) 204.16,197.08 C2694.2 204.13,196.57 203.98,196.42 R2305.2 ; R2163.2 222.22,114 221.84,113.62 v1(221.84,113.49) 222.22,113.11 R2162.2 ; v3(250.25,119.12) 250.06,118.93 C2209.2 ; C169.2 v1(6.9,174.35) ; C212.2 234.74,54.31 v3(234.92,54.49) ; C1338.2 293.29,72.98 R809.2 v1(292.32,72.9) ; C2416.2 241.69,130.27 v3(241.79,130.37) ; v1(81.88,14.56) 82.07,14.37 PC206.2 ; v1(191.11,156.88) 191.52,156.47 C930.2 ; C2584.2 291.52,132.01 v3(291.43,131.92) ; v1(273.91,58.7) 273.27,58.7 PC671.2 ; v1(219.93,166.83) 219.81,166.96 PR724.2 ; v3(269.03,88.72) 268.35,88.04 C2624.2 ; v2(30.96,54.54) 31.06,54.44 R235.1 ; C364.2 264.92,31.7 v1(264.89,31.73) 264.56,32.06 R328.2 ; v1(292.7,191.85) 292.73,191.82 PR3470.2 PR3471.2 PR3472.2 ; C2459.2 244.2,174.87 v3(244.08,174.75) ; v1(175.93,151.01) 176.4,151.48 C982.2 ; v3(243.47,94.72) 243.42,94.77 C2677.2 ; C2210.2 244.11,119.29 v3(243.99,119.17) ; R428.1 245.33,44.57 Q12.3 ; v3(254.11,165.15) 254.25,165.01 C2505.2 ; v1(302.1,170.77) 302.43,171.1 PR3586.2 ; PR621.2 76.58,55.45 v1(75.66,54.54) ; v3(240.49,123.37) 240.66,123.54 C702.2 ; C2644.2 265.08,95.87 v3(265.03,95.92) ; v1(252.02,103.09) 251.82,102.89 C2320.2 ; C2682.2 292.15,79.2 v1(291.56,79.2) ; R2333.1 82.14,75.72 v1(82.14,75.26) ; v3(291.3,153.74) 291.36,153.67 C2561.2 ; v3(254.87,96.72) 254.97,96.62 C2671.2 ; v1(168.45,150.96) 169.07,150.33 PC1630.2 ; C308.1 32.56,48.9 v2(32.48,48.97) C236.1 ; v2(50.57,81.86) 50.96,81.86 R2015.2 ; v3(262.19,127.52) 262.19,127.25 262.62,126.81 C2336.2 263.49,126.7 263.09,126.3 C2347.2 262.37,125.94 v3(262.19,126.12) ; C232.1 31.59,49.1 v2(31.47,48.97) ; C2483.2 262.11,165.94 v3(262.11,165.95) ; v1(298.8,65.87) 299.38,65.87 R2334.1 ; v3(231.74,56.85) 232.1,56.49 R506.2 ; PC1432.1 297.66,182.83 v1(297.78,182.71) ; v3(225.52,71.9) 225.73,71.9 226.26,72.42 C316.2 226.26,73 v3(226.16,73.1) ; C525.1 77.82,65.23 v1(77.95,65.1) ; C980.2 179.71,151.04 v1(179.75,151.01) 180.14,150.61 C988.2 ; v3(289.03,121.89) 289.13,121.99 C2619.2 ; C2659.2 242.95,98.44 v3(243.47,97.92) ; C493.1 76.17,73.87 v1(76.55,73.49) 77.06,73.99 C527.1 ; v3(264.76,143.11) 264.76,142.06 C2408.2 ; PC1615.2 169.2,146.91 v1(169.36,147.08) ; v2(44.8,92.28) 44.93,92.15 R2025.2 ; R855.1 225.93,59.82 225.8,59.69 ; v3(241.09,140.07) 242.06,140.07 C2323.2 ; C933.2 189.66,157.25 189.71,157.31 ; D53.3 D53.8 v1(16.23,28.91) ; v3(242.59,146.47) 242.59,145.66 C167.2 243.1,145.77 v3(243.89,145.77) ; C224.1 229.66,62.89 v3(230.09,63.33) ; v3(236.88,177.15) 237.01,177.28 C2469.2 ; C934.2 183.73,152.03 C935.2 ; C2689.2 58.71,84.73 v1(59.02,84.41) ; C1021.2 178.34,149.07 v1(178.81,148.6) 179.23,149.02 C1009.2 ; v3(241.09,133.77) 241.09,133.59 C669.2 ; v3(249.49,131.02) 249.4,131.1 C2388.2 249.4,132.33 v3(249.49,132.42) ; v2(52.52,84.43) 52.38,84.57 C2151.2 ; v1(169.63,154.52) 169.83,154.72 PC1613.2 ; 190.34,156.42 190.29,156.37 C932.2 ; C230.2 31.21,55.32 v2(30.96,55.58) ; C2390.2 248.09,130.36 v3(248.09,131.02) ; v3(178.43,150.96) 178.43,151.54 C981.2 ; v3(249.49,137.32) 249.42,137.25 C2386.2 ; C2129.2 C2130.2 31,76.24 31.34,75.9 v2(32.23,75.9) 32.15,75.97 R2085.1 ; C978.2 174.73,148.94 v1(175.16,148.51) 175.62,148.98 C977.2 ; C2110.2 46.46,86.59 v2(46.69,86.36) ; v1(292.83,177.12) 292.96,176.99 PR3571.1 ; JTYPC1.4 9.54,75.94 v1(9.75,76.15) ; C1333.2 v1(302.79,68.61) ; v3(266.99,119.77) 266.99,119.65 266.8,119.46 266.8,119.11 C2394.2 265.93,118.24 v3(265.76,118.24) ; v3(241.09,131.67) 241.12,131.63 C666.2 ; v1(247.37,103.08) 247.56,102.89 C2322.2 ; C2696.2 205.71,166.2 v1(205.58,166.07) ; v3(233.65,122.76) 233.65,123.08 C694.2 ; v3(287.43,128.72) 287.43,127.76 C2568.2 ; PR718.2 v1(219.93,163.4) ; C573.2 60.29,65.61 v1(60.8,65.1) ; R2193.2 234.4,170.67 v3(234.48,170.75) ; v1(271.88,6.18) C629.1 272.66,6.2 272.66,8.59 ; PC1264.2 265.97,74.69 v1(265.78,74.88) ; v1(111.09,86.06) 110.89,85.86 PR404.2 PC411.2 ; v1(180.82,193.25) 181.12,193.55 C416.1 ; PR1460.2 292.83,178.82 PR1458.2 PC3590.1 v1(291.82,178.26) ; C2692.1 240.3,46.23 240.51,46.43 v1(240.51,46.69) ; C925.2 169.92,138.74 v1(170.37,138.29) ; v3(244.59,117.77) 244.59,118.45 C2213.2 ; C233.1 v2(36.8,57.36) ; PC1313.1 197.28,193.42 v1(197.33,193.37) 197.35,193.4 PC1311.1 ; C528.1 73.63,70.44 v1(73.88,70.69) ; U2031.5 U2031.7 ; D24.1 v1(16.61,162.02) ; v3(289.03,128.72) 289.03,128.02 C2591.2 ; v1(164.88,138.95) 164.38,138.45 ; R919.2 237.56,120.72 v3(237.56,121.33) ; C2496.2 254.29,169.33 v3(254.11,169.15) ; PC717.2 v1(219.93,164.29) ; PC222.1 81.12,4.07 PC221.1 ; v1(186.37,142.62) 186.18,142.62 C873.2 ; U51.3 4.03,145.55 v1(4.46,145.55) ; v3(269.83,89.52) 269.74,89.61 C2625.2 ; C548.2 248,139.5 v3(248.09,139.42) ; PC3542.2 v1(296.31,190.2) ; v1(79.27,12.53) 79.2,12.6 PR206.2 ; R2032.2 R2049.2 49.7,91.98 49.37,91.65 49.37,90.39 v2(49.27,90.28) ; C2131.1 32.65,74.76 v2(32.25,74.76) ; C2570.2 290.7,139.99 v3(290.63,139.92) ; R2165.2 222.35,116.16 v1(221.84,115.65) 222.22,115.27 R2164.2 ; v1(79.09,96.47) 79.15,96.53 C627.1 ; C2491.2 258.87,172.38 v3(258.11,173.15) ; v3(265.03,93.52) 265.2,93.35 C2641.2 ; v3(257.99,126.12) C2363.2 v3(257.99,124.72) ; D56.1 v1(9.06,72.75) ; C594.2 253.69,130.8 v3(253.69,130.97) ; PU1608.3 v1(301.59,86.88) ; PC1157.1 118.03,194.59 118.46,195.02 v1(118.84,195.02) ; PC1536.2 168.63,142.07 v1(168.24,141.68) ; v3(246.69,132.42) 246.69,131.89 C595.2 246.86,131.19 v3(246.69,131.02) ; R927.2 v3(237.59,119.71) ; v3(301.03,130.32) 301.49,129.86 C2574.2 ; v3(288.23,131.92) 288.21,131.94 C2583.2 ; v1(167.63,138.95) 167.9,139.22 167.9,140.16 168.25,140.52 168.92,140.52 PC1632.2 ; C401.2 243.17,46.31 v1(242.79,46.69) ; C2690.2 56.92,84.99 56.18,85.73 v2(55.07,85.73) ; v1(107.41,93.04) 107.46,93.09 C426.2 ; R2042.2 63.85,92.92 64.1,92.66 v1(64.36,92.66) ; v1(300.07,189.56) PR3468.2 300.02,188.8 PC3572.2 ; C229.1 C228.2 ; C418.1 181.07,195.89 v1(181.07,195.66) ; PR3576.1 v1(297.71,88.67) ; PC217.2 85.83,3.06 v1(85.86,3.04) ; v3(288.23,113.88) 288.16,113.95 C2616.2 ; C237.1 v2(40.36,50.88) ; C1339.2 v1(301.98,73.23) ; C179.1 247.57,47.25 v1(247.37,47.45) ; PC410.2 v1(109.82,94.06) ; v3(251.67,94.32) 251.61,94.26 C2667.2 ; C1386.2 v1(290.93,20.91) ; R2307.2 207.94,162.36 208.17,162.13 v1(208.62,162.13) ; PC190.1 v1(299.74,90.05) ; PC626.1 76.09,46.1 v1(76.04,46.05) 76.04,45.22 PC622.2 ; v3(241.09,135.87) 241.09,135.48 241.36,135.21 C656.2 241.5,134.87 241.78,134.6 v3(241.78,134.57) ; C188.2 243.73,49.43 244.11,49.05 ; C497.1 74.65,70.06 v1(75.28,70.69) ; 210.54,166.2 R2304.1 ; v2(42.26,92.28) 42.26,91.53 C2083.2 ; C2397.2 270.8,140.78 v3(270.34,140.32) ; v3(257.99,138.72) v3(257.99,139.42) 258.18,139.61 C2393.2 C2332.2 ; v1(208.12,114.89) 208.3,114.71 PR431.2 ; v1(184.12,146.16) 184.07,146.21 C871.2 ; v2(30.96,69.93) 30.96,69.96 29.92,71 R2092.2 ; R568.2 v1(14.19,125.94) ; C539.1 67.2,61.37 ; R411.2 v3(19.15,159.21)
  TOP w0.381: R463.2 279.62,59.85 280.08,59.39 v1(280.89,59.39) ; PC1226.2 192.02,127.92 v1(192.88,128.78) ; C644.2 274.75,20.7 v1(275.05,20.4) 275.36,20.7 C643.2 ; v1(177.5,150.94) 177.4,150.84 C975.2 ; v3(150.28,151.81) 149.98,151.51 R29.2 C33.2 ; v3(230.22,58.83) 230.68,58.37 C223.1 ; v3(248.5,55.33) 249.07,54.77 R146.2 ; v1(80.57,3.25) 80.55,3.25 80.23,3.57 PC222.1 ; v1(44.23,58.63) 44.61,58.25 C273.1 ; v1(134.26,192.92) 134.26,193.35 134.03,193.58 PR1191.1 ; v1(118.08,191.27) 118.43,190.91 PR1188.1 ; R912.2 263.05,90.27 263.43,90.65 v3(263.43,91.12) ; C328.1 v1(285.47,26.37) ; C1379.2 88.11,19.13 v1(87.6,19.64) ; PC1305.2 23.65,18.3 v1(23.85,18.11) ; D29.1 v1(13.94,136.86) ; PC205.2 77.88,14.05 v1(77.44,14.05) ; v1(118.84,195.02) 119.1,195.02 119.48,195.41 PC1160.1 ; R148.2 243.38,57.73 v3(243.37,57.73) ; Q52.1 20.53,45.03 v1(20.67,45.16) 20.67,45.42 20.04,46.05 C407.1 ; C922.2 186.47,134.98 v1(187.02,135.53) ; v3(243.81,55.96) 243.38,55.96 243.21,55.78 R149.1 ; v1(284.9,116.38) 284.87,116.41 C2185.2 ; v1(108.3,0.91) 107.98,0.91 107.41,1.48 D55.2 ; PC1306.2 17.93,13.74 v1(18.13,13.54) ; v1(245.41,46.69) 245.41,46.38 245.33,46.3 Q12.3 ; R471.1 R472.1 v1(283.18,59.39) ; v3(261.83,87.92) 261.08,87.92 260.69,87.53 C2637.2 ; v1(70.2,4.14) 70.61,4.14 70.66,4.19 R511.1 ; v1(133.45,189.31) PR1192.2 PR1189.1 PR1190.2 ; R2228.1 273.75,92.99 v3(273.28,92.52) ; v1(44.93,68.91) 44.93,68.2 C276.2 ; PC1255.2 202.97,157.36 v1(203.55,157.94) ; v3(77.87,8.36) 77.87,8.51 78.07,8.72 PC218.1 PC219.1 ; v1(266.36,46.54) 265.69,45.86 PC512.2 ; v1(90.9,19) 90.47,18.57 C1378.1 ; v3(233.73,52.35) 234.11,51.97 R126.2 ; R2044.2 46.11,88.52 46.32,88.31 46.71,88.31 46.74,88.33 46.74,88.33 v2(46.71,88.33) ; C509.1 106.4,1.1 v1(106.65,0.84) ; v1(65.25,3.13) 65.76,3.64 C1364.1 ; v1(118.82,189.36) 118.99,189.18 PC1152.1 ; C379.2 288.84,53.11 v1(288.77,53.04) ; U18.5 18.32,71.26 v1(18.26,71.33) ; PR314.2 49.12,11.76 v1(49.5,12.14) 49.5,12.22 49.07,12.65 PC317.2 ; C2653.2 244.5,84.69 v3(244.47,84.72) ; C2666.2 250.58,89.38 v3(250.72,89.52) ; C949.2 176.6,139.25 176.3,138.94 v1(175.86,138.94) ; R125.2 234.41,50.24 v3(235.05,50.88) 235.17,51.01 C209.1 ; PQ206.3 273.67,40.61 v1(274.29,41.23) 274.92,40.59 PC676.2 ; C2623.2 273.11,95.04 v3(273.03,95.12) ; PR1197.1 119.25,185.02 v1(118.84,184.61) ; D58.1 17.28,76.94 v1(16.94,76.94) ; R930.1 C1368.2 ; C2660.2 242.83,86.32 v3(243.67,86.32) ; R451.2 13.69,137.87 v1(13.94,137.62) ; C2186.2 284.73,117.68 v1(284.86,117.55) ; v1(42.13,17.86) 42.26,17.99 PC316.2 ; R2118.2 60.19,93.88 v1(59.86,93.55) 59.66,93.75 R2120.1 ; D40.1 v1(275.05,21.67) D41.1 ; C628.2 v1(268.57,9.99) ; v3(255.07,90.72) 255.9,89.89 C2674.2 ; v1(163.8,131.79) 163.89,131.79 164.43,132.34 C920.2 ; v1(284.52,133.99) 284.47,133.94 C2183.2 ; PQ1404.1 v1(118.09,67.4) ; R187.1 v3(225.75,59.64) 225.8,59.69 ; PC1163.2 PR1187.1 118.87,188.29 v1(118.79,188.22) ; v1(46.58,68.79) 46.85,69.06 Y4.2 ; v1(150.94,147.9) 150.88,147.83 R12.1 ; PR224.1 82.62,5.92 v1(82.27,5.57) ; C331.2 287.5,26.5 288.01,25.99 v1(288.01,25.48) 287.45,25.48 R314.2 ; v1(11.02,78.39) 10.7,78.07 JTYPC1.3 ; C332.1 280.64,32.97 v1(280.51,33.1) ; v3(247.67,89.52) 247.67,89.85 247.27,90.26 C2678.2 ; v1(152.24,150.26) 152.45,150.06 R10.1 ; v1(183.28,150.93) 183.26,150.96 183.26,151.56 C935.2 ; R348.1 v1(277.85,51.9) R345.1 ; C350.1 v1(278.35,29.8) ; v1(17.11,164.32) 17.06,164.27 C465.1 ; v1(189.96,157.56) 189.71,157.31 ; PC1227.2 207.44,152.56 208,153.11 v1(208.25,153.11) ; v1(66.14,3.13) 66.64,3.64 C1365.1 ; C2177.2 274.43,159.7 v1(274.5,159.77) ; v3(226.28,66.25) 226.28,66.58 R97.1 ; v1(148.91,153.41) 149.02,153.51 ; v3(242.84,52.33) 243.25,51.92 C400.1 ; C918.2 178.98,131.72 v1(178.89,131.81) ; C2188.2 260.01,106.19 v1(259.62,105.79) ; R2045.1 44.17,91.72 v2(44.17,92.28) ; v1(257.45,159.82) 257.02,159.39 C2180.2 ; v3(244.19,48.97) 244.11,49.05 ; R2051.2 42.9,91.85 v2(42.9,92.28) ; 29.43,80.72 29.43,80.98 28.98,81.44 v1(28.11,81.44) ; R495.2 21.13,66.7 v1(20.8,66.37) ; C278.1 v1(4.67,116.92) ; C378.1 293.31,48.42 293.92,48.42 v1(293.97,48.47) ; C936.2 183.66,148.29 C937.2 183.67,148.29 184.16,148.29 184.3,148.14 v1(184.3,148.12) ; v3(245.27,91.92) 245.16,92.03 R2201.2 ; PC726.2 284.96,125.3 v1(285.01,125.36) ; PC1315.2 203.87,155.34 v1(203.93,155.27) ; C2645.2 269.72,93.41 v3(269.83,93.52) ; v1(109.75,64.24) 109.94,64.43 PQ1401.4 ; R130.2 247.24,58.96 v3(247.03,58.75) ; v3(261.63,90.5) 260.8,89.67 C2647.2 260.79,89.6 C2650.2 ; PR305.2 v1(42.77,8.08) ; v1(14.32,131.78) D26.3 D26.8 ; R32.1 150.92,144.72 v1(150.94,144.75) ; v3(261.63,96.32) 261.56,96.39 C2648.2 ; C1376.2 v1(92.55,17.73) ; PR307.2 40.99,8.11 v1(40.96,8.08) ; C280.1 v1(2.51,89.49) ; v1(275.81,48.47) 275.31,47.96 R347.2 ; v1(273.17,159.68) 273.16,159.67 C2178.2 ; U16.4 v1(40.23,2.37) ; v3(251.67,97.52) 251.58,97.61 C2673.2 ; v1(105.76,94.72) 105.76,94.69 105.96,94.49 PC820.2 ; v3(295.4,121.9) 295.37,121.92 295.19,121.92 C2621.2 294.05,123.06 C1353.2 C2425.2 ; C260.2 49.8,57.66 v1(49.63,57.48) ; C2649.2 265.9,89.58 v3(265.83,89.52) ; R430.1 81.25,20.78 v1(82.27,21.8) ; R62.1 247.9,61.19 R177.2 248.81,59.59 v3(248.89,59.52) ; v3(253.27,91.12) 253.27,90.48 253.52,90.22 R911.2 ; C2643.2 269.69,97.66 v3(269.83,97.52) ; v1(79.27,12.53) 79.91,11.89 ; v1(119.6,197.06) 119.65,197.01 PR1152.1 ; C921.2 172.05,132.03 171.8,131.78 171.36,131.78 v1(171.35,131.76) 170.92,131.76 170.66,132.03 C926.2 ; R477.1 v1(54.15,72.09) ; C1369.1 v1(76.8,3.64) ; v1(206.01,154.51) 204.9,154.51 PC1254.2 204.74,154.26 PC1251.2 ; R2050.2 R2121.1 45.61,92.92 R2025.2 ; v1(277.46,40.97) 278.99,42.5 R346.2 ; v1(128.11,184.23) 128.11,184.31 127.73,184.69 PC1142.1 ; C924.2 164.37,138.44 164.38,138.45 ; v1(151.59,144.75) 152.09,144.25 R28.1 ; C1362.1 75.03,16.03 v1(75.03,16.72) ; v1(295.52,51.01) 294.99,51.54 293.29,51.54 C377.1 ; C329.1 284.58,26.5 v1(284.45,26.37) ; v3(236.06,63.33) 236.82,64.09 C314.2 ; C346.2 279.14,33.48 v1(278.76,33.1) ; v1(285.13,127.46) 284.88,127.21 PC727.2 ; C256.1 v1(56.31,65.69) ; v3(241.65,50.88) 241.52,51.01 C405.1 ; 15.85,128.22 v1(14.32,128.22) ; PC303.1 v1(43.91,8.08) ; C222.2 242.03,60.58 v3(242.03,61.12) ; v3(235.94,57.48) 235.63,57.18 R547.1 ; v1(284.45,132.72) 284.4,132.67 C2184.2 ; v3(271.43,91.92) 271.42,91.93 R857.2 ; C2439.2 C1373.2 256.05,91.7 C2670.2 255.62,91.55 255.12,92.06 v3(255.12,92.52) ; v1(78.63,5.92) PR226.2 ; C927.2 179.55,135.75 v1(179.51,135.78) ; v1(291.43,46.82) 291.43,46.97 291.21,47.2 291.18,47.2 C380.2 ; C255.2 59.02,66.63 v1(58.77,66.88) ; C2639.2 273.15,96.6 v3(273.03,96.72) ; v1(57.5,66.88) 57.5,66.5 57.88,66.12 C258.2 ; C625.2 v1(14.32,32.08) ; PC231.2 87.68,13.34 v1(87.47,13.54) ; v3(241.57,58.75) 241.57,58.47 C399.2 ; C556.1 281.66,70.06 v1(281.91,70.31) ; D2005.3 v1(15.06,79.3) ; C908.2 294.07,159.78 C2552.2 ; C917.2 163.01,135.72 v1(163.05,135.77) ; PQ1403.4 108.18,68.54 v1(107.54,67.9) 108.05,67.38 PQ1401.1 ; C1363.1 v3(77.06,6.61) ; v1(187.82,133.07) 187.71,133.18 C923.2 ; PR612.2 272.23,65.48 272,65.71 v1(272,65.74) ; C2597.2 299.15,110.41 v3(299.43,110.69) ; PR303.1 v1(47.21,8.21) ; v1(187.02,152.85) 186.9,152.73 C945.1 ; v1(105.51,89.87) PC439.1 ; C320.2 v1(77.69,3.64) ; D28.1 v1(13.94,135.72) ; PC315.2 v1(46.9,18.88) ; v1(116.68,68.79) 116.68,68.78 117.06,68.4 PQ1404.4 ; PC1316.2 v1(202.79,150.6) ; v3(243.67,84.72) 243.67,84.61 243.04,83.98 C2661.2 ; C557.1 C555.1 v1(284.96,59.39) ; v1(228.82,45.8) 228.32,46.31 R372.2 ; PR306.2 v1(48.86,8.89) ; R460.1 267.48,74.17 v1(267.43,74.12) ; C495.2 13.94,67.9 v1(13.81,68.02) ; C281.1 v1(3.53,89.61) ; C2187.2 263.62,106.19 v1(264.2,105.6) ; v1(62.07,7.32) 61.77,7.01 R407.2 ; R2080.2 30.45,68.41 30.91,67.95 v1(30.91,67.67) ; C2179.2 v1(284.95,123.78) ; C464.2 v1(17.11,163.4) ; PC1153.1 119.04,185.91 v1(118.82,185.68) ; PC216.2 v1(89.16,3.63) ; C2181.2 255.75,159.34 v1(256.28,159.87) ; v3(242.61,57.73) 241.9,57.73 241.4,57.23 C398.1 ; C345.2 264.33,34.57 v1(264.13,34.37) 264.56,33.94 C340.2 ; v1(42.77,67.39) 43.71,67.39 R280.2 ; v1(136.62,147.53) 136.62,147.83 136.98,148.19 C601.1 ; PU402.3 103.93,87.78 v1(103.98,87.84) ; C279.1 v1(13.81,116.89) ; C361.1 v1(280,31.07) ; C249.2 72.61,4.19 v1(73.2,4.78) ; PR225.1 v1(87.85,6.18) ; PR220.1 v1(84.81,4.02) ; v1(79.6,5.92) PR219.1 ; R2040.2 v1(23.59,87.96) ; v1(284.99,128.68) 284.94,128.73 C2176.2 ; D59.1 v1(18.63,79.95) ; v1(102.46,83.52) 102.53,83.52 PR433.1 ; PC414.2 PC415.2 100.43,88.67 v1(100.42,88.68) ; C2642.2 261.31,98.24 v3(261.63,97.92) ; v1(176.77,135.78) 177.01,135.55 C919.2 ; v1(186.37,144.19) 186.34,144.22 C872.2 ; v3(246.87,97.52) 246.93,97.58 C2675.2 ; v1(181.44,154.52) 181.48,154.56 C931.2 ; v2(41.65,58.53) 41.93,58.25 41.93,56.87 R324.1 ; v1(9.06,72.75) D57.1 ; v3(244.95,54.69) 244.75,54.89 R147.1 ; v3(232.63,170.15) 232.43,169.96 C2453.2 ; v3(246.87,93.52) 246.88,93.53 C2676.2 ; v1(160.31,135.78) 160.37,135.72 C916.2 ; D27.1 v1(13.94,134.32) ; v1(190.47,156.54) 190.34,156.42 ; v3(273.03,87.93) 274.27,87.93 C2638.2 ; v1(105.51,86.69) 106.01,86.19 PR406.2 ; C626.2 C627.1 ; C476.1 v1(50.39,7.45) ; C475.2 v1(51.28,7.45)
  TOP w0.457: C219.2 238.35,62.11 v3(238.35,62.56) ; v1(190.45,132.52) 190.45,132.25 PC1258.2 ; R476.1 R475.1 283.43,70.02 283.72,70.31 v1(283.81,70.31) ; v3(229.2,50.88) 229.08,51.01 C221.1 ; v1(57.82,10.62) PC313.2
  TOP w0.508: v1(223.87,121.36) 224,121.49 C693.2 ; PC314.2 38.45,5.16 37.82,4.52 v1(37.69,4.52) ; v1(217.15,169.89) 217.1,169.84 PC719.2 ; C463.2 v1(17.11,165.31) ; v1(222.09,127.84) 222.41,127.52 C687.2 ; PC214.2 94.14,7.26 v1(93.44,6.56) PC220.2 ; JBAT1.13 99.7,4.7 PH201.1 ; PR108.2 v1(78.25,94.19) ; C640.2 v1(72.99,22.18) ; PC215.2 93.7,9.22 v1(94.2,8.72) ; PC1539.2 v1(168.37,144.48)
  IN03 w0.356: v1(297.02,62.44) v1(297.02,60.91) v1(297.02,59.9) ; 288.89,58.25 289.66,57.48 v1(289.66,55.83) 289.66,54.82
  IN03 w0.381: v1(277.46,40.97) 277.65,40.78 277.65,40.53 278.1,40.08 280.51,40.08 281.78,41.35 288.01,41.35 v1(289.15,42.5) 289.97,43.32 289.97,45.67 290.48,46.18 v1(291.43,46.18) ; v1(284.83,44.02) 286.74,44.02 287.69,44.97 287.69,51.45 288.77,52.53 v1(288.77,53.04) 289.66,53.93 289.66,54.82 ; 288.89,58.25 288.89,59.77 288.39,60.28 281.78,60.28 v1(280.89,59.39) 280.89,56.98 v1(279.5,55.58) v1(278.86,54.94) 277.85,53.93 277.85,53.17 ; v1(284.32,62.94) 284.07,62.69 280.49,62.69 278.11,60.31 278.11,58.77 273.4,54.05 273.4,47.2 271.5,45.3 NUT3.1 269.98,43.77 v1(267.3,43.77) 267.3,41.1 267.94,40.47 268.85,40.47 v1(269.21,40.83) 273.38,40.83 273.78,41.23 v1(274.29,41.23) 274.29,41.86 275.81,43.39 v1(275.81,48.47) 275.81,52.15 276.83,53.17 277.85,53.17 ; 277.85,53.17 v1(277.85,51.9) ; v1(297.02,59.9) 297.02,58.5 296.51,57.99 293.21,57.99 292.2,56.98 292.2,52.28 290.16,50.24 290.16,48.09 v1(291.43,46.82)
  IN10 w0.381: 287.62,44.02 v1(284.83,44.02) v1(284.07,44.02) 276.58,44.02 274.29,41.74 v1(274.29,41.23) 274.92,40.59 277.08,40.59 v1(277.46,40.97) 277.97,41.48 284.83,41.48 286.28,40.03 286.28,38.13 286.99,37.42 289.15,37.42 289.4,37.16 289.4,36.15 v1(290.04,35.51) 290.05,35.52 290.05,39.21 290.16,39.32 290.16,41.48 v1(289.15,42.5) 287.62,44.02
  BOTTOM w0.089: 52.28,81.02 U2005.R23 ; v2(34.44,76.43) 34.25,76.62 U2007.E10 ; 30.5,46.69 C239.1
  BOTTOM w0.102: G2.P51 262.49,148.42 262.81,148.75 262.81,150.08 v3(261.79,151.1)
  BOTTOM w0.127: v3(248.59,143.2) 248.49,143.3 G2.AP45 ; v3(254.44,118.42) 254.79,118.76 G2.AE10 v3(254.79,120.17) ; G2.AP49 248.49,146.1 v3(248.86,145.72) ; G2.BC34 242.88,136.27 v3(242.89,136.27) ; G2.K8 265.29,117.27 v3(264.99,116.97) ; v3(261.09,120.17) G2.T10 ; G2.AY51 244.29,148.84 v3(244.14,148.99) ; v3(256.89,141.87) G2.AB43 ; v3(267.76,133.88) 267.66,133.88 267.37,134.17 G2.H31 ; v3(258.99,141.87) G2.W43 ; v3(242.88,123.67) G2.BC16 ; v3(242.67,121.39) 242.49,121.57 G2.BC13 ; v3(252.69,141.87) G2.AH43 ; v3(258.99,120.17) G2.W10 ; U2005.A6 U2005.B6 ; G2.AH45 252.69,143.16 v3(252.98,142.87) ; 54.12,81.02 U2005.W23 ; v3(250.59,141.87) G2.AL43 ; G2.K25 v3(264.59,129.97) ; v3(267.02,140.17) 266.99,140.17 G2.H40 ; G2.K34 v3(264.59,136.27) ; G2.AU47 G2.AU45 ; G2.BC19 v3(242.89,125.77) ; G2.K22 v3(264.59,127.87) ; v3(268.44,142.26) 268.75,142.57 G2.D43 ; G2.AH47 252.69,146.07 v3(252.81,146.19) ; G2.K37 v3(264.59,138.37) ; G2.AU49 246.39,145.96 v3(246.09,145.67) ; v3(265.49,115.74) 265.29,115.94 G2.K6 ; v3(267.54,132.27) 267.54,132.18 267.43,132.07 G2.H28 ; G2.AP10 v3(248.49,120.17) ; G2.AL10 v3(250.59,120.17) ; G2.K19 v3(264.59,125.77) ; G2.K40 v3(264.59,140.47) ; v3(261.09,141.87) G2.T43 G2.T45 ; v3(264.59,132.07) G2.K28 266.09,132.07 266.23,132.21 v3(266.23,132.25) ; v3(264.59,121.57) G2.K13 ; G2.N10 263.19,120.17 v3(263.19,120.17) ; G2.BC31 v3(242.89,134.17) ; G2.BJ7 237.46,117.37 ; G2.D31 269.09,134.17 v3(268.94,134.32) 268.79,134.17 G2.F31 ; v3(256.89,120.17) G2.AB10 ; v3(252.86,117.52) 252.69,117.34 G2.AH6 ; v3(263.19,141.87) G2.N43 ; G2.T47 261.09,144.66 v3(260.76,144.33) ; v3(265.89,140.62) 266.04,140.47 G2.H40 ; 252.69,115.9 G2.AH4 ; v3(242.88,132.07) G2.BC28 ; G2.H40 v3(266.99,140.77) ; v3(248.49,141.87) G2.AP43 ; v3(264.59,134.17) G2.K31 265.99,134.17 v3(266.24,134.42) ; G2.AH10 v3(252.69,120.17) ; G2.BC22 242.88,127.87 v3(242.89,127.87) ; v3(264.59,123.67) G2.K16 ; G2.AU10 v3(246.39,120.17) ; 248.49,144.63 G2.AP47 ; v3(254.79,141.87) G2.AE43
  BOTTOM w0.13: 256.89,144.73 G2.AB47
  BOTTOM w0.15: G2.K16 265.49,123.87 v3(265.84,123.87) ; G2.W43 258.99,142.57 ; v3(269.79,146.47) G2.D49 v3(269.79,147.07) ; v3(270.26,131.99) 270.08,132.17 269.59,132.17 G2.D28 269.32,132.23 v3(269.08,132.23) 269.03,132.23 268.56,131.77 v3(268.39,131.77) G2.F28 268.07,132.08 267.97,132.08 267.96,132.09 267.72,132.09 v3(267.54,132.27) ; v3(267.18,114.45) 267.18,114.43 267.29,114.33 267.29,113.97 G2.G2 ; v3(268.49,146.37) G2.E48 v3(268.49,145.77) ; G2.AH10 252.84,119.32 v3(252.84,119.02) ; v3(266.19,138.21) 266.53,138.21 G2.H37 ; G2.AL43 250.59,142.57 v3(250.99,142.97) ; G2.D16 269.82,124 270.22,124 v3(270.46,123.77) ; v3(255.08,145.67) G2.AE47 v3(254.49,145.67) ; v3(265.47,144.45) 265.47,144.95 v3(265.59,145.07) G2.K47 ; G2.W47 258.99,145.42 v3(259.3,145.74) ; v3(265.09,146.27) 265.24,146.42 265.24,146.72 G2.K49 ; G2.K47 265.54,145.62 v3(265.54,145.83) ; G2.K47 v3(264.99,145.07) ; v3(246.09,145.67) G2.AU47 v3(246.68,145.67) ; G2.AH45 252.69,143.97 ; v3(268.56,140.7) 268.32,140.7 G2.F40 v3(268.39,140.17) ; v3(243.89,145.77) 244.22,146.1 244.22,146.7 G2.AY49 ; v3(267.79,119.77) G2.F10 v3(268.39,119.17) ; v3(250.4,146.22) 250.4,146.46 250.59,146.64 G2.AL49 ; v3(258.79,118.97) 258.79,119.27 G2.W10 ; G2.K8 265.46,118.24 v3(265.76,118.24) ; G2.D37 v3(269.78,138.66) 269.94,138.66 v3(270.4,138.21) ; v3(258.82,146.31) 258.9,146.39 258.9,146.68 G2.W49 ; G2.T10 260.89,119.27 v3(260.89,118.97) ; 254.79,142.57 G2.AE43 ; v3(252.39,144.27) 252.84,144.72 v3(252.84,144.93) ; G2.AH8 252.86,117.89 v3(252.86,117.52) ; G2.AY49 244.29,146.8 244.39,146.9 244.39,146.9 v3(244.6,147.12) ; G2.AY49 v3(243.99,147.07) v3(243.99,147.87) ; G2.T45 261.09,143.97
  BOTTOM w0.152: U2005.AC6 U2005.AB6 ; v3(231.82,74.58) 231.82,74.45 232.13,74.15 232.13,73.79 232.67,73.25 U2.A32 ; U2005.J22 U2005.J23 ; U2005.AC12 U2005.AB12 ; U2005.E22 U2005.E23 ; v3(268.09,149.52) 268.09,150.1 268.45,150.46 v3(268.45,151.46) v3(268.45,152.35) ; U2.P45 226.39,66.35 v3(226.28,66.25) ; 54.12,81.02 U2005.W22 54.12,81.48 ; U2005.B20 U2005.A20 ; v3(225.75,59.64) 226.02,59.92 U2.AH45 ; v3(266.04,149.47) v3(266.04,150.45) 266.04,151.08 265.65,151.46 v3(265.53,151.46) ; U2005.B18 U2005.A18 ; U2.AU1 v3(248.5,55.33) ; U2005.U23 U2005.U22 ; U2005.L23 U2005.L22 ; v3(235.05,50.88) 235.05,51.01 234.93,51.13 U2.BE28 ; U2005.M1 U2005.M2 ; U2.BE37 230.09,51.11 v3(230.09,50.88) ; v3(225.65,57.48) 226.23,57.48 U2.AM45 ; U2005.A22 U2005.B22 ; U2005.A10 U2005.B10 ; v3(269.09,148.47) 269.11,148.49 269.11,149.84 269.59,150.32 269.59,152.63 269.51,152.71 v3(269.51,152.73) ; v2(55.21,80.6) 55.2,80.6 55.04,80.76 U2005.AA23 U2005.AA22 55.04,81.81 v2(55.09,81.86) U2005.AB22 U2005.AC22 ; v3(239.36,50.75) 239.36,51.26 U2.BE18 ; U2.A18 v3(239.48,73.61) ; U2005.AC16 U2005.AB16 ; U2005.B14 U2005.A14 ; U2005.H1 U2005.H2 ; U2005.G22 U2005.G23 ; U2.AC1 248.44,62.18 248.45,62.17 v3(248.48,62.17) ; U2.BE32 v3(232.65,50.88) ; v3(236.82,50.5) 237.25,50.92 237.25,51.32 U2.BE23 ; U2005.N22 U2005.N23 ; U2005.AC10 U2005.AB10 ; U2.BE14 241.75,50.97 v3(241.65,50.88) ; U2005.A12 U2005.B12 ; U2005.T1 U2005.T2 ; U2005.AB18 U2005.AC18 ; U2005.R22 52.28,81.02 ; v3(225.9,62.06) 226.26,62.06 U2.AC45 ; v3(248.89,59.52) 248.81,59.52 248.43,59.9 U2.AH1 ; U2005.P1 U2005.P2 ; U2005.B16 U2005.A16 ; U2005.A8 U2005.B8 ; U2005.K1 U2005.K2 ; U2005.AC8 U2005.AB8 ; U2005.AC20 U2005.AB20
  BOTTOM w0.178: v2(47.32,88.33) 47.32,88.34 U2005.D6 ; U2005.K2 49.92,90.6 v2(49.92,90.24) ; v2(50.57,82.48) 50.9,82.81 U2005.M19 ; 46.76,81.46 46.76,81.82 v2(46.71,81.87) ; 46.76,81.46 U2005.B22 ; 46.76,81.46 U2005.C22 U2005.C23 ; U2005.H8 v2(49.27,88.33) 49.59,88.01 U2005.J8 ; U2005.D13 47,85.37 v2(46.71,85.09) ; v2(46.72,87.03) 47,87.31 U2005.D9 U2005.E9 U2005.E11 ; U2005.H2 49.06,90.5 v2(49.27,90.28) ; U2005.T2 52.74,90.5 v2(52.52,90.28) ; U2005.Y13 54.8,85.46 v2(55.07,85.73) ; U2005.G22 48.6,81.85 v2(48.61,81.87) 48.32,82.16 U2005.F20 47.68,81.54 U2005.E22 ; U2005.R5 U2005.T5 ; U2005.M2 50.9,90.55 v2(50.65,90.3) ; v2(46.71,85.09) 47,84.8 U2005.D15 ; v2(46.71,85.09) 46.66,85.14 U2005.B14 ; v2(49.27,81.83) 49.52,81.59 U2005.J22 ; U2005.AB16 55.33,84.22 v2(55.12,84.43) ; U2005.D12 46.99,86.06 v2(46.69,86.36) 47,86.66 U2005.D11 ; v2(55.12,87.68) 55.34,87.9 U2005.AB8 ; U2005.AB14 U2005.AC14 ; v2(50.57,81.86) 50.44,81.72 U2005.L22 ; U2005.D8 47,88.05 v2(46.71,88.33) ; G2.AF38 254.09,139.24 G2.AF39
  BOTTOM w0.2: v3(265.59,136.57) 266.35,136.57 v3(266.36,136.58) ; G2.AM4 249.89,115.27 ; v3(269.09,136.55) 269.04,136.55 268.6,136.11 v3(268.53,136.11) ; v3(264.99,118.37) G2.K8 ; G2.F37 267.78,138.68 v3(267.76,138.68) ; G2.AF38 254.09,138.9 G2.AF37 ; G2.AP45 248.29,144.16 248.29,144.43 248.49,144.63 ; G2.F31 267.79,133.88 v3(267.76,133.88) ; v3(254.94,114.85) 254.94,115.12 G2.AE4 ; v3(261.19,147.67) 261.19,147.37 v3(261.49,147.07) 261.39,147.07 ; v3(267,138.66) 267.39,139.05 G2.G38 ; G2.K51 265.29,147.97 265.22,147.91 265.22,147.8 265.13,147.71 v3(265.13,147.7) ; G2.B52 v3(271.21,149.19) ; v3(267.79,136.67) 267.56,136.44 v3(267.21,136.44) ; G2.BF2 240.2,113.98 v3(240.2,114.63) ; v3(264.99,116.97) G2.K6
  BOTTOM w0.203: U1.AJ3 168.82,132.57 168.58,132.57 U1.AK4 U1.AL4 ; U1.AJ3 169.3,132.09 169.3,131.49 U1.AJ2 U1.AJ1 169.27,130.82 169.27,130.27 v1(169.27,130.27) ; U1.AJ3 169.15,132.12 v1(168.83,131.79) ; 176.06,134.48 175.65,134.48 175.55,134.37 175.44,134.37 U1.AB6 U1.AC6 174.3,134.15 174.01,134.45 v3(174,134.45) 173.85,134.45 U1.AD6 U1.AE6 172.54,134.07 172.28,133.82 172.28,133.26 171.79,132.77 ; U1.H11 185.4,137.21 185.32,137.13 U1.J10 ; U1.AM4 166.83,132.7 166.83,132.19 U1.AM3 U1.AM2 U1.AM1 v1(166.76,130.27) ; D60.1 14.69,82.44 v1(14.78,82.35) ; v1(148.68,133.71) 148.77,133.63 U1.BT5 ; U2.N41 228.31,67.35 U2.M42 228.32,68.22 U2.L41 228.16,68.52 U2.K42 227.48,68.84 U2.K43 ; U2.D17 240.42,72.03 v3(240.53,72.03) 240.67,72.03 241.11,71.59 U2.D15 241.27,71.03 U2.E15 ; U1.C9 188.6,135.97 188.05,135.97 U1.D9 ; U2005.J13 v2(49.92,85.73) 49.6,86.06 U2005.J12 ; U1.BM18 151.89,142.75 151.29,142.75 U1.BN18 ; U2005.T5 52.85,89.31 v2(53.17,88.98) ; U1.F11 186.7,137.5 186.7,137.43 v1(187.02,137.1) ; JDIMM1.9 134.57,86.48 134.27,86.19 v1(134.27,85.8) ; v2(53.82,85.73) U2005.W13 ; U1.BJ31 153.42,152.89 v1(153.09,152.56) 153.35,152.31 153.48,152.31 U1.BJ30 ; v2(47.31,89.64) 47,89.32 U2005.D5 ; U1.A12 v1(190.58,138.28) ; v1(51.79,45.8) 52.11,45.48 U22.11 ; v1(165.8,135.78) 165.8,136.42 v1(165.8,136.42) ; v1(165.8,135.78) 165.39,135.38 U1.AP8 165.78,134.94 165.78,134.59 165.92,134.45 U1.AN6 165.87,134.02 U1.AN5 166.2,133.09 v1(166.37,133.09) 166.69,133.42 U1.AM5 ; v1(165.8,135.78) 165.55,136.03 U1.AP9 ; U1.G8 185.62,134.71 U1.J7 185.09,134.47 v1(184.84,134.47) ; v2(52.52,83.13) 52.2,83.46 U2005.R18 ; v2(52.52,83.13) 52.85,83.46 U2005.T18 ; v2(52.52,83.13) 52.2,82.81 U2005.R19 ; U2.C37 U2.B37 230.31,72.44 230.31,72.9 230.37,72.96 U2.A37 230.37,73.09 v3(229.97,73.49) ; v3(271.84,117.12) 271.55,117.4 270.92,117.4 G2.B7 270.77,117.37 v3(270.48,117.08) ; v2(35.33,73.38) 35.25,73.3 U2007.C2 ; U1.A22 v1(190.58,146.16) ; U2005.V16 v2(53.17,84.43) 52.85,84.11 U2005.T16 v2(52.52,84.43) 52.85,84.76 U2005.T15 52.85,84.76 v2(53.17,85.08) ; v2(53.17,88.98) 53.5,88.66 U2005.V6 53.5,88.66 v2(53.82,88.33) ; v2(53.17,88.98) U2005.V5 53.5,89.31 v2(53.82,88.98) U2005.W5 ; U1.C13 188.65,139 v1(188.97,138.68) ; U2005.H12 48.95,86.06 v2(49.27,85.73) ; U2005.F9 U2005.E8 47.64,88.01 v2(47.32,88.33) 47.65,88.66 U2005.E6 ; U1.A4 190.18,132.79 v1(190.45,132.52) 190,132.07 U1.A3 ; U1.BL29 152.52,151.39 151.97,151.39 U1.BM29 ; 174.48,137.98 U1.AC12 ; 174.48,137.98 174.63,138.12 175.25,138.12 U1.AA12 ; 174.48,137.98 174.31,137.98 v1(174.03,137.69) ; U2005.J20 49.6,82.16 v2(49.27,81.83) 48.95,82.16 U2005.H20 ; U1.AR5 U1.AR4 U1.AR3 163.92,131.79 v1(163.8,131.79) 164.12,131.47 U1.AR2 U1.AR1 ; v1(179.52,137.05) 179.43,137.05 U1.T10 ; U2005.J19 49.6,82.81 v2(49.92,83.13) 49.6,83.46 U2005.J18 U2005.H16 U2005.H15 v2(49.27,85.08) ; v1(188.7,132.11) 188.79,132.2 U1.B3 ; v1(188.7,132.11) 188.18,132.11 U1.D3 187.86,132.32 187.82,132.32 U1.E4 187.22,132.92 186.84,132.92 U1.F4 ; v1(188.7,132.11) 188.59,132 U1.C2 ; U2.AY45 226.21,53.55 v3(225.9,53.55) ; U2.V45 226.39,64.32 226.03,63.96 v3(225.93,63.96) ; U1.A16 v1(190.58,141.43) ; v3(243.94,50.75) 244.04,50.86 U2.BE9 ; G2.AF45 254.39,144.27 v3(254.49,144.27) G2.AE45 254.97,143.79 v3(254.97,143.52) ; U1.A28 190.4,151.34 v1(190.85,151.34) ; v1(186.37,136.32) 186.05,135.99 U1.G9 ; U1.AF4 171.79,132.77 ; 171.79,132.77 171.79,132.12 ; U1.BH8 U1.BH7 154.37,134.38 154.23,134.24 154.23,134.11 U1.BH6 ; U1.BE1 U1.BE2 ; v1(165.8,137.69) 165.51,137.98 U1.AP12 ; v1(165.8,137.69) 165.8,137.69 v1(165.8,137.05) ; v1(165.8,137.69) 166.08,137.98 U1.AN12 166.51,138.24 166.8,138.24 167.06,137.98 U1.AM12 167.33,138.14 167.82,138.14 167.98,137.98 U1.AL12 168.43,138.33 v1(168.54,138.33) ; U2005.N13 51.55,85.41 v2(51.22,85.08) U2005.N15 ; U2.D12 242.37,71.08 U2.E13 ; U1.N11 182.07,137.05 v1(182.26,137.05) ; v1(165.8,136.42) v1(165.8,137.05) ; v1(165.8,136.42) 165.54,136.68 U1.AP10 ; v1(165.8,137.05) 165.62,137.05 U1.AP11 ; v3(259.28,143.66) 259.28,143.68 G2.W45 258.73,144.22 v3(258.73,144.4) ; v1(185.61,133.09) 185.93,132.77 U1.G4 186.16,132.92 186.53,132.92 U1.F4 ; v1(185.61,133.09) 185.93,133.42 U1.G5 ; v1(185.61,133.09) 185.52,133.09 U1.J4 U1.K4 ; v2(46.72,87.03) 46.67,86.98 U2005.B10 ; G2.AB8 256.89,118.07 v3(257.22,117.73) ; G2.AB8 v3(256.59,117.77) ; G2.AB8 256.59,118.37 v3(256.59,118.47) ; U1.BM26 151.92,149.01 v1(152.24,148.68) ; U1.BE3 U1.BE4 U1.BE5 ; v2(51.22,87.03) U2005.N9 ; v2(51.22,87.03) U2005.M11 ; v2(51.22,87.03) U2005.N11 ; v1(174.03,136.42) U1.AD9 ; 186.46,131.79 186.79,132.11 U1.F3 186.79,132.66 U1.F4 ; 186.46,131.79 v1(186.39,131.79) ; 186.46,131.79 186.46,131.79 186.79,131.47 U1.F2 ; U1.N1 181.87,130.8 181.87,130.06 v1(181.85,130.04) ; U1.A9 U1.B9 189.3,135.85 v1(188.97,135.53) 188.65,135.2 U1.C8 188.65,135 U1.D6 ; U1.K5 184.43,133.35 184.43,132.84 U1.K4 ; U2005.B18 46.72,83.72 v2(46.72,83.76) ; v1(148.18,149.47) 148.62,149.03 149.27,149.03 U1.BT26 ; v1(176.37,131.79) 176.49,131.79 U1.W2 U1.W1 176.82,130.33 v1(176.37,129.89) ; U1.A24 v1(190.58,147.73) ; U1.G5 186.14,133.56 U1.F5 ; U1.G5 186,133.49 186.06,133.54 186.06,134.01 U1.G6 ; U1.AF2 171.81,131.49 171.81,132.09 171.79,132.12 ; U1.AF2 U1.AF1 171.79,130.82 171.79,130.27 v1(171.79,130.27) ; U1.AF2 171.66,131.47 171.36,131.76 v1(171.35,131.76) ; U2005.J15 49.59,84.76 v2(49.27,85.08) ; v1(134.47,72.6) 134.47,72.96 134.8,73.28 JDIMM3.9 ; U2005.N20 51.57,82.16 v2(51.85,81.88) ; U1.BJ32 153.41,153.54 v1(153.09,153.86) ; U1.A14 v1(190.58,139.86) ; U1.H25 U1.J25 ; U1.K4 184.41,132.72 184.41,132.12 U1.K3 ; v1(151.59,140.02) 151.27,139.7 151.27,139.63 U1.BN14 ; U2005.R22 52.27,81.46 v2(51.85,81.88) ; U2005.N12 51.55,86.06 v2(51.22,85.73) 50.9,86.06 U2005.M12 ; U1.E38 186.97,157.37 186.97,156.5 v1(186.95,156.47) ; U2005.W20 54.12,82.16 v2(53.82,81.86) ; U2005.L13 50.25,85.41 v2(49.92,85.08) ; v2(55.07,85.73) 55.4,86.06 U2005.AB12 ; v2(55.12,87.68) 54.8,87.36 U2005.Y9 55.18,86.98 U2005.AB10 ; U1.AC1 U1.AC2 U1.AC3 174.18,132.12 v1(173.86,132.44) 174.18,132.77 U1.AC4 U1.AC5 ; v1(187.82,133.07) 188.15,133.07 U1.C5 ; v1(153.77,133.74) 153.67,133.74 U1.BK6 U1.BL6 ; U1.J18 v1(184.13,143.01) ; 52.85,88.66 U2005.T6 ; U1.W3 U1.W4 176.86,132.81 176.86,133.37 U1.W5 ; U1.BM2 151.89,132.35 U1.BM3 151.81,132.43 151.32,132.92 U1.BN4 ; U2005.V9 U2005.V8 53.5,88.01 v2(53.82,88.33) ; v2(51.85,81.88) 52.13,82.16 U2005.R20 52.2,82.16 ; v1(170.37,138.29) 170.19,138.11 170.18,138.11 170.05,137.98 U1.AH12 ; U2005.L20 50.27,82.16 v2(50.57,81.86) 50.87,82.16 U2005.M20 ; U1.F8 186.7,135.2 v1(187.02,135.53) ; v1(184.84,134.47) 184.84,134.98 184.47,135.35 184.47,135.38 U1.K8 184.53,135.44 184.53,135.96 U1.K9 184.47,136.03 184.53,136.09 184.53,136.61 184.47,136.68 U1.K10 184.53,136.74 184.53,137.26 U1.K11 ; v1(184.84,134.47) 184.64,134.47 184.59,134.53 U1.K7 ; U2005.E5 47.65,89.31 v2(47.97,89.63) ; U2005.F5 48.29,89.31 v2(47.97,89.63) ; U1.BJ29 154.02,151.31 v3(154.3,150.99) ; U2005.F6 U2005.H8 ; v1(154.38,130.08) 153.93,130.53 U1.BH1 153.93,131.05 154.19,131.3 U1.BH2 154.05,131.6 153.93,131.6 v1(153.74,131.79) ; U1.BT14 149.42,139.53 149.87,139.53 U1.BR14 150.04,139.55 150.54,139.55 U1.BP14 ; U2005.F16 U2005.E16 47.64,84.11 v2(47.32,84.43) 47.65,84.76 U2005.E15 ; v1(174.03,137.69) U1.AD11 ; v1(174.03,137.69) 173.74,137.98 173.57,137.98 U1.AD12 ; U1.BT4 148.84,132.83 v1(148.71,132.77) ; v1(178.88,129.85) 179.35,130.32 179.35,130.8 U1.T1 179.38,130.86 179.38,131.42 U1.T2 ; v2(53.82,88.33) U2005.W6 ; v2(53.82,88.33) 54.15,88.01 U2005.W8 U2005.W9 ; G2.AH10 v3(252.29,119.07) ; v3(268.44,142.26) 268.13,142.57 G2.F43 268.09,142.57 v3(267.79,142.87) 267.79,142.97 G2.F44 v3(268.39,142.97) ; U2.AU45 226.16,55.11 v3(226.16,54.94) ; v2(46.69,86.36) 46.4,86.06 U2005.B12 ; U1.T4 179.35,132.79 179.35,133.4 U1.T5 ; U1.G20 186.05,144.52 v1(186.37,144.19) ; U1.H12 U1.G12 ; 171.79,132.12 U1.AF3 ; 148.9,155.71 149.67,155.71 149.98,156.01 U1.BR36 ; U1.A20 v1(190.58,144.58) ; U1.T3 179.2,132.12 v1(178.89,131.81) ; v1(187.02,135.53) 187.35,135.85 U1.E9 ; v1(187.02,135.53) 186.7,135.85 U1.F9 ; U1.Y13 176.58,138.36 176.85,138.36 U1.W12 177.46,138.21 177.91,138.21 U1.V12 ; 54.12,81.48 54.12,81.56 v2(53.82,81.86) ; U2005.B20 46.62,82.38 v2(46.72,82.48) ; v1(142.27,88.98) 142.25,89.01 141.62,89.01 141.07,88.45 JDIMM1.35 ; v1(161.29,131.79) 161.61,132.12 U1.AW3 U1.AW4 U1.AW5 161.92,133.42 U1.AU6 ; U1.BT21 149.16,144.99 148.86,144.99 v3(148.31,145.55) ; v1(148.71,131.92) 148.83,132.03 149.24,132.03 U1.BT3 ; U1.BN24 151.67,147.1 151.67,147.1 151.92,146.85 151.92,146.72 U1.BM23 ; U2.D24 236.56,71.59 236.13,72.02 v3(235.98,72.02) ; U1.AW1 U1.AW2 ; U1.BB1 U1.BB2 ; U2.D19 238.85,71.59 238.41,72.03 v3(238.25,72.03) ; U1.AD10 v1(174.03,137.05) ; U2005.H13 48.95,85.41 v2(49.27,85.08) ; U2005.W18 54.15,83.46 v2(53.82,83.13) ; U1.BA6 U1.BB6 ; v2(53.82,81.86) 53.52,82.16 U2005.V20 ; U1.A18 190.49,143.01 v1(190.59,142.91) ; v2(46.71,88.33) 46.3,87.92 U2005.B8 ; v1(43.91,79.45) 43.91,79.53 44.7,80.32 45.23,80.32 45.44,80.52 45.44,81.06 U2005.A22 ; 261.39,147.07 G2.T49 261.04,146.72 261.04,146.49 260.89,146.33 v3(260.89,146.22) 260.94,146.22 v3(261.39,145.77) ; U1.D12 188.17,138.11 188.36,137.92 188.36,137.78 U1.C11 188.65,137.43 v1(188.97,137.1) ; v3(247.03,58.75) 246.61,58.33 U2.AL4 ; U1.C21 188.37,145.65 188.37,145.79 U1.D22 ; U1.D30 187.6,152.06 187.02,152.06 ; v2(47.97,89.63) U2005.E4 ; U1.BJ12 153.54,138.02 v1(153.91,137.65) ; U1.J22 v1(184.12,146.16) ; U1.AG10 170.85,136.68 171.2,137.03 v1(171.29,137.03) ; v2(46.69,88.98) 46.53,88.82 U2005.B6 ; U1.K2 184.46,131.37 184.46,130.91 U1.K1 184.41,130.77 184.41,130.08 v1(184.37,130.04) ; v3(266.99,130.27) 266.69,129.97 G2.H25 v3(266.39,129.67) ; D61.1 13.52,83.74 v1(13.51,83.75) ; C208.1 242.54,45.75 242.54,43.92 242.79,43.67 245.31,43.67 245.54,43.89 245.54,45.8 C205.1 ; U2005.Y13 55.07,85.14 U2005.AB14 ; U1.BF12 156.44,138.22 156.87,138.22 U1.BD12 157.28,137.98 v1(157.57,137.69) ; v2(53.17,85.08) U2005.V15 ; v2(53.17,85.08) 52.85,85.41 U2005.T13 ; v1(152.24,150.26) 152.24,150.19 U1.BM27 ; U1.A10 v1(190.58,136.71) ; 155.02,134.07 U1.BF6 ; v3(268.95,130.17) 269.14,130.17 269.34,129.97 G2.D25 269.49,129.91 v3(269.77,129.62) 269.77,129.56 G2.D24 ; U2005.D16 46.99,84.11 v2(46.67,84.43) 46.46,84.22 U2005.B16 ; v2(56.48,80.98) 56,81.46 U2005.AC22 ; U1.BA12 160.02,137.98 v1(160.31,137.69) ; U1.AG8 171.23,135.78 v1(171.28,135.78) ; 153.87,140.42 U1.BJ15
  BOTTOM w0.25: v3(268.42,138.05) 268.41,138.05 G2.F37 ; v3(242.56,149.41) 242.45,149.52 241.78,149.52 v3(241.58,149.32) ; 237.29,113.17 G2.BK1 237.29,112.79 v3(237.22,112.72) ; v3(267.76,138.68) 267.76,138.7 G2.G38 ; v3(248.59,143.2) 248.63,143.15 248.63,142.71 G2.AP43 ; G2.V37 259.39,138.67 v3(259.39,138.72) 259.39,138.77 G2.V38 ; v3(259.28,143.66) 259.28,142.88 v3(259.29,142.87) 258.99,142.57 ; G2.AW52 v3(244.69,149.17) 244.31,149.17 v3(244.14,148.99) ; v3(264.99,145.07) 264.99,144.93 v3(265.47,144.45) ; G2.BL10 236.66,119.54 237.03,119.54 237.2,119.71 v3(237.59,119.71) 237.74,119.71 G2.BJ10 ; G2.K40 265.44,140.62 v3(265.89,140.62) ; v3(266.04,149.47) 265.99,149.42 G2.J52 ; G2.J49 265.64,147.12 v3(265.56,147.12) 265.56,147.04 G2.K49 ; G2.BG31 v3(239.69,134.47) ; v3(239.84,126.02) 239.64,126.02 G2.BG19 ; v3(268.6,117.62) 268.6,117.88 G2.E8 ; v3(254.5,115.68) 254.38,115.68 G2.AF5 ; G2.AT8 v3(246.69,118.47) ; v3(261.49,147.07) G2.R49 ; v3(268.47,115.6) 268.49,115.62 268.49,115.67 G2.E5 ; v3(252.77,147.53) 252.62,147.38 252.62,146.84 G2.AH49 252.81,146.64 v3(252.81,146.19) ; G2.T8 260.85,117.83 v3(260.85,117.5) 260.52,117.5 G2.U7 ; v3(267,138.66) 266.97,138.66 266.69,138.37 G2.H37 ; G2.G51 G2.F52 v3(268.09,149.52) ; G2.W49 v3(259.33,147.11) 259.68,146.77 G2.V49 ; v3(263.54,116.97) 263.84,116.67 G2.M6 ; G2.R52 v3(261.79,149.33) ; G2.BE31 v3(240.49,133.87) ; G2.F17 268.39,124.07 v3(268.39,124.02) 268.39,123.97 G2.F16 ; v3(246.15,117.71) 246.15,117.83 G2.AU8 ; G2.BE21 v3(241.09,127.47) ; G2.G6 267.39,116.76 v3(267.09,117.06) ; G2.AF29 v3(253.79,133.07) G2.AG30 G2.AG31 G2.AG32 253.39,134.87 253.09,135.17 v3(253.09,135.22) ; v3(269.87,149.31) 269.87,149.19 G2.C52 270.39,149.08 v3(270.39,149.61) ; G2.BE18 v3(241.09,125.37) ; G2.AF1 v3(254.09,112.69) ; v3(257.19,147.07) 257.29,147.07 G2.AA49 ; v3(243.89,145.77) G2.BA48 ; G2.T6 261.39,116.97 v3(261.39,117.07) ; v3(252.84,144.93) 252.84,145.22 G2.AH47 ; v3(252.82,114.28) 253.1,114.28 G2.AG3 253.39,114.57 253.09,114.87 v3(252.84,114.87) ; v3(250.3,117.05) 250.3,116.96 G2.AL6 ; v3(267.1,147.17) 267.1,147.06 G2.G49 ; v3(242.04,114.51) 242.04,115.12 G2.BC4 242.19,115.27 ; G2.AY8 v3(244.59,117.77) ; v3(246.1,118.52) 246.1,118.54 245.87,118.77 G2.AV9 ; G2.BE30 v3(241.09,133.77) ; G2.AY10 v3(243.99,119.17) ; v3(261.19,147.67) 261.09,147.77 G2.T51 ; G2.BE10 v3(240.49,119.17) ; G2.BE19 v3(240.49,125.47) ; 267.61,114.83 v3(267.61,114.83) 267.61,115.08 267.42,115.27 G2.G4 ; G2.V52 v3(259.69,149.35) ; v3(266.19,138.21) 265.73,138.67 v3(265.59,138.67) G2.J38 ; v3(265.09,146.27) 265.1,146.27 v3(265.54,145.83) ; 254.79,142.57 254.49,142.87 v3(254.49,142.94) ; G2.V39 259.39,139.47 v3(259.39,139.42) ; G2.D31 269.79,133.87 v3(269.89,133.87) G2.D30 ; v3(257.19,114.97) G2.AB4 ; G2.AA8 v3(257.17,118.49) ; G2.BG10 v3(239.69,119.77)
  BOTTOM w0.254: G2.B13 270.5,121.57 v3(270.33,121.4) ; U1.BB6 159.1,134.07 v1(158.77,133.74) ; R2315.1 74.21,87.71 v1(73.5,87.71) ; G2.B28 270.34,132.07 v3(270.26,131.99) 270.26,132.69 G2.C29 ; 207.89,108.79 207.7,108.6 207.27,108.6 207.09,108.78 U25.6 ; v3(267.79,142.87) 267.67,142.75 v3(267.14,142.75) 266.87,142.75 G2.H43 ; v1(185.1,64.6) 185.05,64.65 JDIMM3.202 ; 185.97,186.57 185.98,186.56 PU1602.5 ; R392.1 65.12,94.44 64.23,95.33 v1(64.23,95.71) ; U2.H17 239.93,69.27 v3(239.47,69.27) 239.3,69.27 U2.H19 ; 176.7,136.42 176.57,136.42 U1.Y10 ; 176.7,136.42 v1(176.77,136.42) ; 176.7,136.42 U1.Y9 ; v3(225.52,71.9) 225.78,71.64 U2.D45 ; v1(149.64,142.38) 149.64,142.45 ; 149.64,142.45 U1.BR18 150.29,142.45 ; 149.64,142.45 U1.BT18 ; v3(229.2,50.88) 228.75,51.34 U2.BE40 ; JDIMM1.239 194.07,88.62 v1(193.71,88.98) 193.39,88.98 193.07,88.66 JDIMM1.235 ; Q6.4 77.18,96.21 v1(77.44,96.47) ; v3(265.47,144.45) 265.47,144.15 G2.K45 ; JIO1.37 302.45,38.52 v1(303.37,39.45) ; U2.D30 233.78,71.59 U2.D29 234.58,71.45 v3(234.92,71.45) ; R408.2 10.89,160.3 v1(11.65,160.3) 12.42,160.3 R807.2 ; 184.63,199.09 185.52,199.09 185.95,198.66 PR1313.2 ; JDIMM1.213 187.57,88.87 187.68,88.98 v1(188.5,88.98) 188.57,88.91 JDIMM1.217 ; U1.AC1 v1(174.3,130.27) ; R393.1 R394.1 R397.1 R398.1 R399.1 R391.1 R390.1 v1(71.6,96.73) ; U1.BP7 150.62,134.97 v1(150.29,135.3) 149.97,134.97 U1.BR7 ; U1.BR34 U1.BP34 150.62,154.52 v1(150.94,154.2) ; JDIMM3.40 142.55,64.65 v1(142.6,64.6) 141.6,64.6 141.55,64.65 JDIMM3.36 ; JDIMM3.172 177.55,64.63 v1(177.52,64.6) 177.9,64.6 178.55,65.25 JDIMM3.176 ; JDIMM3.64 148.55,65.04 v1(148.1,64.6) ; v3(240.49,131.77) G2.BE28 ; U1.BM13 151.92,138.77 v1(152.24,138.45) 152.24,138.38 U1.BM12 ; G2.D13 269.79,121.27 v3(269.79,121.17) 269.49,120.87 G2.D12 ; JDIMM3.184 180.55,65.04 v1(180.1,64.6) 179.55,65.15 JDIMM3.180 ; v3(246.69,143.62) 246.39,143.92 G2.AU45 ; G2.A50 v3(272.04,147.47) ; U1.BM7 151.83,134.99 151.83,135.6 U1.BM8 151.79,135.82 151.79,136.35 U1.BM9 151.92,136.55 v1(151.59,136.87) 151.59,136.8 U1.BN9 ; U2.C42 228.46,72.04 228.5,72 ; Q82.1 282.3,174.7 281.91,175.09 v1(281.78,175.09) ; PC1081.1 v1(235.55,195.66) ; JDIMM1.99 157.07,88.72 156.81,88.98 v1(155.61,88.98) ; PU1606.19 243.12,199.38 PU1606.26 ; R2237.1 R2236.1 85.52,81.94 v1(85.82,82.25) ; v1(301.34,41.86) 301.08,42.12 JIO1.28 ; 159.1,89.61 159.07,89.58 JDIMM1.107 ; 159.1,89.61 v1(160.18,89.61) ; 159.1,89.61 158.85,89.61 158.47,89.23 158.47,88.93 158.07,88.53 JDIMM1.103 ; G2.C5 v3(270.49,115.67) ; G2.BG13 239.39,121.57 v3(239.69,121.87) ; JDIMM3.234 193.05,65.19 193.64,64.6 194.03,64.6 ; v3(236.29,115.67) G2.BL5 ; G2.H1 266.74,113.11 266.74,111.9 267.29,111.34 v3(267.47,111.34) 267.58,111.34 267.93,111.69 267.93,112.14 267.55,112.51 v3(267.47,112.51) ; U1.BA8 159.91,135.38 v1(160.31,135.78) ; v3(242.43,148.58) 241.77,148.58 G2.BD52 241.49,149.23 v3(241.58,149.32) ; v3(252.82,114.28) 252.69,114.15 G2.AH2 ; U1.N33 181.51,154.52 ; 181.51,154.52 v1(181.44,154.52) ; 181.51,154.52 U1.N34 ; U1.BA11 160.22,137.69 v1(160.31,137.69) 160.6,137.98 U1.AY12 U1.AW12 161.91,137.75 162.37,137.75 U1.AU12 U1.AU11 U1.AU10 162.6,136.66 162.86,136.4 162.99,136.4 ; 162.99,136.4 162.61,136.03 U1.AU9 ; 162.99,136.4 v1(163.05,136.4) ; v1(16.61,162.02) 16.59,162.03 R409.2 ; U2026.N1 v3(243.47,94.72) ; v1(154.83,137.05) 154.64,137.05 U1.BH11 ; 186.37,147.27 U1.F23 186.7,146.88 v1(186.37,146.55) ; 186.37,147.27 v1(186.37,147.34) ; 186.37,147.27 U1.G23 186.15,146.84 186.15,146.77 v1(186.37,146.55) ; v1(159.1,64.6) 159.1,64.85 159.05,64.9 JDIMM3.106 ; PC3579.2 208.15,119.61 v1(208.17,119.61) ; v1(160.96,154.52) 160.9,154.52 ; 160.9,154.52 U1.AY34 ; 160.9,154.52 U1.AY33 ; v3(252.84,114.87) 252.84,115.12 G2.AH4 ; G2.BL2 v3(236.14,113.42) 235.89,113.67 G2.BM2 ; U2.AR42 228.06,56.59 v3(228.7,56.59) 229.2,57.1 U2.AN39 ; v1(186.37,146.55) 186.37,146.48 U1.G22 186.05,146.09 v1(186.37,145.76) 186.37,145.69 U1.F21 186.7,145.3 v1(186.37,144.98) ; JEC1.28 55.97,49.83 56.07,49.74 v1(56.61,49.74) ; PU902.5 270.7,198.23 v1(270.86,198.07) ; PU901.19 255.31,199.38 PU901.26 ; JDIMM3.56 146.55,65.15 v1(147.1,64.6) 147.55,65.04 JDIMM3.60 ; v1(234.31,198.1) 234.17,198.23 PU1002.5 ; JDIMM3.73 150.8,75.75 v1(150.27,76.28) 149.8,75.81 JDIMM3.69 ; U1.M14 U1.M13 U1.M12 182.54,137.98 v1(182.26,137.69) 181.97,137.98 U1.N12 181.67,138.11 181.02,138.11 U1.P12 180.75,138.11 180.1,138.11 U1.R12 179.8,137.98 v1(179.51,137.69) ; U2.AU35 231.13,55.43 v3(230.98,55.58) ; v1(150.94,154.2) 150.62,153.87 U1.BP33 ; v1(150.94,154.2) 151.27,154.52 U1.BN34 ; U1.AT6 163.26,134.07 U1.AU7 ; v1(305.53,94.24) 305.48,94.24 305.02,94.69 PR3412.2 ; JDIMM1.181 179.57,88.81 v1(179.74,88.98) 180.31,88.98 180.57,88.72 JDIMM1.185 ; v1(191.6,64.6) 191.74,64.73 191.75,64.73 192.05,65.03 JDIMM3.230 ; v1(166.37,133.09) 166.53,132.92 166.57,132.92 166.73,132.77 U1.AM4 ; v1(179.51,137.69) 179.23,137.98 U1.T12 U1.T13 178.92,138.63 v1(178.6,138.95) 178.92,139.28 U1.T14 ; v1(179.51,137.69) 179.42,137.69 U1.T11 ; v3(272.19,114.57) 272.18,114.57 G2.A3 ; 176.55,64.65 176.05,65.15 JDIMM3.166 ; 176.55,64.65 v1(176.6,64.6) ; 176.55,64.65 JDIMM3.168 ; 187.02,152.06 186.7,151.74 U1.F29 186.7,151.6 v1(187.02,151.28) ; v3(241.83,136.63) 241.49,136.97 G2.BD35 ; U2.G42 227.5,70.12 v3(227.36,70.12) 227.3,70.18 227.3,70.29 226.96,70.63 U2.F44 ; G2.AP47 248.51,145.37 v3(248.86,145.72) ; v1(280.77,77.17) 280.75,77.18 JWLAN1.1 ; U2.AC25 236.06,62.55 v3(236.06,62.56) ; v3(250.99,142.97) G2.AK44 ; v1(152.24,148.68) U1.BM25 ; U2019.6 v1(84.15,86.8) ; v3(227.36,67.75) 227.38,67.78 U2.M42 ; G2.B22 270.49,127.87 v3(270.34,127.72) 270.05,128 269.62,128 G2.D22 ; U1.BM11 151.92,137.29 151.59,137.62 v1(151.59,137.66) 151.27,137.98 U1.BN12 151.14,138.18 150.75,138.18 U1.BP12 150.49,137.93 150.1,137.93 U1.BR12 U1.BT12 148.85,138.05 v1(148.72,138.18) ; v1(150.94,140.02) 150.94,140.02 150.95,140.01 150.95,139.96 U1.BP14 ; JDIMM3.14 136.05,65.15 v1(136.6,64.6) ; U1.AG11 170.85,137.33 171.19,137.67 v1(171.28,137.67) 171.45,137.67 171.74,137.95 U1.AF12 U1.AF13 U1.AF14 171.74,139.4 171.96,139.62 v1(171.96,140.47) ; JDIMM1.197 183.57,88.7 v1(183.29,88.98) 182.72,88.98 182.57,88.83 JDIMM1.193 ; 164.83,157.12 U1.AR38 ; 164.83,157.12 U1.AR37 ; 164.83,157.12 v1(164.9,157.12) ; JDIMM1.171 177.07,88.66 176.75,88.98 v1(176.44,88.98) 176.07,88.61 JDIMM1.167 ; JDBUG1.5 36.11,6.25 35.08,5.21 v1(35.08,4.52) ; v3(230.22,58.83) 230.55,59.16 U2.AJ36 ; Q83.1 v1(302.24,124.91) ; U2005.T9 U2005.V8 ; v1(186.95,156.47) 186.88,156.47 U1.F36 ; G2.E4 268.8,115.27 v3(269.12,114.95) ; JIO1.43 302.08,36.12 v1(302.23,36.27) ; v1(176.37,131.79) 176.54,131.96 176.66,131.96 U1.W3 ; U1.BF12 155.99,138.18 155.77,138.18 155.32,138.63 U1.BG13 U1.BG14 ; 194.03,64.6 v1(194.6,64.6) 194.99,64.6 195.55,65.16 JDIMM3.244 ; 194.03,64.6 194.05,64.62 JDIMM3.238 ; G2.AU2 246.39,114.17 v3(246.51,114.29) ; G2.AM9 249.9,118.77 v3(250.25,119.12) ; JDIMM3.192 182.55,65.04 v1(182.1,64.6) ; R2138.1 v1(86.33,89.87) ; U1.F36 186.26,155.85 186.13,155.85 U1.H35 185.12,156.14 U1.J36 ; U1.F36 186.89,155.8 v1(186.96,155.8) 187.28,155.49 U1.E35 187.34,154.82 U1.E34 187.28,154.75 187.26,154.75 v1(186.98,154.48) 187.03,154.43 187.63,154.43 188,154.06 U1.D33 ; v1(19.48,55.1) 19.32,55.25 D33.3 ; U1.BF33 155.92,154.19 v1(156.24,154.52) 155.92,154.84 U1.BF34 ; U1.BA37 159.85,156.79 v1(160.18,157.12) 160.11,157.12 U1.BA38 ; U2.AU36 230.65,55.25 v3(230.98,55.58) ; U2.AT36 230.69,55.87 v3(230.98,55.58) ; 185.31,153.87 v1(185.37,153.87) 185.7,153.54 U1.H32 ; 185.31,153.87 U1.J32 ; 185.31,153.87 U1.J33 ; v3(265.49,115.74) 265.49,115.47 G2.K4 265.37,115.18 v3(265.37,114.6) 265.29,114.51 G2.K2 ; v1(157.57,137.05) 157.49,137.05 ; 157.49,137.05 U1.BD10 ; 157.49,137.05 157.39,137.05 U1.BD11 ; v1(148.95,136.05) 149.32,136.42 U1.BT9 ; v1(190.85,151.34) 190.85,151.72 190.47,152.1 189.07,152.1 188.65,151.67 U1.C29 188.32,151.99 188.32,152.13 U1.D30 ; U58.3 v1(44.91,37.02) ; U2005.AB18 55.31,83.3 v2(55.12,83.11) ; U1.AE33 172.71,154.52 ; 172.71,154.52 U1.AE34 ; 172.71,154.52 v1(172.78,154.52) ; U1.D14 188.65,139.21 U1.C13 ; U2022.G10 v3(240.88,169.15) U2022.F10 v3(240.88,168.35) ; v3(270.34,125.62) 270.49,125.77 G2.B19 ; U1.G18 U1.H18 ; JDIMM1.175 178.07,88.96 v1(178.09,88.98) ; R2238.1 R2239.1 76.98,77.73 v1(76.93,77.68) ; v1(76.55,89.23) 76.93,89.61 R2140.1 ; G2.AP4 248.61,115.15 v3(248.61,114.85) ; U1.AD7 U1.AD8 173.62,135.38 v1(174.03,135.78) ; v1(187.02,149.7) 187.02,149.77 U1.F27 ; v3(236.23,112.82) 236.58,113.17 G2.BL1 ; v1(305.74,91.85) 305.66,91.93 PR3572.1 ; G2.AT4 246.67,114.85 v3(246.51,114.85) ; G2.AT4 G2.AT5 ; G2.AT4 G2.AR4 v3(248.16,115.64) ; 151.27,145.07 v1(151.59,144.75) ; 151.27,145.07 v1(150.94,144.75) 150.62,145.07 U1.BP21 150.47,144.99 150.12,144.99 U1.BR21 149.82,144.99 149.47,144.99 U1.BT21 ; 151.27,145.07 U1.BN21 ; v1(151.59,144.75) 151.92,145.07 U1.BM21 ; v1(151.59,144.75) 151.59,144.68 U1.BN20 151.1,144.18 151.1,143.74 U1.BN19 ; v3(269.86,147.84) G2.C51 v3(270.56,148.54) ; U1.AU7 162.6,134.1 U1.AU6 ; U1.AU7 U1.AU8 162.61,135.38 163,135.77 v1(163.05,135.77) ; U1.F31 186.7,153.18 v1(187.02,152.85) ; v1(155.74,139.59) 155.59,139.59 U1.BG14 ; PU1502.5 175.53,186.56 175.13,186.17 ; v3(246.51,114.85) 246.11,114.85 G2.AV4 ; v3(246.51,114.85) 246.51,115.15 G2.AU4 ; v1(189.66,155.69) 189.66,155.66 189.95,155.37 U1.A34 ; v3(265.66,129.66) 265.35,129.97 G2.K25 ; U1.A6 v1(190.51,134.36) ; U1.AM37 167.2,157.12 ; 167.2,157.12 v1(167.26,157.12) ; 167.2,157.12 U1.AM38 ; 153.87,140.42 154,140.42 v1(154.43,140.85) ; G2.B16 270.56,123.67 v3(270.46,123.77) ; G2.AR9 248.14,119.12 v3(248.2,119.12) ; U2.D10 243.61,71.59 U2.C10 ; 155.02,134.07 U1.BG6 U1.BH6 154.09,134.07 v1(153.77,133.74) 154.09,133.42 U1.BH5 154.2,133.41 154.2,132.78 U1.BH4 154.22,132.74 154.22,132.15 U1.BH3 154.01,131.95 153.89,131.95 v1(153.74,131.79) ; C537.1 69.44,54.56 69.06,54.18 68.3,54.18 v1(67.66,54.82) R437.1 R595.1 ; U4.3 247.7,45.5 247.49,45.29 v1(247.49,44.45) ; v1(181.4,133.74) 181.52,133.74 U1.N5 181.89,133.37 181.89,132.81 U1.N4 181.89,132.72 181.89,132.16 U1.N3 181.79,132.12 181.47,131.79 v1(181.4,131.79) 181.57,131.63 181.68,131.63 U1.N2 181.89,131.42 181.89,130.86 U1.N1 ; v1(181.4,133.74) 181.33,133.74 U1.P6 ; v1(181.4,133.74) 181.73,134.07 U1.N6 ; U2.H29 234.25,69.45 v3(234.79,68.91) ; U1.AW1 161.73,130.78 161.31,130.36 v1(161.31,129.78) ; JDIMM3.226 191.05,65.04 v1(190.6,64.6) 190.34,64.6 190.05,64.89 JDIMM3.222 ; G2.F13 268.11,121.57 v3(268.43,121.25) ; JDIMM3.82 153.05,64.65 v1(153.1,64.6) ; v3(238.39,113.57) G2.BH2 ; JDIMM1.223 190.07,88.9 v1(190.15,88.98) ; U2.E13 242.01,70.97 v3(241.78,71.2) ; 180.72,157.12 U1.P38 ; 180.72,157.12 v1(180.65,157.12) ; 180.72,157.12 U1.P37 ; G2.BE36 240.79,137.67 v3(241.09,137.97) ; v3(263.54,116.97) 263.49,116.97 G2.N6 262.87,116.35 v3(262.87,116.25) ; U1.BK22 U1.BJ22 154.05,145.93 154.33,146.21 v1(154.41,146.21) ; v1(152.18,88.98) 153.34,88.98 153.57,88.75 JDIMM1.85 ; v1(152.18,88.98) 151.86,88.98 151.57,88.69 JDIMM1.77 ; v1(152.18,88.98) 152.57,88.59 JDIMM1.81 ; v3(265.99,112.6) 265.99,112.61 G2.J1 ; v1(148.92,155.73) 148.92,155.87 149.17,156.13 U1.BT36 ; v1(148.92,155.73) 149.32,155.34 U1.BT35 ; v1(148.92,155.73) 148.9,155.71 ; G2.F35 v3(267.79,136.67) 268.09,136.37 G2.F34 268.25,136.11 v3(268.53,136.11) ; G2.AD44 255.49,143.25 v3(255.16,142.93) ; v1(152.96,139.16) 153.22,139.42 U1.BK14 U1.BK15 U1.BJ15 ; v1(152.96,139.16) 153.22,138.9 U1.BK13 ; v1(152.96,139.16) 152.64,138.84 U1.BL13 ; v3(265.66,121.28) 265.66,121.2 G2.J12 ; JDIMM1.73 150.57,88.68 v1(150.27,88.98) 149.7,88.98 149.57,88.85 JDIMM1.69 ; v3(270.36,136.12) 270.36,135.74 G2.C33 ; v3(270.36,136.12) 270.08,136.4 269.62,136.4 G2.D34 269.21,136.55 v3(269.09,136.55) ; v3(270.36,136.12) 270.51,136.27 G2.B34 ; U1.T3 179.37,132.15 179.37,132.73 U1.T4 ; v1(77.95,65.1) 77.82,65.23 C525.1 ; v1(155.61,88.98) 154.66,88.98 154.57,88.89 JDIMM1.89 ; v1(155.61,88.98) 155.57,88.94 JDIMM1.93 ; 150.94,151.77 U1.BP29 150.62,151.48 v3(150.28,151.81) 150.26,151.81 149.97,151.53 U1.BR29 ; 150.94,151.77 150.94,151.76 U1.BN29 ; 150.94,151.77 v1(150.94,151.84) ; U1.BD37 157.49,156.79 v1(157.82,157.12) 157.75,157.12 U1.BD38 ; C245.1 26.89,45.8 v1(26.13,46.56) ; U2.BB25 236.06,52.76 v3(236.06,52.33) ; U1.AL10 168.46,137.05 v1(168.55,137.05) ; U1.BF6 U1.BE6 156.77,134.07 v1(157.1,133.74) ; Q53.1 49.24,46.3 50.13,47.2 v1(50.26,47.2) ; v1(202.28,200.61) 202.07,200.4 JEDP1.10 ; v1(186.37,136.32) 186.05,136.64 U1.G10 185.9,136.86 185.47,136.86 U1.J10 ; U2005.L15 50.24,84.76 v2(49.92,85.08) ; PU1602.19 184.01,187.71 PU1602.26 ; PU1601.5 194.78,186.56 PU1601.19 194.81,187.71 PU1601.26 ; JDIMM1.247 196.07,88.71 195.8,88.98 v1(195.36,88.98) 195.07,88.69 JDIMM1.243 ; U2.AR33 232.16,56.43 v3(231.74,56.85) 231.65,56.76 U2.AR34 ; G2.AP51 248.44,148.12 v3(248.44,147.72) 248.33,147.61 v3(248.33,147.18) 248.33,146.92 G2.AP49 ; 243.17,62.06 243.09,61.98 U2.AD11 243.09,61.4 v3(243.38,61.12) ; G2.A26 272.04,130.67 v3(272.09,130.72) ; U1.AV37 162.47,157.12 ; 162.47,157.12 U1.AV38 ; 162.47,157.12 v1(162.54,157.12) ; JDIMM3.68 149.55,65.04 v1(149.1,64.6) ; JDIMM1.256 198.32,80.45 198.72,80.85 v1(198.85,80.85) 199.32,80.38 JDIMM1.260 ; 205.36,188.2 205.73,188.57 PU1603.26 ; v1(133.1,64.6) 133.05,64.65 JDIMM3.2 ; U2014.24 61.23,64.68 v1(60.8,65.1) ; U2.AV33 232.58,54.56 v3(232.63,54.56) 232.83,54.56 U2.AV31 ; v1(44.17,45.8) 43.45,45.08 U26.3 ; U1.AU34 163.26,154.52 ; 163.26,154.52 U1.AU33 ; 163.26,154.52 v1(163.33,154.52) ; v3(270.34,140.32) 270.49,140.47 G2.B40 ; v3(190.37,149.69) 189.99,149.31 U1.A26 ; v3(244.7,60.91) 244.62,60.99 U2.AD8 ; 70.84,75.01 71.01,74.84 U2013.24 ; JSSD2.57 104.83,79.54 v1(104.62,79.33) ; JDIMM3.102 158.05,65.04 157.6,64.6 v1(157.32,64.6) 157.05,64.87 JDIMM3.98 ; v1(158.6,154.52) 158.53,154.52 ; 158.53,154.52 U1.BC33 ; 158.53,154.52 U1.BC34 ; 236.66,69.6 U2.H24 ; v3(234.79,68.91) 234.87,68.83 U2.K27 ; v3(234.79,68.91) 234.79,68.96 U2.H27 ; JDIMM1.51 145.07,88.91 144.37,89.61 v1(144.18,89.61) ; v1(187.02,138.68) 186.44,138.68 U1.G12 ; 150.29,142.45 v1(150.29,142.38) ; 150.29,142.45 U1.BP18 U1.BN18 ; v1(157.57,136.42) 157.5,136.42 U1.BD9 157.36,135.78 v1(157.57,135.78) 157.16,135.38 U1.BD8 U1.BD7 ; 241.52,62.06 241.57,62.01 U2.AD14 241.68,61.52 242.03,61.17 v3(242.03,61.12) 242.03,60.79 242.33,60.48 U2.AG13 ; U1.G16 186.05,141.37 v1(186.37,141.04) ; PU1001.26 218.74,199.38 PU1001.19 ; v1(176.77,135.78) 176.72,135.78 U1.Y8 U1.Y7 176.06,134.48 ; v3(231.75,52.34) 231.61,52.48 U2.BB34 ; 162.05,188.2 162.42,188.57 PU1501.26 ; PC3435.2 v1(306.55,98.63) ; v1(67.03,59.39) 67.38,59.04 U2014.3 ; U2005.AB20 55.19,82.38 v2(55.11,82.45) ; U1.F25 186.7,148.45 v1(186.37,148.13) 186.37,148.06 U1.G24 ; 234.92,54.46 235.15,54.69 235.35,54.69 235.43,54.77 U2.AV27 ; 234.92,54.46 234.92,54.44 234.59,54.11 U2.AW29 ; 234.92,54.46 v3(234.92,54.49) ; v3(269.86,117.66) 269.57,117.37 G2.D7 269.45,117.37 269.21,117.13 v3(269.07,117.13) ; v3(263.04,118.92) 263.04,119.32 G2.N10 ; JIO1.40 v1(301.56,37.32) ; v3(228.44,63.33) 227.98,63.33 U2.AA42 ; U1.BE5 156.77,133.42 v1(157.1,133.74) ; G2.D4 269.49,115.27 v3(269.79,115.57) ; v3(239.69,123.97) G2.BG16 ; JIO1.46 v1(301.29,34.92) ; U1.C17 188.65,142.16 v1(188.31,141.83) 188,141.51 U1.D16 188.62,140.81 188.62,140.67 U1.C15 ; PR3415.2 309.72,96.6 v1(309.85,96.73) ; v1(196.98,88.98) 197.07,88.89 JDIMM1.251 ; v3(243.67,87.92) U2026.E1 v3(244.47,87.92) ; U1.BL38 152.77,157.5 v1(152.43,157.84) ; U1.BK29 153,151.44 U1.BL29 ; U1.BE1 156.71,130.8 156.71,130.3 156.27,129.85 v1(156.26,129.85) ; PR416.2 305.24,108.49 PQ1409.4 v1(305.79,109.8) ; U1.T2 178.99,131.81 v1(178.89,131.81) ; JDIMM3.44 143.55,64.65 v1(143.6,64.6) ; JWLAN1.18 276.5,70.13 v1(277.21,69.42) ; U1.BG38 155.38,157.12 ; 155.38,157.12 U1.BG37 ; 155.38,157.12 v1(155.45,157.12) ; G2.B25 270.49,129.97 v3(270.34,129.82) ; C888.2 210.66,199.6 210.03,200.23 209.77,200.23 ; v3(244.47,87.12) U2026.C1 244.07,86.72 v3(243.67,86.32) ; D65.1 v1(4.98,78.63) ; v1(185.72,149.7) 185.72,149.63 U1.G26 ; v3(239.74,128.24) 239.74,128.22 239.39,127.87 G2.BG22 ; JDIMM3.214 v1(188.05,64.6) 188.6,64.6 189.05,65.04 JDIMM3.218 ; v3(266.39,128.17) 266.69,127.87 G2.H22 ; R555.2 41.42,42.37 v1(41.8,41.99) ; G2.N4 263.41,115.49 v3(263.41,115.61) ; JDIMM3.30 140.05,65.15 v1(140.6,64.6) 139.54,64.6 139.05,65.09 JDIMM3.26 ; PR803.2 v1(301.59,182.83) ; G2.AF35 254.09,137.02 v3(254.39,137.32) 254.09,137.62 G2.AF36 G2.AF37 ; v3(246.63,143.03) v3(246.11,143.55) G2.AV45 ; JWLAN1.7 279.25,77.69 279.24,77.68 279.24,77.55 279.37,77.42 v1(279.37,77.17) ; PC1269.2 220.26,44.71 v1(221.08,43.89) ; JDIMM1.47 144.07,86.65 143.61,86.19 143.61,85.42 143.86,85.17 v1(144.18,85.17) ; v1(84.04,83.65) 83.89,83.8 U2019.12 ; U1.F17 186.37,142.55 v1(186.37,142.62) ; U2022.A12 v3(242.48,164.35) ; v3(228.57,65.61) 227.99,65.61 U2.T42 ; U2007.H5 32.62,74.25 32.37,74.25 v2(32.25,74.13) 32.5,73.88 U2007.H4 ; v1(204.16,198.07) 203.86,198.37 203.76,198.37 203.57,198.56 JEDP1.7 ; JDIMM3.48 144.55,64.82 144.78,64.6 v1(144.85,64.6) 145,64.6 145.55,65.14 JDIMM3.52 ; v2(55.09,81.86) 54.8,82.16 U2005.Y20 ; U1.V30 U1.V29 177.89,151.49 v3(178.43,150.96) ; v1(222.09,198.07) 221.93,198.23 PU1001.5 ; U2.AE42 228.61,60.96 v3(228.7,61.04) ; U1.BH8 154.42,135.38 v1(154.82,135.78) 154.61,135.78 U1.BH9 ; U1.W5 177.22,133.82 177.4,133.82 U1.V6 U1.U6 179.06,134.63 U1.T7 U1.T8 179.46,135.78 v1(179.51,135.78) ; v2(32.25,74.76) 32.62,74.76 U2007.H6 ; PC704.2 v1(302.1,101.93) ; G2.AL45 250.59,144 v3(250.29,144.3) ; JDIMM3.196 183.55,65.15 v1(184.1,64.6) ; R438.2 64.49,69.42 v1(63.85,70.06) ; v3(270.34,144.52) 270.12,144.73 269.55,144.73 G2.D46 ; U1.AR14 164.53,139.28 v1(164.89,139.64) ; 165.62,154.52 U1.AP33 ; 165.62,154.52 v1(165.69,154.52) ; 165.62,154.52 U1.AP34 ; Q95.4 279.06,192.79 279.62,192.23 v1(279.62,192.1) ; v1(75.92,91.65) 75.8,91.53 U2016.3 ; R2057.2 59.86,92.54 v1(59.86,93.55) 59.35,94.06 R2284.2 R2283.2 ; v3(238.39,115.67) G2.BH5 ; v1(229.46,125.17) R2257.2 R1019.2 ; PU1002.19 230.93,199.38 PU1002.26 ; JDIMM1.189 181.57,88.8 v1(181.39,88.98) ; U1.AJ6 U1.AH6 U1.AG6 170.83,134.19 U1.AG7 U1.AG8 ; U1.AJ6 169.16,134.07 168.5,134.73 U1.AL7 U1.AL8 168.14,135.38 v1(168.54,135.78) ; U1.AJ6 169.29,134.05 169.29,133.43 U1.AJ5 169.35,133.34 169.35,132.84 U1.AJ4 ; v3(240.49,135.97) G2.BE34 ; v3(263.35,142.97) 263.35,142.73 G2.N43 ; U2.E15 241.08,70.82 v3(240.76,70.82) 240.53,71.05 U2.D16 v3(240.53,72.03) ; v3(242.04,114.51) 242.04,114.38 242.19,114.23 G2.BC2 ; R488.2 v1(64.99,54.82) ; v1(158.77,133.74) 158.45,134.07 U1.BC6 U1.BD6 157.42,134.07 v1(157.1,133.74) ; v1(158.77,133.74) 159.1,133.42 U1.BB5 159.23,133.4 159.23,132.78 U1.BB4 159.23,132.75 159.23,132.13 U1.BB3 159.1,132.12 v1(158.77,131.79) 158.89,131.79 U1.BB2 ; v1(151.6,151.84) 151.6,151.76 U1.BM29 ; U1.BT26 149.37,149.03 149.92,149.03 U1.BR26 150.02,149.03 150.57,149.03 U1.BP26 ; JIO1.31 v1(301.29,40.92) ; v3(234.92,71.45) 235.29,71.45 U2.D27 ; v3(234.92,71.45) 234.92,71.83 U2.C28 ; U2.D21 v3(238.25,72.03) ; U2.BB11 242.98,52.46 v3(242.84,52.33) ; v1(188.97,152.86) 188.65,153.18 U1.C31 ; R541.1 v1(76.04,65.1) ; v3(229.71,54.56) 229.23,55.04 U2.AU39 ; v3(229.71,54.56) 229.56,54.41 U2.AY38 ; v3(229.71,54.56) 229.89,54.56 U2.AW37 ; PU1501.5 164.73,186.56 164.34,186.17 ; U2.AW13 242.28,54.19 v3(241.9,54.56) 241.78,54.69 241.78,55.08 U2.AT15 ; JEDP1.16 199.07,197.78 v1(199.18,197.67) ; G2.K13 265.29,121.57 v3(265.59,121.87) ; U61.3 45.45,40.45 45.82,40.08 v1(45.82,39.83) ; v1(304.13,101.93) 304.21,101.86 PC3424.2 PR3423.2 ; v1(154.82,136.42) 154.63,136.42 U1.BH10 ; G2.BE15 240.79,123.07 v3(240.49,123.37) G2.BE16 ; v1(199.23,68.66) 198.55,67.98 JDIMM3.256 ; PR3416.1 v1(306.55,96.6) ; v3(248.89,118.37) G2.AN8 ; G2.AH43 252.69,142.58 v3(252.98,142.87) 253.37,143.27 G2.AG44 ; v3(253.09,135.22) 253.39,135.52 G2.AG33 G2.AG34 ; R389.1 v1(67.69,83.19) R2314.1 ; U2014.18 62.97,61.68 v1(63.22,61.93) ; v3(244.41,114.3) 244.29,114.18 G2.AY2 ; U2.BB16 240.76,52.91 v3(240.76,53.37) ; G2.AB43 257.08,142.76 v3(257.08,143.14) ; C1400.2 223.03,116.11 223.54,115.6 224.07,115.6 224.89,116.41 v1(224.89,117.17) 225.01,117.3 R2252.2 225.7,116.28 226.21,115.78 233.01,115.78 v1(233.14,115.9) ; JIO1.34 v1(301.32,39.72) ; 169.69,154.52 v1(169.63,154.52) ; 169.69,154.52 U1.AH33 ; 169.69,154.52 U1.AH34 ; U1.BE3 156.58,132.12 v1(156.26,131.79) 156.58,131.47 U1.BE2 ; G2.N47 263.37,145.55 v3(263.37,145.76) ; G2.BE37 240.79,138.32 240.48,138.01 v3(240.48,138) ; U2019.30 v1(79.34,85.3) ; v2(36.42,71.83) 36.39,71.86 36.39,72.24 U2007.A1 ; U1.D38 187.85,157.64 187.8,157.69 187.8,158.19 v1(187.04,158.96) ; PQ1405.4 209.38,194.38 209.01,194.01 v1(209.01,193.12) 208.75,193.38 PQ1405.1 ; U1.Y11 176.59,137.05 v1(176.78,137.05) ; v1(160.31,136.42) 160.24,136.42 U1.BA9 ; v3(256.59,116.37) G2.AB6 ; v1(152.1,64.6) 152.05,64.65 JDIMM3.78 ; v2(30.58,72.22) 31.08,72.22 U2007.L1 ; v1(154.1,64.6) 154.05,64.65 JDIMM3.86 ; U1.H22 U1.J22 ; PU902.26 267.5,199.38 PU902.19 ; v1(183.28,150.93) 183.28,151.42 U1.L29 U1.L30 ; 172.85,188.2 173.22,188.57 PU1502.26 ; JDIMM3.10 135.05,65.04 v1(134.6,64.6) 134.34,64.6 134.05,64.88 JDIMM3.6 ; JDIMM3.94 156.05,65.1 155.54,64.6 v1(155.16,64.6) 155.05,64.71 JDIMM3.90 ; JDIMM1.231 192.07,88.71 v1(191.8,88.98) 191.23,88.98 191.07,88.82 JDIMM1.227 ; U1.BM6 151.72,133.99 151.37,134.34 v1(151.34,134.34) 151.34,134.37 151.27,134.44 U1.BN7 ; G2.AY4 244.29,115.27 244.62,114.94 v3(244.65,114.94) 244.98,115.27 G2.AW4 G2.AW5 ; U1.BH12 154.65,137.69 v1(154.82,137.69) 155,137.69 U1.BG12 ; v3(241.79,130.37) G2.BD26 ; U1.Y13 176.18,138.63 v1(175.86,138.94) 176.2,139.28 U1.Y14 ; U1.BC13 U1.BC12 157.86,137.98 v1(157.57,137.69) ; v1(71.85,51.64) 71.47,51.26 JEC1.27 ; JDIMM3.85 153.8,76.06 154.02,76.28 155.56,76.28 v1(155.61,76.23) ; v3(270.49,111.04) 270.57,111.04 270.99,111.46 270.99,112.37 v3(270.49,112.87) G2.C1 ; U1.D24 188,147.7 188.65,147.05 U1.C23 188.65,146.88 v1(188.32,146.55) ; C2688.1 67.15,69.42 v1(67.03,69.55) ; v3(246.96,149.41) 246.96,148.99 G2.AT52 G2.AT51 ; v3(247.03,58.75) 246.93,58.86 U2.AK4 ; U60.H1 273.08,92.32 v3(273.28,92.52) ; D2006.3 v1(11.02,78.39) ; U2.AV17 240.21,54.77 v3(240.76,55.32) ; G2.AL4 250.44,115.12 250.03,115.12 G2.AM4 G2.AN4 G2.AN5 ; U1.BG14 U1.BH14 ; JDIMM1.209 186.57,88.95 v1(186.6,88.98) ; JDIMM3.22 138.05,65.04 v1(137.6,64.6) 137.05,65.15 JDIMM3.18 ; v3(271.19,115.67) G2.B5 ; PU1603.5 208.04,186.56 207.64,186.17 ; U2025.L10 292.63,118.29 v3(292.23,118.69) ; G2.A29 v3(272.06,132.77) ; JIO1.25 301.15,43.32 v1(301.34,43.51) ; U1.BM35 151.92,155.42 v3(152.25,155.75) 152.51,155.49 U1.BL35 ; 179.14,154.52 U1.T34 ; 179.14,154.52 v1(179.08,154.52) ; 179.14,154.52 U1.T33 ; G2.AB49 v3(257.19,147.07) 257.19,147.54 256.89,147.84 G2.AB51 ; PU901.5 258.53,198.23 v1(258.69,198.07) ; PU1606.5 246.36,198.23 v1(246.5,198.1) ; G2.BG34 239.39,136.27 v3(239.69,136.57) ; JDIMM1.201 184.57,88.6 v1(184.94,88.98) 185.26,88.98 185.57,88.67 JDIMM1.205 ; v3(230.22,65.61) 230.22,65.46 U2.U38 ; U1.AY14 160.77,139.51 v1(160.37,139.91) ; JEDP1.36 189.07,200.36 188.82,200.61 v1(188.82,200.99) ; U2007.F1 33.75,72.08 v2(33.62,71.94) ; 228.5,72 v3(228.54,71.96) ; 228.5,72 U2.B40 ; U1.BM2 151.89,131.4 v1(151.78,131.29) 151.48,131.29 U1.BN2 ; U1.N10 182.06,136.42 v1(182.26,136.42) 181.87,136.03 U1.N9 U1.N8 U1.N7 181.8,134.11 U1.N6 ; JDIMM3.206 186.05,64.65 186.1,64.6 v1(187.1,64.6) 187.05,64.65 JDIMM3.210 ; v3(251.29,112.62) G2.AK1 G2.AJ2 ; v1(161.29,131.79) 161.61,131.47 U1.AW2 ; v3(239.04,117.69) 239.36,117.37 G2.BG7 G2.BF6 ; v3(262.86,144.25) 263.15,143.97 G2.N45 ; G2.BM3 v3(235.41,114.09) 234.89,114.61 232.4,114.61 232.25,114.76 225.44,114.76 224.1,113.41 C1399.2 ; U1.BA10 160.23,137.05 v1(160.32,137.05) ; G2.B43 270.49,142.57 v3(270.34,142.42) 270.09,142.66 269.58,142.66 G2.D43 ; v1(157.58,139.78) 158.03,139.33 U1.BC14 ; v2(35.38,76.13) 35.51,76.13 U2007.B8 ; v1(200.76,198.07) 200.57,198.26 JEDP1.13 ; v3(247.78,149.39) 247.79,149.39 G2.AR52 ; G2.N51 263.19,147.69 v3(263.22,147.66) 262.99,147.44 262.99,146.96 G2.N49 ; 181.83,197.05 PU1306.7 ; U1.BA7 160.05,134.53 U1.BA6 ; D22.1 v1(11.65,162.09) ; v1(151.1,64.6) 150.55,65.15 JDIMM3.72 ; v3(263.48,118.43) 263.48,118.36 G2.N8 263.34,117.92 v3(263.34,117.52) ; U1.K5 184.36,133.49 184.11,133.74 v1(183.92,133.74) ; U1.G14 186.05,140 U1.F15 ; v1(186.37,143.4) 186.37,143.47 U1.F19 186.37,144.12 v1(186.37,144.19) ; v1(75.03,93.93) 75.42,94.32 Q6.1 ; v1(176.44,77.55) 175.82,78.17 JDIMM1.166 ; R2105.2 R942.2 63.6,55.38 v1(63.6,54.82) ; PC3434.2 v1(306.55,97.49) ; v3(248.79,117.77) 248.49,118.07 G2.AP8 ; v3(238.48,54.05) 238.52,54.01 U2.AW19 ; v3(237.16,56.47) 237.16,55.4 236.54,54.78 U2.AV24 ; JSSD2.51 v1(104.6,78.04) ; U2.AG4 246.53,60.47 U2.AE4 246.53,61.58 U2.AD4 246.63,61.91 246.35,62.18 ; U1.BN30 151.27,152.3 v1(150.94,152.62) 150.94,152.69 U1.BN31 ; U1.BM28 151.92,150.58 v1(152.24,150.26) ; U1.BK18 U1.BJ18 ; v1(181.1,64.6) 181.55,65.04 JDIMM3.188 ; v1(76.55,70.69) 76.55,69.65 77.03,69.17 U2013.3 ; U2.A25 U2.B25 v3(235.98,72.02) U2.D25 ; U2.BB21 238.43,52.47 v3(238.55,52.35) ; PQ1409.1 v1(306.79,107.15) ; R2104.2 v1(73.38,65.1) ; v3(270.45,134.07) 270.55,134.17 G2.B31 ; G2.F22 267.92,127.7 v3(267.61,127.7) ; G2.BC6 241.89,116.37 v3(241.89,116.32) ; G2.A32 v3(272.13,134.87) ; PR3418.2 v1(302.99,91.9) ; v3(240.46,127.49) 240.49,127.52 240.49,127.57 G2.BE22 ; U1.BB12 158.84,137.98 v3(158.54,138.28) ; U1.D28 188.65,150.23 U1.C27 188.67,150.09 188.96,149.81 v1(188.96,149.72) ; v3(267.21,136.44) 266.86,136.44 G2.H34 266.68,136.27 v3(266.36,136.58) ; v3(271.43,91.92) U60.H2 ; U2005.AB6 55.29,88.82 v2(55.12,88.98) ; v3(270.4,138.21) 270.56,138.37 G2.B37 ; U2023.U12 v3(287.3,155.34) ; U1.T9 179.45,136.42 v1(179.51,136.42) ; U1.BN24 151.27,147.57 v1(150.94,147.9) 150.62,147.57 U1.BP24 150.47,147.65 150.12,147.65 U1.BR24 149.92,147.55 149.37,147.55 U1.BT24 ; U2.AK42 227.73,58.83 v3(227.38,58.83) ; U1.D10 188.65,136.06 U1.C9 188.97,135.6 v1(188.97,135.53) ; U2013.18 v1(72.86,71.84) ; v1(158.77,129.85) 158.78,129.85 159.23,130.3 159.23,130.8 U1.BB1 ; G2.BD32 241.49,134.86 v3(241.78,134.57) ; U1.N6 U1.M6 ; v3(241.09,131.67) G2.BE27 ; JDIMM1.65 148.57,88.78 v1(148.37,88.98) 147.67,88.98 147.57,88.88 JDIMM1.61 ; v3(265.59,128.17) 265.29,127.87 G2.K22 ; v3(239.69,132.37) G2.BG28 ; v3(266.29,121.82) 266.38,121.82 266.64,121.57 G2.H13 266.75,121.57 v3(267.06,121.88) ; v3(271.19,119.17) 270.89,119.47 G2.B10 ; JDIMM3.248 196.55,65.25 197.2,64.6 v1(197.33,64.6) 197.55,64.82 JDIMM3.252 ; C1340.2 v1(204.06,130.64) ; G2.BE13 v3(241.09,121.27) 241.49,121.67 242.08,121.67 G2.BC13 ; U1.AL9 168.47,136.42 v1(168.54,136.42) ; U1.BM5 151.82,133.13 v1(152.05,132.89) ; PC3509.2 v1(218.92,98.5) ; U2.W38 230.09,63.65 v3(230.09,63.33) 230.09,63.15 U2.AB38 ; JIO1.19 301.16,45.72 301.59,45.29 301.59,44.4 v1(301.35,44.15) 300.97,44.52 JIO1.22 ; U1.D20 188.65,143.93 U1.C19 188.65,143.73 v1(188.32,143.4) 188,143.08 U1.D18 ; JDIMM1.188 181.32,77.62 v1(181.39,77.55) 182.02,77.55 182.32,77.85 JDIMM1.192 ; G2.AP2 248.49,114.2 v3(248.58,114.29) ; U2.BB30 233.88,52.51 v3(233.73,52.35) ; v3(256.59,119.17) G2.AB10 ; U2.A42 227.75,73.29 v3(227.53,73.51) ; U2014.31 65.88,64.85 65.63,64.6 v1(65.63,63.45) v1(65.63,61.93) ; G2.M52 v3(263.89,149.35) ; R489.2 v1(74.26,79.58) ; JDIMM1.57 146.57,88.62 v1(146.21,88.98) ; U2023.K13 v3(292.9,156.14) U2023.K14 v3(292.9,156.94) ; v1(188.32,144.98) 188.65,145.3 U1.C21 ; U1.K3 184.23,131.98 184.11,131.98 v1(183.92,131.79) 184.04,131.79 U1.K2 ; v3(268.48,129.7) 268.35,129.7 G2.F25 ; G2.W4 v3(259.29,114.97) ; U2013.31 75.53,76.35 75.58,76.4 v1(75.58,76.48) ; v3(269.09,113.57) G2.E2 ; v1(74.26,65.1) R940.2 R455.2 ; G2.BD29 v3(241.79,132.47) ; v1(272.75,80.22) JWLAN1.33 ; U1.J25 184.69,148.51 v1(184.3,148.12) ; C599.1 v1(78.02,98.89) ; v3(239.68,138.66) 239.39,138.37 G2.BG37 ; v1(188.32,148.13) 188.65,148.45 U1.C25 188.65,148.66 U1.D26 ; D64.1 v1(4.98,76.22) ; v3(241.09,135.87) 240.79,135.57 G2.BE33 ; v3(268.54,127.62) G2.F21 ; JSSD2.45 104.62,76.54 ; G2.AL2 v3(250.59,114.32) ; U2.A44 226.64,73.1 v3(226.16,73.1) 226.16,72.87 226.38,72.64 U2.B45 226.47,72.64 226.6,72.51 U2.B44 226.87,72.74 226.75,72.87 U2.A44
  BOTTOM w0.3: G2.AE8 254.49,118.37 v3(254.44,118.42) ; v3(272.14,113.32) G2.A2 271.59,113.87 ; G2.J20 265.68,126.16 v3(265.68,126.04) ; G2.T2 261.09,114.17 v3(260.94,114.32) 261.27,114.65 261.27,115.08 G2.T4 ; G2.AB2 256.89,114.18 v3(256.79,114.28) ; v3(260.75,116.31) 260.75,116.33 G2.T6 ; G2.BF4 240.2,115.16 v3(240.2,114.63) ; v3(252.29,119.07) G2.AJ9 ; v3(254.63,114.39) 254.79,114.23 G2.AE2 ; 270.89,113.87 G2.B2 v3(271.26,113.49) ; G2.F19 268.34,125.52 v3(268.51,125.52) ; v3(260.89,118.97) 260.59,118.97 G2.U9 ; G2.A51 v3(271.94,148.52) ; v3(271.49,112.72) 271.34,112.72 G2.B1 ; G2.B51 v3(271.34,148.62) ; G2.B48 v3(271.19,146.37) ; G2.H10 v3(266.99,119.77) ; G2.AU51 246.39,147.62 v3(246.46,147.54) 246.25,147.33 246.25,146.9 G2.AU49 ; G2.D40 269.62,140.6 270.05,140.6 v3(270.34,140.32) ; G2.N2 263.19,114.22 v3(263.09,114.32) ; G2.W8 v3(259.29,117.77) ; v3(267.59,147.72) 267.39,147.92 G2.G51 ; G2.AE49 254.67,146.89 254.67,147.35 v3(254.94,147.62) 254.79,147.77 G2.AE51 ; v3(250.91,145.72) 250.89,145.7 250.89,145.67 G2.AL47 ; v3(266.1,142.69) 265.91,142.88 265.91,143.41 v3(266.36,143.87) ; G2.AY51 v3(243.99,147.87) ; G2.AL8 v3(250.89,118.37) ; G2.T47 261.39,145.67 v3(261.39,145.77) ; v3(270.34,144.52) 270.49,144.67 G2.B46 ; v3(250.46,147.7) 250.59,147.83 G2.AL51 ; v3(259.16,147.66) 258.99,147.83 G2.W51 ; G2.H16 266.94,123.92 v3(267.09,123.92) ; v3(258.79,118.97) 258.49,118.97 G2.Y9 ; G2.AK47 v3(250.99,145.07) ; v3(270.14,119.57) 269.59,119.57 G2.D10 ; v3(266.24,134.42) 266.44,134.42 G2.H31 ; v3(260.76,144.33) 260.76,144.3 261.09,143.97 ; G2.W6 258.69,116.37 v3(258.69,116.27) ; G2.AE6 v3(255.13,117.02) ; G2.AH51 252.69,147.62 v3(252.77,147.53) ; v3(265.84,123.87) 265.84,124.22 G2.J17 ; v3(270.34,125.62) 270.05,125.9 269.62,125.9 G2.D19 ; v3(269.09,148.47) G2.E51 ; v3(267.14,116.22) 267.14,116.42 G2.G6 ; 252.69,143.97 v3(252.39,144.27) ; G2.W2 v3(258.99,114.47) ; v3(267.79,117.07) G2.F7 ; G2.H19 v3(266.99,126.07)
  BOTTOM w0.305: Q53.4 47.22,45.3 v1(47.21,45.29) ; U48.F5 258.51,173.55 v3(258.11,173.15) U48.G5 ; v3(270.33,166.75) 269.93,166.35 U55.C3 v3(269.53,165.95) ; JDIMM1.82 152.82,78.19 v1(152.18,77.55) 151.82,77.91 JDIMM1.78 ; U1.K38 184.19,158 v1(184.15,158.04) ; G2.BL31 236.94,134.17 v3(237,134.11) ; v3(271.93,177.15) 271.53,176.75 U55.T5 ; U2024.L10 295.83,132.32 v3(296.23,132.72) U2024.M10 v3(297.03,131.92) ; JDIMM1.252 197.32,77.88 v1(196.98,77.55) ; JDIMM3.27 139.3,75.85 139.73,76.28 v1(140.37,76.28) 140.3,76.21 JDIMM3.31 ; U55.E3 v3(269.53,168.35) ; JSSD1.15 107.02,44.67 v1(107.26,44.91) ; v3(252.51,164.35) 252.9,164.75 U48.U12 ; v3(289.7,155.34) U2023.R12 v3(288.9,154.54) U2023.R11 289.3,154.14 v3(289.7,153.74) U2023.P10 ; JDIMM1.23 138.07,88.71 v1(138.34,88.98) 138.91,88.98 139.07,88.82 JDIMM1.27 ; JDIMM1.218 188.82,77.87 v1(188.5,77.55) 187.99,77.55 187.82,77.72 JDIMM1.214 ; U1.AC38 174.03,157.44 v1(174.35,157.12) 174.03,156.79 U1.AC37 ; v1(107.26,45.93) 107.02,46.17 JSSD1.21 ; v3(262.63,95.12) U60.E14 v3(261.63,94.72) ; v3(267.93,167.55) U55.E1 ; v3(294.9,157.04) 294.9,156.54 U2023.H14 U2023.H13 v3(294.5,155.34) ; U2.D12 242.88,71.59 U2.D10 ; v3(300.1,155.34) U2023.A12 v3(300.9,154.54) ; v3(288.23,118.69) 288.63,118.29 U2025.T10 ; v3(260.51,164.35) U48.U3 ; JDIMM1.18 136.82,78.19 v1(136.18,77.55) 135.82,77.91 JDIMM1.14 ; JWLAN1.75 v1(262.25,80.21) ; v1(154.36,143.03) 154.1,142.78 U1.BJ18 ; v1(196.98,76.28) 197.3,75.96 JDIMM3.251 ; JDIMM3.189 181.8,75.87 v1(181.39,76.28) 180.8,75.69 JDIMM3.185 ; v3(287.43,121.89) 287.83,121.49 U2025.U14 ; v1(186.37,150.49) 186.37,150.56 U1.G28 ; JWLAN1.63 v1(265.25,80.21) ; JDIMM1.64 148.32,77.61 v1(148.38,77.55) 147.73,77.55 147.32,77.96 JDIMM1.60 ; U2023.C4 v3(299.3,148.94) 299.3,148.94 U2023.B5 v3(300.1,149.74) ; JDIMM1.210 186.82,77.77 v1(186.6,77.55) ; U55.F5 v3(271.13,169.15) U55.G5 ; 164.75,138.95 v1(164.88,138.95) ; 164.75,138.95 U1.AR14 ; 164.75,138.95 U1.AR13 ; v1(107.26,47.84) 107.09,47.67 JSSD1.27 ; JWLAN1.51 v1(268.25,80.21) ; v3(261.31,165.15) 261.71,164.75 U48.U1 v3(262.11,164.35) ; v3(289.83,112.29) 289.43,112.68 U2025.R3 289.03,113.09 v3(289.03,113.09) 289.03,113.09 U2025.R4 ; U1.W33 177.43,154.52 ; 177.43,154.52 U1.W34 ; 177.43,154.52 v1(177.5,154.52) ; U48.M5 v3(258.91,169.15) 258.51,169.55 U48.L5 ; PC428.2 214.14,114 v3(214.47,114) 214.47,112.6 214.73,112.35 PR3581.1 ; v3(289.03,121.09) U2025.R14 289.03,121.88 v3(289.03,121.89) ; v1(60.68,88.9) 60.68,89.44 R2027.2 ; v3(236.88,177.15) 236.48,176.75 U2022.T5 v3(236.08,176.35) U2022.R4 v3(235.28,176.35) U2022.R3 v3(234.48,176.35) ; U48.K14 v3(251.71,169.95) U48.K13 ; JDIMM3.213 187.8,75.96 188.12,76.28 v1(188.5,76.28) 188.8,75.98 JDIMM3.217 ; U2024.A14 287.83,129.12 v3(287.43,128.72) ; JDIMM1.176 178.32,77.78 v1(178.09,77.55) 177.32,78.32 JDIMM1.172 ; U2026.M10 251.27,93.92 v3(251.67,94.32) ; U1.U37 179.01,157.12 v1(179.08,157.12) 178.75,157.44 U1.U38 ; JDIMM3.99 157.3,75.64 v1(157.89,76.23) 158.3,75.82 JDIMM3.103 ; JDIMM3.223 190.3,76.13 v1(190.15,76.28) ; JDIMM1.36 141.32,77.87 141,77.55 v1(140.37,77.55) 139.82,78.1 JDIMM1.30 ; JSSD1.1 107.07,41.17 107.39,41.49 v1(107.39,41.61) 107.33,41.67 JSSD1.3 ; v1(107.26,48.98) 107.07,49.17 JSSD1.33 ; v3(232.88,167.55) 233.28,167.95 U2022.E1 ; JDIMM1.19 137.07,88.79 136.88,88.98 v1(136.18,88.98) 136.07,88.87 JDIMM1.15 ; v3(254.07,87.92) U2026.E14 v3(254.87,87.92) ; v3(264.76,143.11) 265.05,143.11 265.4,143.46 265.4,143.85 G2.K45 ; v3(300.23,121.88) U2025.A14 v3(300.23,121.08) ; v3(254.87,96.72) 254.47,96.32 U2026.R14 v3(254.07,96.72) ; v3(254.07,86.32) U2026.C14 254.47,86.72 v3(254.87,86.32) 255.5,86.95 256.01,86.95 ; 154.78,76.28 154.8,76.26 JDIMM3.89 ; JDIMM3.61 147.8,76.09 147.99,76.28 v1(148.38,76.28) 148.38,76.27 148.8,75.85 JDIMM3.65 ; JDIMM1.238 193.82,77.66 v1(193.71,77.55) 193.07,77.55 192.82,77.8 JDIMM1.234 ; v3(297.83,130.32) 297.43,130.72 U2024.N12 ; v3(241.68,165.95) U2022.C12 ; U1.F15 186.37,140.97 v1(186.37,141.04) ; JDIMM1.9 134.57,88.68 v1(134.27,88.98) 133.76,88.98 133.57,88.79 JDIMM1.5 ; v3(297.03,113.88) U2025.F5 296.63,114.41 v3(296.23,114.81) 295.83,114.41 U2025.G5 ; U1.Y37 176.39,156.79 v1(176.71,157.12) 176.39,157.44 U1.Y38 ; v3(293.03,128.72) 293.43,129.12 U2024.H14 v3(293.03,129.52) U2024.H13 ; U55.A3 v3(269.53,164.35) ; U1.H18 U1.J18 ; v1(107.26,43.01) 107.1,43.17 JSSD1.9 ; v1(294.86,22.18) R317.1 v1(294.18,22.86) ; R2138.1 R2123.1 ; U2022.C11 v3(240.88,166.75) U2022.D10 ; U1.AJ38 U1.AJ37 169.16,156.79 v1(168.84,156.47) ; v3(288.1,153.74) U2023.T10 ; v1(132.11,77.55) 132.82,78.26 JDIMM1.2 ; U55.D10 275.93,166.75 v3(275.93,166.75) U55.C11 276.73,165.95 v3(276.73,165.95) U55.C12 ; U1.F13 186.7,139 v1(187.02,138.68) ; JDIMM3.23 138.3,76.23 v1(138.35,76.28) 137.7,76.28 137.3,75.88 JDIMM3.19 ; U2026.U14 254.47,97.92 v3(254.87,98.32) ; U2026.N12 v3(253.27,94.32) ; JDIMM1.22 137.82,78.07 138.34,77.55 v1(138.35,77.55) 138.35,77.56 138.82,78.03 JDIMM1.26 ; JDIMM1.6 133.82,78 v1(134.27,77.55) 134.82,78.1 JDIMM1.10 ; v3(275.93,168.35) U55.F10 275.53,168.75 v3(275.93,169.15) U55.G10 ; JDIMM1.48 144.32,77.69 v1(144.18,77.55) 143.54,77.55 143.32,77.77 JDIMM1.44 ; v1(178.09,76.28) 178.3,76.07 JDIMM3.175 ; v3(250.91,164.35) U48.U14 ; v1(152.43,157.84) 152.06,157.47 U1.BM38 ; U2023.T5 288.5,149.34 v3(288.1,148.94) ; v1(107.26,51.9) 106.99,52.17 JSSD1.45 ; U2024.U12 300.63,130.72 v3(301.03,130.32) ; v3(287.43,112.29) 287.82,112.68 U2025.U3 ; v3(263.43,87.92) U60.N12 ; U2025.K14 293.43,121.49 v3(293.03,121.89) ; U2025.M10 291.83,118.29 v3(291.43,118.69) ; v1(190.65,152.81) 190.57,152.73 190.02,152.73 U1.A30 ; v1(142.27,77.55) 142.32,77.6 JDIMM1.40 ; U2025.E3 297.43,112.69 v3(297.82,113.09) ; v3(288.23,113.88) 288.63,114.28 U2025.T5 ; 167.33,154.51 U1.AL34 ; 167.33,154.51 v1(167.26,154.51) ; 167.33,154.51 167.34,154.51 U1.AL33 ; U2026.L10 251.27,93.12 v3(251.67,93.52) ; U2023.L10 v3(292.1,153.74) U2023.M10 v3(291.3,153.74) ; v3(260.51,167.55) U48.N3 ; 183.73,154.52 v1(183.8,154.52) ; 183.73,154.52 U1.L33 ; 183.73,154.52 U1.L34 ; U2022.R14 v3(244.08,176.35) ; JDIMM1.244 195.32,77.59 v1(195.36,77.55) 195.99,77.55 196.32,77.88 JDIMM1.248 ; v3(252.51,168.35) U48.N12 ; U55.B10 275.53,165.55 v3(275.93,165.15) ; JWLAN1.57 v1(266.75,80.21) ; U48.L10 v3(254.11,169.15) 254.11,169.15 U48.M10 ; PU5.3 303.44,198.6 v1(303.11,198.93) ; U2024.G10 292.23,131.92 v3(292.23,131.92) 291.83,132.32 U2024.F10 291.83,132.32 v3(291.43,131.92) ; R2139.1 R2141.1 R2142.1 R2125.1 R2126.1 83.15,92.92 v1(83.03,93.04) ; v3(244.28,167.95) 244.27,167.95 U2022.E14 243.67,167.95 v3(243.28,167.55) ; v3(263.43,91.12) U60.K13 U60.K14 261.85,90.72 v3(261.63,90.5) 261.62,90.5 260.8,90.5 ; U60.C11 v3(265.03,95.92) U60.D10 ; JDIMM1.106 158.82,77.71 158.6,77.5 v1(157.89,77.5) ; JDIMM3.5 133.8,75.61 133.58,75.82 133.58,76.61 133.89,76.91 v1(134.27,76.91) ; v3(293.03,121.09) 293.03,121.09 ; JDIMM1.56 146.32,78.33 146.84,77.8 146.84,77.17 146.59,76.91 v1(146.21,76.91) 145.7,76.91 145.32,77.3 JDIMM1.52 ; U48.K2 v3(260.51,170.75) ; JDIMM1.72 150.32,77.6 v1(150.27,77.55) 149.51,77.55 149.32,77.74 JDIMM1.68 ; v3(290.63,129.52) 291.03,129.12 U2024.E14 291.03,129.12 v3(290.63,128.72) ; U2024.E1 291.03,139.52 v3(290.63,139.92) ; v3(297.82,121.08) 297.43,121.48 U2025.E14 297.42,121.48 v3(297.02,121.08) ; U2024.D10 290.23,132.32 v3(289.83,131.92) 289.83,131.92 U2024.C11 v3(289.03,131.12) U2024.C12 289.43,130.72 v3(289.83,130.32) ; v3(243.38,61.12) 243.38,60.7 U2.AG11 ; v3(289.83,120.29) 289.43,119.89 U2025.R12 289.03,119.49 v3(289.03,119.49) U2025.R11 289.43,119.08 v3(289.83,118.69) U2025.P10 ; JDIMM3.209 186.8,76.08 v1(186.6,76.28) ; JDIMM1.196 183.32,77.58 v1(183.29,77.55) ; v3(253.27,98.32) U2026.U12 v3(253.27,97.52) ; JDIMM3.231 192.3,75.78 v1(191.8,76.28) 191.3,75.78 JDIMM3.227 ; v3(262.26,170.2) 262.11,170.35 U48.K1 ; JDIMM1.184 180.32,78.13 v1(179.74,77.55) 179.32,77.97 JDIMM1.180 ; v3(252.51,171.55) U48.H13 U48.H14 251.31,171.95 v3(250.81,171.95) ; U60.H13 v3(262.63,92.72) U60.H14 261.78,92.32 v3(261.63,92.47) 261.62,92.48 260.83,92.48 ; v3(261.63,96.32) U60.C14 v3(262.63,95.92) ; U2025.U1 287.83,111.08 v3(287.43,110.68) ; C572.1 v1(47.98,41.99) ; U60.C12 263.83,96.32 v3(263.43,96.72) ; JDIMM1.102 157.82,77.57 v1(157.89,77.5) ; JDIMM1.230 191.82,77.57 v1(191.8,77.55) ; v3(243.28,174.75) 243.28,174.75 U2022.N14 v3(244.08,174.75) ; JDIMM3.15 136.3,76.16 v1(136.18,76.28) ; JDIMM3.201 184.8,76.13 v1(184.94,76.28) 185.58,76.28 185.8,76.06 JDIMM3.205 ; JDIMM3.171 177.3,75.38 176.98,75.7 v1(176.44,75.7) 176.3,75.56 JDIMM3.167 ; JDIMM1.206 185.82,77.79 185.58,77.55 v1(184.94,77.55) 184.82,77.68 JDIMM1.202 ; v1(160.18,76.23) 159.62,76.23 159.3,75.91 JDIMM3.107 ; JDIMM3.81 152.8,75.66 v1(152.18,76.28) 151.8,75.9 JDIMM3.77 ; v3(262.63,86.32) U60.R14 v3(261.83,86.32) ; v3(290.63,121.89) 291.03,121.49 U2025.N14 ; U2024.P10 v3(297.83,132.72) ; U2022.B10 v3(240.88,165.15) ; v3(301.03,128.72) U2024.U14 300.23,129.52 v3(300.23,129.52) ; JSSD1.39 107.05,50.67 v1(107.26,50.88) ; v3(250.91,175.55) 251.31,175.95 U48.C14 v3(251.71,175.55) ; v3(296.9,148.94) 296.5,149.34 U2023.F5 296.5,149.41 v3(296.1,149.81) 295.7,149.41 U2023.G5 ; v3(242.48,167.55) U2022.E12 ; v3(234.48,166.75) U2022.C3 v3(235.28,166.75) 235.67,166.35 U2022.C4 ; U2024.E3 v3(291.43,138.32) ; JDIMM3.1 132.8,75.59 v1(132.11,76.28) ; v1(179.74,76.28) 179.8,76.22 JDIMM3.181 ; v3(300.23,132.72) 299.83,132.32 U2024.T10 ; v3(290.5,155.34) U2023.N12 v3(291.3,155.34) ; JDIMM1.222 189.82,77.88 v1(190.15,77.55) 190.53,77.55 190.82,77.84 JDIMM1.226 ; JDIMM3.57 146.8,76.07 146.59,76.28 v1(146.21,76.28) 145.7,76.28 145.3,75.88 JDIMM3.51 ; v1(155.61,76.23) 155.8,76.04 JDIMM3.93 ; U48.C3 259.71,176.35 v3(259.71,176.35) U48.C4 v3(258.91,176.35) U48.B5 258.51,176.75 v3(258.11,177.15) ; JWLAN1.45 v1(269.75,80.21) ; v3(267.93,164.35) U55.A1 v3(268.73,165.15) ; v3(300.23,131.92) U2024.T10 ; U2024.T10 299.83,132.32 v3(299.43,131.92) U2024.R11 ; JDIMM3.47 144.3,75.39 144.81,75.9 144.81,76.79 144.69,76.91 v1(144.18,76.91) 143.54,76.91 143.3,76.67 JDIMM3.43 ; v3(234.48,170.75) U2022.H2 ; v1(132.11,88.98) 132.57,88.52 JDIMM1.1 ; v3(253.31,177.15) 252.91,177.55 U48.A12 ; JSSD1.57 v1(107.26,55.17) ; v3(263.43,95.12) U60.E12 ; U1.AL14 167.95,139.28 v1(167.63,138.95) ; v3(258.91,165.15) 258.51,165.55 U48.T5 ; v3(263.43,98.32) U60.A12 ; v3(245.27,98.32) 245.67,97.92 U2026.U3 ; v3(254.11,165.15) 254.51,165.55 U48.T10 ; JWLAN1.39 v1(271.25,80.21) ; U1.BK25 U1.BJ25 153.97,148.39 155.01,148.39 v1(155.08,148.46) ; v3(271.43,87.92) U60.N3 v3(270.63,87.92) ; JWLAN1.77 v1(261.15,80.22) ; 217.09,109.81 217.09,108.92 ; v3(297.7,147.34) 297.3,147.74 U2023.E3 v3(297.7,148.14) ; v1(157.89,77.5) 157.18,77.5 156.82,77.86 JDIMM1.98 ; JSSD2.9 107.18,67.54 v1(107.54,67.9) ; JDIMM1.31 140.07,88.71 140.37,89.01 v1(140.37,88.98) ; JDIMM1.168 176.32,78.3 176.44,78.18 v1(176.44,77.55) ; JDIMM3.197 183.8,75.77 v1(183.29,76.28) 182.8,75.79 JDIMM3.193 ; v3(299.43,130.32) U2024.R12 ; U48.P10 254.51,167.15 v3(254.11,166.75) U48.R11 v3(253.31,165.95) U48.R12 v3(252.51,166.75) ; v3(267.93,165.95) U55.C1 v3(268.73,166.75) ; v3(289.03,111.49) 289.43,111.09 U2025.R1 289.43,111.08 v3(289.03,110.68) ; JDIMM1.39 142.07,88.54 142.27,88.74 v1(142.27,88.98) 142.72,88.98 143.07,88.63 JDIMM1.43 ; JWLAN1.69 v1(263.75,80.21) ; JDIMM3.39 142.3,76.25 v1(142.27,76.28) 141.89,76.28 141.3,75.69 JDIMM3.35 ; C699.2 v1(44.55,39.7) ; U60.G10 v3(265.03,93.52) U60.F10 ; v3(230.35,66.75) 229.89,66.3 U2.R38 ; v3(299.43,139.92) 299.03,139.52 U2024.R1 298.63,139.12 v3(298.63,139.12) ; JDIMM3.243 195.3,76.22 v1(195.36,76.28) 195.99,76.28 196.3,75.97 JDIMM3.247 ; v3(262.63,97.52) 262.23,97.92 U60.A14 v3(261.63,97.92) ; U1.AB33 174.81,154.19 v1(175.14,154.52) 174.81,154.84 U1.AB34 ; v1(48.33,35.64) 48.43,35.54 C622.1 ; U48.N1 v3(262.11,167.55) ; v3(288.23,131.92) 288.63,132.32 U2024.B10 ; v3(262.11,165.95) U48.R1 261.71,166.35 v3(261.31,166.75) ; G2.G47 267.69,145.06 v3(267.69,144.94) 267.81,144.94 G2.F46 ; v3(261.83,84.72) U60.U14 ; JDIMM3.239 194.3,75.69 v1(193.71,76.28) 193.3,75.87 JDIMM3.235 ; v3(290.63,120.29) U2025.N12 291.03,119.89 v3(291.43,120.29) ; JDIMM1.86 153.82,77.54 153.19,76.91 v1(152.18,76.91) ; JDIMM1.94 155.82,77.71 v1(155.61,77.5) 155.15,77.5 154.82,77.83 JDIMM1.90 ; v3(251.71,165.95) U48.R14 v3(250.91,165.95) ; U55.B5 v3(271.13,165.15) ; v3(299.43,128.72) U2024.R14 ; JSSD1.51 107,53.67 v1(107.26,53.93) ; PR3553.1 v1(296.13,200.58) ; U55.C4 v3(271.13,166.75)
  BOTTOM w0.33: PU1303.A2 152.56,198.19 152.82,197.93
  BOTTOM w0.356: v1(165.96,150.99) 165.96,151.41 U1.AN29 U1.AN30 166.07,152.19 v1(165.69,152.57) ; C2136.2 v1(31.43,81.98) ; PR3554.1 v1(298.8,204.54) ; v1(160.72,151.01) 160.83,151.01 U1.AW29 U1.AW30 161.37,152.19 v1(161.75,152.57) ; v1(219.93,166.83) 219.81,166.96 PR724.2 ; v3(157.03,152.54) 156.68,152.19 U1.BE30 U1.BE29 156.63,151.35 v1(156.32,151.04) ; v1(183.99,162) 183.48,162.51 PR1173.1 ; PR503.1 260.37,48.47 v1(260.07,48.77) ; C239.1 29.81,46.82 29.69,46.69 v1(29.69,46.69) ; U59.3 136.87,147.77 v1(136.62,147.53) 136.62,147.07 C248.1 ; C1372.2 65.81,19 v1(66.39,19) ; C623.1 v1(41.8,41.99) ; v1(278.73,192.1) 278.73,191.69 278.51,191.47 PR2261.2 ; v1(200.76,198.07) 200.63,197.95 R374.2 ; v3(294.63,130.32) U2024.K13 ; v1(172.78,152.57) 172.79,152.57 U1.AD30 U1.AD29 173.17,151.44 v1(173.61,151.01) ; 217.09,108.92 217.09,108.36 216.94,108.21 PC192.1 215.79,108.21 215.42,107.83 PU1609.3 ; v1(223.87,121.36) 224.02,121.51 C2204.2 ; PC3507.2 210.03,98.63 209.65,99.01 v1(209.65,99.27) 209.9,99.52 PR3440.1 ; 263.18,83.65 263.18,84.46 v3(263.43,84.72) ; v1(179.75,151.01) 180.26,151.52 U1.R29 U1.R30 180.27,152.19 v1(180.65,152.57) ; v3(231.62,119.08) 230.3,119.08 229.64,118.42 R925.2 R924.2 ; PC1328.1 187.65,197.76 v1(187.09,197.76) ; U2022.N12 v3(242.48,174.75) ; R486.1 92.68,54.69 v1(93.06,55.07) ; v1(291.82,178.26) 291.87,178.31 PR1459.2 ; v1(223.36,195.79) 223.24,195.66 PC1074.1 222.6,195.74 PC1072.2 ; C2217.2 v1(234.52,111.95) ; v3(242.48,177.95) 242.62,178.1 242.62,178.83 ; PC3518.2 209.27,94.06 v1(208.76,93.55) 208.38,93.93 PR3541.2 ; v1(221.84,115.65) 222.3,116.11 C1400.2 222.6,116.28 221.71,117.17 v1(221.66,117.17) 221.63,117.2 v1(219.3,117.2) 219.3,117.06 219.03,116.79 Y6.2 217.9,114.98 v1(217.9,113.24) 217.9,113.11 218.31,112.7 220.29,112.7 220.73,113.15 Y6.4 221.41,113.91 v1(221.84,113.49) 221.91,113.41 C1399.2 ; C1395.2 v1(227.17,127.84) ; v1(126.21,136.1) PC3532.2 126.21,134.22 PR3457.1 ; v3(289.03,129.52) U2024.C14 289.43,129.12 v3(289.03,128.72) ; v1(286.1,70.31) 286.35,70.06 R473.1 ; PR3446.2 214.35,103.66 v1(214.35,104.19) 214.42,104.27 PR3573.1 ; v1(168.45,150.96) U1.AK29 U1.AK30 168.43,152.19 v1(168.05,152.57) ; v3(290.63,130.32) 291.03,130.72 U2024.E12 ; U2025.D10 297.83,118.69 v3(297.82,118.69) ; v1(208.12,109.05) 208.12,109.02 207.89,108.79 ; v1(175.93,151.01) 175.53,151.4 U1.AA29 U1.AA30 175.15,152.57 v1(175.14,152.57) ; C180.2 249.27,45.04 v1(249.52,44.78) ; C1407.2 v1(225.5,124.67) ; v3(250.91,164.35) 250.65,164.09 249.91,164.09 ; PU1.1 9.55,141.12 v1(10,140.67) ; v1(13.3,143.84) 13.18,143.72 C541.1 ; v1(163.72,150.98) U1.AT29 U1.AT30 ; PR3454.1 213.33,93.93 213.81,93.45 v1(214.42,93.45) 214.42,93.7 214.22,93.91 PC3505.2 ; C1394.2 229.69,124.94 v1(229.46,125.17) 229.22,124.94 C2443.2 ; 302.09,154.99 301.35,154.99 v3(300.9,154.54) ; U2023.N1 290.9,146.14 v3(290.5,145.74) ; U2021.4 v1(284.83,87.71) ; v3(269.03,89.52) U60.L5 v3(269.83,89.52) U60.M5 v3(269.03,88.72) ; PC3539.2 v1(123.86,139.01) ; C303.1 285.26,26.57 v1(285.47,26.37) ; R1020.2 233.01,125.79 231.74,124.52 v3(231.74,122.76) ; v1(234.03,196.6) PC1082.2 234.87,196.52 PC1081.1 ; PR439.1 208.28,115.04 v1(208.12,114.89) ; C2715.1 73.43,93.25 73.12,93.55 v1(72.87,93.55) ; PR34.2 v1(304.51,193.6) ; v3(301.03,110.69) 302.09,109.62 302.09,109.57 ; PC3558.2 v1(246.27,196.6) ; 276.91,180.6 PR3529.1 ; 257.25,87.16 257.04,86.95 C2657.2 256.01,86.95 ; v1(49.75,94.95) 49.25,94.44 U2012.4 ; 270.64,83.93 v3(271.43,84.72) ; v1(80.49,77.8) 80.21,78.08 R2122.1 ; v3(297.82,120.28) 297.43,119.89 U2025.E12 ; v1(171.2,152.57) 170.82,152.19 U1.AG30 U1.AG29 v1(170.81,150.98) ; PR3555.1 v1(309.72,198.8) ; C1401.2 v1(281.78,88.47) ; PR1420.2 291.13,185.7 v1(290.93,185.5) ; R269.2 144.37,151.26 v1(144.37,151.46) ; v1(212.19,158.58) 212.19,159.04 211.96,159.26 PC720.2 ; C2502.2 248.96,172.14 250.61,172.14 v3(250.81,171.95) ; C2220.2 232.89,111.59 v1(233.14,111.33) ; PC9.1 v1(306.79,196.26) ; v2(35.66,68.88) 35.66,68.89 35.99,69.22 C2124.2 R2060.1 ; v1(126.91,131.39) 126.81,131.49 PR3461.2 ; v1(247.49,44.45) 247.7,44.25 R123.1 ; U2022.A14 v3(244.32,164.75) ; U2022.T10 v3(240.88,176.35) ; U1.BR38 149.91,158.07 v1(149.9,158.06) ; 245.29,166.24 244.42,166.24 v3(244.32,166.35) ; v1(287.62,72.6) 288.07,73.04 C603.2 ; v3(242.48,175.55) U2022.R12 ; v1(248.89,78.57) 248.63,78.83 Y2.2 ; R464.2 R474.1 283.69,70.18 v1(283.81,70.31) ; v3(301.03,130.32) 301.47,129.87 302.1,129.87 ; R2084.1 v2(33.8,81.18) R2065.1 ; PC1273.2 v1(127.35,145.37) ; v1(86.33,78.18) 86,77.85 R2340.1 83.95,77.85 Q106.3 ; U1.BB29 U1.BB30 158.62,152.57 v1(158.6,152.57) ; C2444.2 v1(222.09,127.84) ; PR3448.2 211.83,101.63 v1(212.8,100.66) ; v1(211.04,93.55) 211.3,93.81 PC3510.2 ; PC1312.2 177.16,196.42 v1(176.88,196.14) ; PC1542.2 v1(270.66,196.6) ; C2117.2 32.82,68.49 R2064.1 ; PC3556.1 v1(247.49,195.66) ; D2004.2 v1(12.59,75.87) ; v1(14.4,75.9) 14.45,75.95 C2126.1 ; C677.2 v1(226.16,128.98) ; C1402.2 v1(280.77,88.47) ; v1(46.58,68.79) 46.26,68.47 C251.2 45.37,68.47 v1(44.93,68.91) ; PC801.2 v1(293.47,185.5) ; PC3541.2 v1(123.03,131.82) ; PC3570.2 v1(209.9,97.49) ; v3(300.9,148.14) 301.74,148.14 ; PR3590.1 v1(300.32,184.61) ; C676.2 v1(225.39,128.98)
  BOTTOM w0.381: U55.L10 v3(275.13,173.15) U55.M10 v3(275.93,173.95) ; R4.1 192.07,127.97 v1(192.88,128.78) ; U2022.R1 v3(232.79,176.44) 232.62,176.27 231.94,176.27 231.73,176.05 C2464.2 ; U2.U11 v3(243.48,65.52) ; U2025.C4 299.03,113.49 v3(299.42,113.89) 299.43,113.89 U2025.B5 299.83,114.29 v3(300.22,114.69) ; v3(262.11,177.95) U48.A1 v3(261.31,177.95) ; v1(118.08,191.27) 118.93,191.27 PC1156.1 ; 293.14,158.96 C910.2 293.14,157.17 v3(292.9,156.94) ; v3(263.43,84.72) U60.U12 v3(263.43,85.52) ; TP78.1 305.48,59.5 305.5,59.52 v1(306.04,59.52) ; v1(41.5,87.96) 42.01,88.47 42.82,88.47 R2052.2 ; U50.5 U50.7 ; U2022.J10 239.98,171.15 v3(239.93,171.1) ; U2023.C11 298.9,154.14 v3(299.3,153.74) U2023.B10 299.7,153.31 v3(300.1,152.91) 301.12,151.89 301.96,151.89 ; U2023.C11 298.5,153.74 v3(298.5,153.74) U2023.D10 v3(298.1,152.71) ; U2023.C11 v3(299.3,154.54) 299.3,154.54 U2023.C12 v3(298.5,155.34) ; U2.U10 v3(244.24,65.52) ; U2026.A1 v3(244.47,84.72) ; U2026.A1 v3(244.47,85.52) ; U2026.A1 244.07,85.12 v3(243.67,84.72) ; U55.R1 v3(268.73,176.35) ; U55.R1 268.33,175.95 v3(268.73,175.55) ; U55.R1 v3(267.93,176.35) ; v3(299.3,156.14) U2023.C14 v3(298.5,156.94) 298.59,157.03 298.59,158.8 C2549.2 ; U2025.M5 291.83,114.28 v3(292.23,113.88) U2025.L5 ; U2024.H2 293.43,138.72 v3(293.83,138.32) ; C639.2 99.28,93.04 v1(99.66,92.66) ; U60.E1 v3(273.03,95.12) ; v3(287.3,145.74) 287.7,146.14 U2023.U1 ; U2024.H1 293.43,139.77 v3(293.23,140.17) ; U2024.B5 288.63,136.32 v3(288.23,136.72) ; v1(266.8,51.51) 266.75,51.51 266.64,51.62 PR507.2 PC511.2 ; U2026.E3 v3(245.27,87.92) ; U2026.E3 245.67,88.32 v3(245.27,88.72) ; U2026.E3 v3(246.07,87.92) ; C334.2 C335.2 C336.2 C337.2 v1(282.8,38.56) ; U1.BT32 149.24,153.74 v1(148.91,153.41) ; JCAM1.9 159.16,199.79 v1(159.1,199.85) ; v1(264.89,30.94) 265.4,30.43 C349.1 ; JFAN2.4 v1(94.23,98.22) ; U2025.A12 300.62,119.88 v3(300.22,119.49) ; U2025.A12 v3(301.03,119.48) ; U2025.A12 300.63,119.89 v3(301.02,120.29) ; C616.2 v1(95.3,71.84) ; v1(217.15,169.89) 217.39,169.65 PC718.2 ; v1(42.77,38.56) 42.72,38.61 R56.2 ; U2022.R11 v3(240.88,176.35) ; v3(265.98,91.57) 265.93,91.52 U60.J10 ; U2025.C12 v3(299.43,119.48) U2025.C11 ; v1(248.89,78.57) v3(248.89,77.3) 248.58,76.99 C207.2 248.58,75.59 247.85,74.86 v3(247.85,73.71) ; v3(272.23,87.12) U60.R1 v3(273.03,86.32) ; U2023.C1 298.9,146.14 v3(299.3,145.74) 299.35,145.69 299.35,144.45 ; U2025.C11 298.63,118.69 v3(298.62,118.69) 298.23,118.29 U2025.D10 v3(298.23,117.73) ; U2025.C11 v3(299.43,118.69) ; v3(293.82,112.29) 293.43,111.89 U2025.K2 ; U2026.R4 v3(246.07,96.72) U2026.R3 v3(245.27,95.92) ; U2024.N14 297.43,129.12 v3(297.83,128.72) ; U55.U3 v3(269.53,177.95) ; v3(298.62,112.29) 299.02,112.68 U2025.C3 v3(299.43,112.29) ; U2025.H2 U2025.H1 295.03,110.63 v3(295.13,110.53) ; v3(295.08,140.22) 295.03,140.17 U2024.K1 U2024.K2 ; v3(277.53,177.95) U55.U12 ; v1(7.8,135.25) 7.67,135.25 7.16,135.77 C543.1 ; v1(30.91,67.67) 31.21,67.97 R2079.2 ; C338.1 284.53,38.64 v1(284.2,38.31) ; U55.R4 v3(270.33,176.35) U55.R3 v3(269.53,176.35) ; U2023.C3 298.9,147.74 v3(299.3,147.34) ; C2508.2 281.01,166.51 279.48,166.51 v3(279.33,166.35) U55.C14 ; C544.1 v1(5.81,135.08) ; U2026.T5 v3(246.87,97.52) ; PR1163.1 168.42,162.59 v1(168.37,162.64) ; U48.C11 v3(253.31,176.35) U48.C12 ; U48.C11 v3(254.11,175.55) 254.51,175.15 U48.D10 ; U48.C11 v3(254.11,176.35) 254.11,176.35 U48.B10 v3(254.91,177.15) ; C250.2 42.96,67.58 v1(42.77,67.39) ; v3(271.43,86.32) U60.R3 v3(270.63,86.32) U60.R4 v3(269.83,86.32) U60.T5 v3(269.03,85.52) ; v3(293.15,145.59) 293.3,145.74 U2023.K1 ; C506.1 v1(58.14,41.99) ; PC1610.1 197.91,184.66 v1(197.84,184.74) ; U2026.L5 v3(246.87,93.52) U2026.M5 ; v1(230.98,45.8) 231.16,45.62 R336.2 ; U2026.A3 v3(246.07,84.72) ; v3(270.33,174.75) 269.93,174.35 U55.N3 v3(269.53,174.75) ; C270.1 40.86,66.68 v1(40.86,67.26) ; U2023.J10 294.1,152.84 v3(294.05,152.79) ; v1(118.84,195.02) 118.95,195.02 119.48,194.5 PC1159.1 ; PC973.1 v1(271.44,195.94) ; v1(149.19,176.99) 149.75,176.43 PH1105.2 ; v1(95.85,46.94) 95.55,46.64 C576.1 ; v1(162.15,182.71) 162.58,183.14 PC1512.1 ; U2026.R12 v3(253.27,95.92) ; v1(137.89,155.53) 137.66,155.53 137.13,154.99 PR1202.1 ; v3(240.08,174.75) U2022.P10 ; v3(244.33,172.2) 244.08,171.95 U2022.K14 U2022.K13 242.88,171.95 v3(242.48,171.55) ; v3(297.02,118.69) 296.63,118.29 U2025.F10 v3(296.63,117.73) 296.38,117.73 U2025.G10 ; U2023.A14 v3(300.1,156.94) ; C244.2 v1(27.02,55.2) 26.97,55.15 C247.2 ; v1(144.37,147.91) R22.1 145.05,148.36 144.37,149.05 v1(144.37,149.69) ; U2024.J10 294.23,132.82 v3(294.18,132.87) ; v3(273.28,90.67) 273.23,90.72 U60.K1 U60.K2 ; U2025.A1 300.63,111.1 v3(301.02,111.49) 301.05,111.47 ; U2025.A1 300.63,111.08 v3(300.22,111.49) ; U2025.A1 v3(301.03,110.69) ; R261.1 C243.2 v1(26.13,50.24) ; v1(208.76,184.74) 208.83,184.66 PC1648.1 ; v1(40.2,65.48) C268.2 ; U2025.B10 v3(300.23,117.88) 300.96,117.15 v1(301.14,117.15) ; U55.R11 v3(275.93,176.35) U55.T10 ; v3(234.48,165.15) U2022.A3 v3(234.48,164.35) ; U55.H1 267.93,170.35 v3(267.78,170.2) ; v3(261.63,96.32) 260.75,96.32 260.75,96.32 ; v3(297.7,155.34) U2023.E12 v3(296.9,155.34) ; v3(243.67,87.92) 243.59,87.84 241.86,87.84 C2668.2 ; v3(246.86,73.74) 246.66,73.55 U2.A4 ; v3(267.68,172) 267.73,171.95 U55.K1 U55.K2 ; C187.2 v1(242.79,46.69) 242.72,46.61 C208.1 ; v3(232.88,177.95) U2022.U1 ; C178.1 218.23,59.87 v1(218.46,59.64) ; JTP1.4 273.85,25.04 v1(274.29,25.48) ; C310.2 v1(27.02,59.52) ; PC103.2 94,22.51 v1(93.57,22.94) ; 208.76,79.07 v1(208.76,78.82) ; C542.2 v1(4.67,134.45) ; C2123.2 13.53,76.74 D2004.2 ; C2123.2 v1(13.56,75.9) ; C2123.2 C2126.1 ; v1(108.3,0.91) SWPWR2.2 ; R21.1 145.77,127.97 v1(145.26,128.48) ; U2023.R4 v3(288.9,148.14) U2023.R3 289.3,147.74 v3(289.7,147.34) ; v3(233.68,165.95) U2022.C1 v3(232.88,165.95) ; JCAM1.4 v1(161.91,198.22) ; U2022.L10 240.48,172.75 v3(240.08,173.15) 240.08,173.15 U2022.M10 v3(240.88,173.95) ; C2663.2 256.66,96.72 255.76,96.72 ; R5.1 R6.1 184.88,127 v1(184.54,127.34) ; v3(301.02,113.09) 300.63,112.7 U2025.A3 ; U2024.K13 U2024.K14 295.03,128.62 v3(295.23,128.42) 295.25,128.4 ; C612.2 v1(93.95,39.3) ; v3(287.43,130.32) 287.83,130.72 U2024.A12 ; v3(252.47,87.93) 252.48,87.93 U2026.E12 ; U55.E14 279.33,167.95 v3(279.33,167.95) ; C71.2 v1(29.69,44.15) ; U2023.N14 v3(290.5,156.94) ; v3(236.08,165.15) 236.48,165.55 U2022.B5 ; U60.T10 v3(265.83,85.52) ; U60.T10 v3(265.03,86.32) U60.R11 ; U60.T10 v3(265.03,85.52) ; R480.1 v1(93.44,49.99) ; R2038.2 v1(54.71,94.44) ; v1(221.71,60.4) 221.84,60.28 R188.1 ; C238.2 30.5,46.69 ; v3(300.23,135.89) 299.83,136.29 U2024.T5 299.43,136.72 v3(299.43,136.72) 299.03,137.12 U2024.R4 v3(299.43,137.52) U2024.R3 299.03,137.92 v3(299.43,138.32) ; 298.26,141.15 298.26,140.35 v3(297.83,139.92) U2024.N1 ; U55.A12 v3(277.53,164.35) ; v1(25.19,68.33) 25.01,68.51 R2071.1 ; v3(288.9,145.74) 289.3,146.14 U2023.R1 v3(288.9,146.54) ; v3(299.42,111.49) 299.03,111.1 U2025.C1 v3(299.43,110.69) ; v1(47.47,67.14) 48.15,67.14 C252.2 ; v3(271.43,98.32) U60.A3 v3(271.43,97.52) ; R485.1 v1(93.44,51.77) ; C2048.2 46.15,78.06 46.53,77.68 46.71,77.68 v1(46.83,77.55) 46.83,76.41 45.79,75.37 v1(45.18,75.37) 45.16,75.39 44.93,75.39 44.27,76.04 Y2001.2 43.78,76.27 43.45,76.6 C2046.2 43.45,79 v1(43.91,79.45) ; v3(273.03,96.72) U60.C1 v3(272.23,96.72) ; 255.76,95.12 257.23,95.12 257.75,95.64 C2662.2 ; U2023.E14 v3(296.9,156.14) ; v1(33.24,23.32) 32.48,24.08 PD101.2 ; v3(287.3,156.94) U2023.U14 ; v1(32.38,67.72) 32.1,68 C2117.2 ; v3(297.83,137.52) U2024.N3 v3(297.83,138.32) ; U2026.H2 U2026.H1 243.67,90.72 v3(243.42,90.47) ; PC1609.2 200.25,186.26 v1(200.38,186.13) ; C613.2 94.39,84.47 v1(94.33,84.41) ; U2022.A1 v3(232.88,164.35) ; U2026.P10 v3(251.67,95.92) U2026.R11 ; U2025.J10 294.23,117.78 v3(294.18,117.73) ; U55.H2 v3(269.53,170.75) ; v3(255.06,171.1) 255.01,171.15 U48.J10 ; C177.2 218.23,59.41 v1(218.46,59.64) ; U60.F5 v3(269.83,93.52) U60.G5 ; Y2.4 246.84,77.47 247.02,77.3 v3(247.24,77.3) ; v3(261.83,87.92) U60.N14 ; C2628.2 274.82,87.23 273.73,87.23 v3(273.03,87.93) 272.64,88.32 U60.N1 ; U48.D10 v3(255.06,175.15) ; U48.D10 v3(254.11,174.75) ; U2023.E1 297.3,146.14 v3(297.7,145.74) ; C611.2 93.07,46.88 v1(92.93,47.01) ; v3(293.7,147.34) U2023.K2 ; v3(244.32,166.35) U2022.C14 v3(243.28,165.95) ; R479.1 v1(93.06,55.07) ; v3(290.5,147.34) 290.9,147.74 U2023.N3 ; JHDD1.11 296.13,90.21 v1(296.13,89.23) ; v3(274.98,171.1) 275.03,171.15 U55.J10 ; 260.16,97.92 v3(261.63,97.92) ; PC433.2 v1(107.41,93.04) ; JCAM1.5 162.51,197.04 162.14,196.67 v1(162.14,195.81) ; U55.E12 v3(277.53,167.55) ; v3(254.87,84.72) 254.97,84.62 255.85,84.62 ; v3(254.87,84.72) U2026.A14 ; v3(254.87,84.72) 254.83,84.68 C2655.2 ; C642.1 C641.2 279.19,25.43 v1(279.12,25.35) ; U55.N14 v3(279.13,174.75) 279.49,175.11 280.81,175.11 C2527.2 ; U2.W8 v3(245,64.34) ; v3(296.9,153.74) U2023.F10 296.5,153.16 v3(296.1,152.76) 295.7,153.16 U2023.G10 ; v3(242.48,177.15) U2022.U12 v3(242.48,177.95) ; U60.C4 v3(270.63,95.92) U60.C3 v3(271.43,95.92) ; U2026.G5 v3(247.67,89.52) U2026.F5 ; v3(297.83,110.69) U2025.E1 297.43,111.09 v3(297.82,111.49) ; C2627.2 260.69,87.67 260.94,87.92 ; v3(251.71,177.15) U48.A14 v3(250.91,177.15) ; v1(67.41,22.81) 68.28,22.81 D48.1 ; U2023.U3 v3(287.3,147.34) ; U2026.T10 v3(251.67,97.52) ; U2026.K2 v3(245.27,91.92) ; JSSD1.76 106.9,40.07 v1(107.13,39.83) ; v1(118.79,188.22) 118.89,188.32 PR1181.1 ; v1(295.37,86.95) 294.94,87.38 JHDD1.3 293.39,87.38 v1(292.96,86.95) ; v1(218.46,59.64) 218.97,60.15 TP18.1 ; U60.R12 v3(263.43,87.12) ; U2026.C3 245.67,86.72 v3(245.27,86.32) ; U55.R12 v3(277.53,175.55) ; U2026.K13 v3(254.07,92.72) U2026.K14 254.92,92.32 v3(255.12,92.52) 255.81,92.52 255.9,92.43 R908.2 257.02,92.43 ; v3(232.63,172) 232.67,171.95 U2022.K1 U2022.K2 ; U60.B10 v3(265.03,97.52) ; PC1629.1 187.12,184.66 v1(187.04,184.74) ; PC1317.1 149.44,197.19 v1(149.96,196.68) ; v3(268.73,177.95) U55.U1 v3(267.93,177.95) ; C580.1 96.49,71.79 v1(96.45,71.84) ; U2022.E3 v3(234.48,168.35) ; v3(243.29,92.44) 243.41,92.32 U2026.K1 ; C246.1 v1(37.18,43.39) ; U2.U8 v3(245,65.52) ; v1(47.21,45.29) 47.09,45.16 C633.1 ; U48.A3 v3(259.71,177.95) ; U60.L10 v3(265.83,89.52) U60.M10 v3(265.03,88.72) ; U55.T10 v3(275.13,176.35) ; U55.T10 v3(275.13,177.15) ; U55.T10 v3(275.93,177.15) ; PC1532.1 v1(175.99,183.34) ; C579.1 v1(96.45,84.92) ; v3(244.28,170.2) 244.13,170.35 U2022.H14 243.28,169.95 v3(243.28,169.95) U2022.H13 ; U60.U3 v3(271.43,84.72) ; v3(289.83,138.32) U2024.C3 v3(289.83,137.52) 289.43,137.12 U2024.C4 ; v3(289.03,139.92) U2024.C1 289.43,139.51 v3(289.03,139.11) ; v1(35.02,92.79) 35.78,93.55 D6.2 ; v3(232.63,170.15) 232.83,170.35 U2022.H1 ; v3(287.43,120.29) 287.83,119.89 U2025.U12 ; U2022.U3 v3(234.48,177.95) ; PC101.2 v1(81.38,25.1) ; Y2.2 247.89,79.34 247.69,79.53 246.07,79.53 245.36,78.82 245.36,77.52 245.89,76.99 C206.2 v3(245.89,76) 244.57,74.68 244.57,74.14 244.51,74.08 244.52,74.08 v3(244.53,74.08) ; C575.1 v1(95.9,61.62) ; PC1323.2 149.44,199.35 v1(149.32,199.47) ; v3(279.13,176.35) U55.R14 v3(278.33,176.35) ; v3(265.83,87.92) U60.P10 ; C2528.2 281.01,172.21 279.39,172.21 v3(279.38,172.2) 279.13,171.95 U55.K14 U55.K13 v3(277.53,171.55) ; 232.21,177.88 231.51,178.58 C2457.2 230.54,178.58 v3(230.22,178.26) ; v3(294.9,157.04) 295.02,157.16 C2548.2 ; U2026.J10 250.77,91.52 v3(250.72,91.57) ; 255.9,90.6 255.78,90.72 v3(255.07,90.72) 255.07,90.72 U2026.H14 U2026.H13 v3(253.27,91.12) ; U2025.N3 v3(290.63,112.29) ; U55.A14 v3(279.33,164.75) 279.65,164.42 280.97,164.42 C2509.2 ; v3(295,145.59) 294.9,145.69 U2023.H1 U2023.H2 ; U2024.F5 291.83,136.32 v3(292.23,136.72) U2024.G5 ; U2022.F5 236.48,168.75 v3(236.08,169.15) 236.48,169.55 U2022.G5 ; v2(44.93,77.8) 45.33,77.41 Y2001.4 ; D7.2 35.87,99.55 v1(35.02,98.71) ; PC1647.2 210.89,186.26 211.53,186.9 v1(211.6,186.9) ; C205.1 v1(245.41,46.69) ; U2026.R1 v3(243.47,96.32) ; 300.96,139.99 v3(301.03,139.92) U2024.U1 ; U2022.L5 v3(236.88,173.15) ; v3(262.11,176.35) U48.C1 v3(261.31,176.35) ; v3(245.27,95.12) U2026.N3 ; v3(250.91,167.55) U48.N14 v3(251.71,167.55) ; v3(234.48,174.75) U2022.N3 v3(235.28,174.75) ; PC102.1 v1(81.38,24.21) ; U2025.N1 v3(290.63,110.69) ; R63.1 252.14,61.97 v3(251.94,62.17) ; C2122.2 C2125.2 15.16,81.44 v1(15.34,81.61) ; v3(288.9,156.94) U2023.R14 v3(288.9,156.14) ; U2023.A1 300.5,146.14 v3(300.9,145.74) 301.97,144.67 301.97,144.62 ; v1(267.69,47.2) PR511.1 ; PC1161.1 127.4,200.18 v1(127.48,200.1) ; U2026.U1 v3(243.47,97.92) ; U55.N12 v3(277.53,174.75) ; U2025.K1 293.43,110.68 v3(293.28,110.53) ; v3(262.26,172.05) 262.16,171.95 U48.H1 U48.H2 ; v3(300.9,148.14) U2023.A3 ; C505.2 v1(58.14,41.1) ; U48.R4 v3(259.71,165.95) U48.R3 ; C406.1 v1(16.35,44.78) ; U48.E14 v3(251.71,174.75) ; v3(233.68,173.95) U2022.N1 v3(232.88,174.75) 232.57,174.44 231.15,174.44 C2463.2 C2476.2 ; U2026.F10 251.67,88.72 v3(251.67,88.72) ; U55.P10 v3(275.13,174.75) ; U2022.U14 v3(244.07,177.95) ; v3(236.88,173.95) U2022.M5 ; v3(269.83,97.52) U60.B5 ; U2023.L5 v3(292.1,148.94) U2023.M5 ; v3(271.43,94.32) U60.E3 ; U2024.A1 v3(287.43,139.92) ; v3(273.03,98.32) U60.A1 ; U2024.A3 v3(288.23,138.32) ; U3.4 v1(213.84,48.47) ; U2024.U3 v3(301.03,138.32) ; D37.1 v1(68.3,19) ; C577.1 v1(95.09,39.32) ; v3(254.87,95.12) U2026.N14 ; U48.E12 v3(252.51,174.75)
  BOTTOM w0.457: PC909.2 v1(254.99,205.69) ; PC917.2 v1(267.05,205.69) ; v1(153.2,197.93) 153.4,197.72 PC1319.2
  BOTTOM w0.508: v1(270.73,20.65) 269.28,20.65 JTP1.8 269.79,21.67 v1(270.73,21.67) ; v1(96.49,55.96) 96.11,56.34 C574.1 ; v1(118.46,125.05) 118.46,125.8 PC3538.2 ; JWLAN1.76 281.85,77.39 281.63,77.17 v1(280.77,77.17) ; JRTC1.2 82.07,21.99 v1(82.27,21.8) ; v1(273.91,58.7) 273.98,58.78 PC416.2 ; C610.2 v1(94.97,55.96) ; v1(74.68,17.97) 74.68,17.98 75.32,18.62 76.55,18.62 76.98,18.19 JRTC1.4 ; JRTC1.3 v1(74.44,24.54) ; v1(103.47,1.1) 103.66,0.91 SWPWR2.4 ; JKB1.51 92.94,12.03 93.44,12.53 93.45,12.53 v1(94.01,13.09) ; JIO1.78 303.88,54.94 v1(303.37,55.45) ; C637.2 290.35,75.72 289.4,76.67 v1(288.9,76.67) ; C604.2 v1(288.07,75.71) ; v2(37.43,77.3) 37.74,77.61 C2113.2 ; C2720.2 v1(11.91,40.21) ; v1(260.07,195.28) 259.68,195.66 PC972.1 ; v1(302.22,142.21) 302.23,142.19 ; PC412.2 v1(119.55,90.17) ; v1(301.96,152.85) 301.96,151.89 ; PC1307.2 151.52,200.95 v1(151.55,200.98) ; v1(279.65,22.56) 279.68,22.54 JTP1.7 ; JDBUG1.7 40.22,7.34 v1(40.96,8.08) ; v1(119.6,139.02) 119.66,138.96 PC3535.2 ; C2119.2 38.32,73.49 38.07,73.23 v1(38.04,73.23) ; JFAN2.6 92.68,100.66 94.2,99.14 v1(94.2,99.01) ; v1(282.03,22.56) 282.03,22.55 JTPBL1.8 ; v1(40.23,2.37) 39.43,3.16 JDBUG1.6 ; 152.82,197.93 v1(153.2,197.93) ; JFAN2.5 92.68,90.76 v1(93.31,90.12) ; PC907.2 v1(258.46,196.6) ; v1(292.32,22.56) 292.68,22.21 JTPBL1.7
  vias: v1(8.63,120.6) v1(10.89,43.26) v1(10.89,41.99) v1(14.7,19.89) v1(14.7,19) v1(15.08,146.26) v1(15.34,68.91) v1(15.72,33.48) v1(15.92,55.99) v1(16.61,136.22) v1(16.86,33.48) v1(16.86,32.46) v1(17.11,19.89) v1(17.11,19) v1(17.36,124.8) v1(17.88,135.46) v1(17.88,69.17) v1(18,19.89) v1(18,19) v1(18.38,61.55) v1(18.89,69.17) v1(19.45,80.04) v1(19.48,78.59) v1(19.91,133.68) v1(20.29,134.98) v1(20.29,126.22) v1(20.42,131.75) v1(20.42,129.87) v1(20.39,128.02) v1(20.59,133.63) v1(20.64,28.63) v1(20.64,27.28) v1(20.67,34.5) v1(20.67,33.61) v1(20.67,32.21) v1(20.77,132.9) v1(20.8,65.61) v1(20.8,64.98) v1(20.8,64.34) v1(20.8,62.18) v1(21.03,131.3) v1(21.31,130.25) v1(21.31,40.47) v1(21.56,34.37) v1(21.56,33.61) v1(21.81,129.24) v1(21.94,32.21) v1(21.97,31.19) v1(21.97,28.78) v1(22.32,128.22) v1(22.32,40.47) v1(22.32,39.45) v1(22.32,35.13) v1(22.32,34.37) v1(22.32,33.61) v1(22.7,127.21) v1(23.21,125.94) v1(23.59,35.11) v1(23.59,33.86) v1(23.59,32.85) v1(23.59,31.83) v1(23.85,124.67) v1(24.25,58.4) v1(24.25,57) v1(24.48,123.52) v1(24.48,68.15) v1(24.61,41.35) v1(24.73,1.6) v1(24.73,0.84) v1(24.86,35.13) v1(24.86,33.86) v1(25.12,122.38) v1(25.24,67.64) v1(25.88,121.24) v1(26,1.6) v1(26,0.84) v1(26.28,60.56) v1(26.28,59.16) v1(26.64,120.09) v1(27.17,67.59) v1(27.27,40.47) v1(27.27,39.58) v1(27.27,38.56) v1(27.27,36.02) v1(27.27,35) v1(27.27,33.86) v1(27.4,118.82) v1(27.91,67.62) v1(28.16,117.81) v1(28.16,1.6) v1(28.16,0.84) v1(28.8,116.79) v1(29.43,1.6) v1(29.43,0.84) v1(29.69,115.78) v1(30.7,114.51) v1(31.59,1.6) v1(31.59,0.84) v1(31.85,113.24) v1(31.85,61.67) v1(31.97,23.32) v1(31.97,22.18) v1(32.74,102.44) v1(32.74,100.41) v1(32.74,98.76) v1(32.74,97.11) v1(32.74,96.09) v1(32.74,94.19) v1(32.74,92.92) v1(32.86,1.6) v1(32.86,0.84) v1(33.24,22.18) v1(33.36,112.09) v1(33.75,102.44) v1(34.01,19) v1(34.01,18.11) v1(34.01,17.22) v1(34.01,16.21) v1(34.64,110.93) v1(34.77,19) v1(34.77,18.11) v1(34.77,17.22) v1(34.77,16.21) v1(35.02,100.57) v1(35.02,94.57) v1(35.5,82.12) v1(35.53,19) v1(35.53,18.11) v1(35.53,17.22) v1(35.53,16.21) v1(35.78,109.93) v1(36.14,82.12) v1(36.29,19) v1(36.29,18.11) v1(36.29,17.22) v1(36.29,16.21) v1(37.05,108.99) v1(37.05,19) v1(37.05,18.11) v1(37.05,17.22) v1(37.05,16.21) v1(37.82,19) v1(37.82,18.11) v1(37.82,17.22) v1(37.82,16.21) v1(38.07,108.16) v1(39.21,107.47) v1(39.47,18.62) v1(39.47,17.86) v1(39.47,17.1) v1(39.47,16.34) v1(39.8,85.02) v1(39.8,83.86) v1(40.23,17.99) v1(40.23,17.22) v1(40.23,16.34) v1(40.74,63.83) v1(40.99,17.99) v1(40.99,17.22) v1(41.96,61.34) v1(42.64,65.92) v1(42.64,64.21) v1(42.77,86.69) v1(42.77,85.42) v1(42.92,83.11) v1(42.9,81.92) v1(43.28,59.77) v1(44.04,14.56) v1(44.04,13.54) v1(45.05,14.56) v1(45.05,13.54) v1(45.69,63.96) v1(45.69,62.69) v1(45.69,61.42) v1(45.66,20.91) v1(46.2,71.2) v1(46.32,72.98) v1(46.43,20.91) v1(46.83,74.76) v1(46.96,63.96) v1(46.96,62.69) v1(47.06,24.21) v1(47.06,23.57) v1(47.06,22.69) v1(47.06,21.92) v1(47.06,20.91) v1(48.23,63.96) v1(48.23,62.69) v1(48.23,61.42) v1(48.74,77.55) v1(49.12,75.9) v1(49.45,24.46) v1(49.45,23.57) v1(49.45,22.69) v1(49.45,21.67) v1(49.5,102.44) v1(50.21,24.46) v1(50.21,23.57) v1(50.21,22.69) v1(50.21,21.67) v1(50.29,75.9) v1(50.9,24.46) v1(50.9,23.57) v1(50.9,22.69) v1(50.9,21.67) v1(51.02,71.07) v1(51.66,75.52) v1(51.66,53.34) v1(51.66,51.02) v1(51.66,24.46) v1(51.66,23.57) v1(51.66,22.69) v1(51.66,21.67) v1(52.42,71.07) v1(52.42,24.46) v1(52.42,23.57) v1(52.42,22.69) v1(52.42,21.67) v1(53.18,24.46) v1(53.18,23.57) v1(53.18,22.69) v1(53.18,21.67) v1(53.31,75.52) v1(53.92,77.42) v1(54.58,101.04) v1(55.24,60.96) v1(55.72,77.42) v1(55.72,25.23) v1(55.72,24.59) v1(55.98,100.79) v1(56.1,27.77) v1(56.23,99.65) v1(56.36,77.42) v1(58.11,77.45) v1(58.31,73.23) v1(59.48,73.23) v1(59.91,11.89) v1(59.91,11) v1(61.95,88.47) v1(63.72,44.02) v1(64.1,63.45) v1(64.1,61.93) v1(64.1,60.53) v1(64.1,44.66) v1(64.23,38.71) v1(64.23,37.8) v1(64.23,22.94) v1(64.23,21.92) v1(64.36,91.39) v1(64.43,89.87) v1(64.49,88.22) v1(64.49,86.95) v1(64.49,44.02) v1(64.49,11.03) v1(64.99,38.69) v1(64.99,37.8) v1(65.25,44.02) v1(65.25,22.94) v1(65.25,21.92) v1(65.25,11.03) v1(65.25,10.27) v1(65.63,60.53) v1(65.63,44.66) v1(66.01,44.02) v1(66.26,14.68) v1(66.26,13.67) v1(66.39,18.11) v1(66.39,17.22) v1(67.03,63.45) v1(67.03,60.53) v1(67.41,19) v1(67.41,18.11) v1(67.41,17.22) v1(67.66,91.39) v1(67.66,89.87) v1(67.66,88.6) v1(67.66,87.33) v1(68.17,45.29) v1(68.3,18.11) v1(68.68,92.92) v1(68.68,91.39) v1(68.68,89.87) v1(68.68,88.6) v1(68.68,87.33) v1(69.31,75.01) v1(70.2,75.64) v1(70.33,45.29) v1(70.93,52.4) v1(71.72,79.58) v1(72.36,45.16) v1(73.38,91.65) v1(73.38,54.54) v1(73.38,45.16) v1(73.5,90.12) v1(73.5,89.49) v1(73.5,88.34) v1(73.88,72.09) v1(74.14,54.54) v1(74.26,63.83) v1(74.26,45.16) v1(74.39,25.23) v1(74.77,83.54) v1(74.9,54.54) v1(75.28,73.49) v1(75.28,72.09) v1(75.28,57.1) v1(75.53,99.14) v1(75.79,82.38) v1(75.92,96.98) v1(76.04,87.33) v1(76.04,83.77) v1(75.99,52.43) v1(75.99,50.6) v1(77.01,90.76) v1(78.33,51.51) v1(78.76,16.67) v1(78.91,90.76) v1(79.09,52.02) v1(79.47,100.41) v1(79.47,66.63) v1(79.47,65.23) v1(80.56,50.57) v1(81.38,86.57) v1(81.38,85.3) v1(81.38,83.01) v1(81.5,63.73) v1(81.5,57.99) v1(81.5,56.59) v1(81.63,65.23) v1(81.88,49.69) v1(82.01,101.68) v1(82.14,85.3) v1(82.14,84.15) v1(82.14,83.01) v1(82.14,73.74) v1(82.14,71.83) v1(82.14,70.06) v1(82.9,57.99) v1(83.41,68.71) v1(83.54,102.31) v1(83.53,65.87) v1(83.53,64.6) v1(83.66,49.86) v1(84.3,10.49) v1(84.3,8.72) v1(84.81,102.82) v1(85.19,9.6) v1(85.57,49.86) v1(85.82,86.69) v1(85.82,85.3) v1(85.82,83.65) v1(86.08,103.58) v1(86.14,75.96) v1(86.14,75.07) v1(86.08,10.49) v1(86.08,8.72) v1(86.96,104.09) v1(86.96,49.86) v1(87.35,88.47) v1(87.35,86.57) v1(87.35,85.3) v1(87.35,83.52) v1(88.23,104.85) v1(89.12,105.36) v1(89.25,14.68) v1(90.27,106.12) v1(91.28,106.89) v1(92.3,107.52) v1(92.55,16.84) v1(92.55,16.21) v1(93.31,108.41) v1(93.95,62.91) v1(94.92,78.82) v1(95.3,63.33) v1(95.68,78.82) v1(96.45,78.82) v1(96.49,63.33) v1(96.77,99.77) v1(96.77,98.89) v1(98.9,11.76) v1(98.9,11) v1(98.9,10.24) v1(98.9,9.35) v1(98.9,8.59) v1(99.79,11.76) v1(99.79,11) v1(99.79,10.24) v1(99.79,9.35) v1(99.79,8.59) v1(100.68,11.76) v1(100.68,11) v1(100.68,10.24) v1(100.68,9.35) v1(100.68,8.59) v1(100.81,29.42) v1(100.81,28.65) v1(100.81,13.92) v1(100.81,13.16) v1(101.57,29.42) v1(101.57,28.65) v1(101.82,5.92) v1(101.82,5.16) v1(102.46,82.76) v1(102.46,82.12) v1(102.71,6.68) v1(102.71,5.92) v1(102.71,5.16) v1(102.87,59.49) v1(103.09,29.42) v1(103.09,28.65) v1(103.6,121.11) v1(103.63,59.49) v1(103.6,58.75) v1(103.83,48.72) v1(103.83,47.45) v1(103.86,29.42) v1(103.86,28.65) v1(104.11,122.25) v1(104.08,50.76) v1(104.08,49.99) v1(104.49,66.5) v1(104.62,75.11) v1(104.62,72.09) v1(104.59,70.54) v1(104.74,123.14) v1(104.72,46.01) v1(104.72,44.79) v1(105.38,124.16) v1(105.38,29.42) v1(105.38,28.65) v1(105.76,125.05) v1(106.01,125.94) v1(106.14,29.42) v1(106.14,28.65) v1(106.15,5.3) v1(106.52,126.95) v1(106.9,127.97) v1(107,64.44) v1(107.28,129.11) v1(107.54,29.42) v1(107.54,28.65) v1(107.79,130.76) v1(108.17,132.16) v1(108.3,29.42) v1(108.3,28.65) v1(108.55,133.43) v1(108.76,5.24) v1(109.06,135.08) v1(109.32,136.99) v1(109.57,138.38) v1(109.7,29.42) v1(109.7,28.65) v1(109.82,170.51) v1(109.82,169.5) v1(109.82,168.23) v1(109.82,166.96) v1(109.82,165.69) v1(109.82,164.42) v1(109.82,163.15) v1(109.82,161.88) v1(109.82,160.61) v1(109.82,159.34) v1(109.82,158.07) v1(109.82,156.67) v1(109.82,155.27) v1(109.82,153.88) v1(109.82,152.61) v1(109.82,151.34) v1(109.8,150.07) v1(109.82,148.29) v1(109.82,146.76) v1(109.82,145.62) v1(109.82,143.72) v1(109.85,141.18) v1(109.82,139.91) v1(109.87,142.45) v1(109.95,201.12) v1(109.95,199.85) v1(109.95,198.58) v1(109.95,197.31) v1(109.95,196.04) v1(109.95,194.77) v1(109.95,193.5) v1(109.95,192.23) v1(109.95,190.96) v1(109.95,189.69) v1(109.95,188.42) v1(109.95,187.15) v1(109.95,185.88) v1(109.95,184.61) v1(109.95,90) v1(109.95,88.98) v1(110.08,183.47) v1(110.08,58.88) v1(110.05,51.26) v1(110.21,205.57) v1(110.46,29.42) v1(110.46,28.65) v1(110.74,53.17) v1(110.74,51.9) v1(110.74,50.63) v1(110.74,49.48) v1(110.69,47.58) v1(110.69,46.18) v1(110.84,171.4) v1(110.84,170.51) v1(110.84,169.5) v1(110.84,168.23) v1(110.84,44.91) v1(110.96,64.24) v1(111.09,85.3) v1(111.09,84.53) v1(111.09,83.77) v1(111.09,83.01) v1(111.09,82.25) v1(111.09,81.49) v1(111.32,79.44) v1(111.48,205.64) v1(111.86,85.3) v1(111.86,84.53) v1(111.86,83.77) v1(111.86,83.01) v1(111.86,82.25) v1(111.86,81.49) v1(111.95,79.44) v1(111.98,75.01) v1(112.09,64.47) v1(112.62,85.3) v1(112.62,84.53) v1(112.62,83.77) v1(112.62,83.01) v1(112.62,82.25) v1(112.62,81.49) v1(112.59,79.44) v1(112.62,75.01) v1(113,205.64) v1(113.35,79.44) v1(113.35,75.01) v1(113.4,64.47) v1(113.76,95.96) v1(114.02,26.5) v1(114.02,24.84) v1(114.02,23.57) v1(114.02,22.3) v1(114.02,21.03) v1(114.02,19.76) v1(114.02,18.49) v1(114.02,17.22) v1(114.02,15.95) v1(114.02,14.68) v1(114.02,13.41) v1(114.02,12.14) v1(114.02,10.87) v1(114.02,9.6) v1(114.02,8.33) v1(114.02,7.06) v1(114.02,5.79) v1(114.14,205.64) v1(115.03,95.96) v1(115.03,27.77) v1(115.05,64.47) v1(115.41,205.64) v1(115.67,52.53) v1(115.79,71.2) v1(116.17,95.96) v1(116.33,50.88) v1(116.56,205.64) v1(116.68,59.77) v1(116.81,54.31) v1(116.94,98.63) v1(116.94,97.36) v1(116.94,27.89) v1(117.32,59.77) v1(117.44,94.69) v1(117.7,205.64) v1(117.95,98.63) v1(117.95,97.36) v1(118.08,59.77) v1(118.46,117.94) v1(118.46,94.69) v1(118.46,54.31) v1(118.59,133.3) v1(118.59,132.54) v1(118.59,131.78) v1(118.84,27.89) v1(118.97,205.64) v1(119.22,117.94) v1(119.35,133.3) v1(119.35,132.54) v1(119.35,131.78) v1(119.6,94.69) v1(120.11,133.05) v1(120.11,132.16) v1(120.24,117.94) v1(120.37,205.64) v1(120.75,27.89) v1(121,117.94) v1(120.95,54.43) v1(121.25,94.69) v1(121.51,205.64) v1(122.02,117.94) v1(122.4,27.89) v1(122.52,36.27) v1(122.52,35.64) v1(122.52,34.62) v1(122.52,33.73) v1(122.52,32.85) v1(122.52,31.45) v1(122.52,30.18) v1(122.52,28.91) v1(122.78,205.64) v1(122.78,117.94) v1(122.91,94.69) v1(123.54,140.92) v1(123.74,117.93) v1(123.79,54.56) v1(124.18,205.64) v1(124.3,193.63) v1(124.3,192.36) v1(124.3,191.09) v1(124.3,189.69) v1(124.5,117.93) v1(125.06,142.19) v1(125.06,141.3) v1(125.32,205.64) v1(125.57,54.56) v1(125.7,117.94) v1(126.21,193.63) v1(126.21,192.36) v1(126.21,191.09) v1(126.21,189.69) v1(126.33,117.94) v1(126.59,205.64) v1(126.72,142.7) v1(126.72,141.81) v1(126.72,140.92) v1(126.84,143.59) v1(127.1,37.8) v1(127.48,140.41) v1(127.6,143.59) v1(127.99,193.63) v1(127.99,192.36) v1(127.99,191.09) v1(127.99,189.69) v1(128.34,58.5) v1(128.37,57.23) v1(128.75,37.8) v1(128.8,153.72) v1(128.8,152.96) v1(128.8,152.2) v1(129.41,92.15) v1(130.02,37.8) v1(130.98,153.72) v1(130.98,152.96) v1(130.98,152.2) v1(130.97,82.12) v1(131.17,68.91) v1(131.3,72.72) v1(131.29,37.8) v1(132.11,92.54) v1(132.18,202.72) v1(132.25,153.72) v1(132.25,152.96) v1(132.25,152.2) v1(132.3,138.64) v1(132.3,137.87) v1(132.58,160.61) v1(132.56,159.85) v1(132.56,37.8) v1(133.07,138.64) v1(133.07,137.87) v1(133.45,202.72) v1(133.37,160.68) v1(133.52,153.72) v1(133.52,152.96) v1(133.52,152.2) v1(133.7,201.12) v1(133.7,199.85) v1(133.83,198.71) v1(133.83,138.64) v1(133.83,137.87) v1(133.83,37.8) v1(134.21,197.44) v1(134.27,92.79) v1(134.27,85.17) v1(134.27,83.26) v1(134.27,81.99) v1(134.47,71.96) v1(134.47,70.06) v1(134.47,68.79) v1(134.59,138.64) v1(134.59,137.87) v1(134.72,196.42) v1(135.1,37.8) v1(135.22,60.66) v1(135.35,138.64) v1(135.35,137.87) v1(135.61,195.53) v1(136.11,138.64) v1(136.11,137.87) v1(136.18,92.79) v1(136.18,84.53) v1(136.18,83.26) v1(136.18,81.99) v1(136.37,72.6) v1(136.37,71.33) v1(136.37,70.06) v1(136.37,68.79) v1(136.37,37.8) v1(136.49,194.77) v1(136.49,60.66) v1(136.88,138.64) v1(136.88,137.87) v1(137.64,138.64) v1(137.64,137.87) v1(137.64,37.8) v1(137.89,194.26) v1(138.34,92.79) v1(138.34,84.53) v1(138.34,83.26) v1(138.34,81.99) v1(138.27,60.66) v1(138.4,138.64) v1(138.4,137.87) v1(138.54,72.6) v1(138.54,71.33) v1(138.54,70.06) v1(138.54,68.79) v1(138.91,37.8) v1(139.16,149.81) v1(139.54,60.66) v1(139.92,149.81) v1(140.18,37.8) v1(140.37,92.79) v1(140.37,83.26) v1(140.37,81.99) v1(140.57,72.6) v1(140.57,70.06) v1(140.69,149.81) v1(141.07,194.24) v1(141.32,60.66) v1(141.45,149.81) v1(141.45,37.8) v1(142.27,92.79) v1(142.27,85.8) v1(142.27,84.53) v1(142.27,83.26) v1(142.27,81.99) v1(142.48,72.6) v1(142.48,71.33) v1(142.48,70.06) v1(142.48,68.79) v1(142.59,60.66) v1(142.72,170.13) v1(142.72,169.5) v1(142.72,37.8) v1(143.2,195.02) v1(143.48,170.13) v1(143.48,169.5) v1(143.86,195.91) v1(143.99,37.8) v1(144.18,92.79) v1(144.18,83.9) v1(144.18,81.99) v1(144.38,71.96) v1(144.38,70.69) v1(144.38,68.79) v1(144.37,60.66) v1(144.75,197.31) v1(144.88,193.75) v1(144.88,193.12) v1(144.88,170.39) v1(144.88,169.62) v1(145.26,199.34) v1(145.26,37.8) v1(145.38,202.64) v1(145.38,200.99) v1(145.64,170.39) v1(145.64,169.62) v1(145.64,138.08) v1(145.64,60.66) v1(145.74,131.4) v1(146.21,92.79) v1(146.21,84.92) v1(146.21,84.28) v1(146.21,81.74) v1(146.4,202.64) v1(146.4,71.45) v1(146.4,69.55) v1(146.53,37.8) v1(146.78,170.39) v1(146.78,169.62) v1(147.09,132.75) v1(147.21,131.55) v1(147.16,130.38) v1(147.42,194.77) v1(147.42,193.88) v1(147.42,193.12) v1(147.42,170.39) v1(147.42,169.62) v1(147.42,60.66) v1(147.67,202.64) v1(147.8,37.8) v1(148.25,127.09) v1(148.37,92.79) v1(148.37,85.55) v1(148.37,84.28) v1(148.37,83.01) v1(148.57,72.34) v1(148.57,71.07) v1(148.57,69.17) v1(148.71,170.39) v1(148.71,169.62) v1(148.69,60.66) v1(149.07,37.8) v1(149.35,170.39) v1(149.35,169.62) v1(149.6,128.44) v1(150.33,126.04) v1(150.27,92.79) v1(150.27,84.92) v1(150.27,83.01) v1(150.34,37.8) v1(150.48,71.71) v1(150.48,69.8) v1(150.46,60.66) v1(150.78,155.95) v1(150.95,129.78) v1(151.35,168.23) v1(151.35,167.34) v1(151.61,171.78) v1(151.61,37.8) v1(151.68,127.39) v1(151.73,60.66) v1(151.86,175.34) v1(151.86,174.07) v1(151.99,169.88) v1(152.12,168.23) v1(152.12,167.34) v1(152.24,142.38) v1(152.24,139.24) v1(152.18,92.79) v1(152.18,84.92) v1(152.18,83.65) v1(152.18,82.38) v1(152.38,71.71) v1(152.38,70.44) v1(152.38,69.17) v1(152.88,37.8) v1(153.03,128.74) v1(153.26,167.34) v1(153.51,60.66) v1(154.02,167.34) v1(154.01,126.97) v1(154.41,142.27) v1(154.4,37.8) v1(154.46,145.37) v1(154.46,144.53) v1(154.66,193.63) v1(154.72,70.94) v1(154.72,69.01) v1(154.78,60.66) v1(154.91,167.34) v1(155.29,187.15) v1(155.26,144.86) v1(155.26,143.64) v1(155.42,194.77) v1(155.42,193.63) v1(155.36,128.32) v1(155.45,150.96) v1(155.6,126.87) v1(155.61,92.79) v1(155.61,84.86) v1(155.61,83.59) v1(155.61,82.32) v1(155.67,167.34) v1(155.67,37.8) v1(156.05,187.91) v1(156.05,187.18) v1(156.18,194.77) v1(156.18,193.63) v1(156.37,71.66) v1(156.37,70.39) v1(156.37,69.12) v1(156.56,200.49) v1(156.56,167.34) v1(156.56,60.66) v1(156.81,187.91) v1(156.86,187.23) v1(156.94,37.8) v1(156.97,186.26) v1(157.15,151.04) v1(157.42,185.7) v1(157.45,167.34) v1(157.58,187.96) v1(157.6,187.18) v1(157.7,200.49) v1(157.83,186.29) v1(157.82,154.51) v1(157.82,153.22) v1(157.84,151.01) v1(157.75,124.14) v1(157.77,92.79) v1(157.83,60.66) v1(157.89,82.32) v1(158.21,185.73) v1(158.21,37.8) v1(158.34,193.25) v1(158.59,188.19) v1(158.59,187.2) v1(158.62,186.26) v1(158.72,125.05) v1(158.66,70.86) v1(158.66,68.96) v1(159.23,193.25) v1(159.39,157.12) v1(159.48,37.77) v1(159.61,60.66) v1(159.75,188.14) v1(159.75,187.12) v1(159.75,186.11) v1(160.12,193.25) v1(160.18,92.79) v1(160.18,84.23) v1(160.18,82.32) v1(160.51,188.14) v1(160.51,187.12) v1(160.51,186.11) v1(160.75,37.77) v1(160.94,70.64) v1(160.94,69.37) v1(160.88,60.66) v1(160.96,157.12) v1(161.13,193.25) v1(161.28,188.14) v1(161.28,187.12) v1(161.28,186.11) v1(161.39,53.42) v1(161.89,193.25) v1(162.04,188.14) v1(162.04,187.12) v1(162.04,186.11) v1(162.02,37.77) v1(162.36,128.37) v1(162.63,193.22) v1(162.72,92.79) v1(162.72,84.23) v1(162.72,82.96) v1(162.72,81.69) v1(162.72,71.02) v1(162.72,69.12) v1(162.66,60.66) v1(162.66,55.96) v1(162.8,188.14) v1(162.8,187.12) v1(162.91,53.42) v1(163.04,175.59) v1(162.99,124.72) v1(162.99,122.82) v1(163.29,171.78) v1(163.29,170.01) v1(163.29,37.77) v1(163.56,188.14) v1(163.56,187.12) v1(163.56,186.11) v1(163.67,193.22) v1(163.93,175.59) v1(163.93,174.45) v1(163.93,173.56) v1(163.93,60.66) v1(164.22,125.47) v1(164.18,55.96) v1(164.32,188.14) v1(164.32,187.12) v1(164.32,186.11) v1(164.26,127.45) v1(164.43,53.42) v1(164.5,71.66) v1(164.5,70.39) v1(164.5,68.48) v1(164.56,37.77) v1(164.75,92.79) v1(164.75,84.86) v1(164.75,82.96) v1(165.11,53.42) v1(165.2,55.96) v1(165.32,200.1) v1(165.65,70.51) v1(165.65,68.61) v1(165.7,60.66) v1(165.79,53.42) v1(165.83,37.77) v1(166.47,55.96) v1(166.47,53.42) v1(166.66,92.79) v1(166.66,84.99) v1(166.66,81.82) v1(166.85,187.15) v1(166.85,186.13) v1(166.76,128.36) v1(166.76,126.46) v1(166.76,124.55) v1(166.76,122.65) v1(166.97,60.66) v1(167.1,37.77) v1(167.48,189.06) v1(167.48,188.17) v1(167.61,187.15) v1(167.61,186.13) v1(167.8,72.16) v1(167.8,70.26) v1(167.99,191.47) v1(168.12,189.06) v1(168.37,37.77) v1(168.5,188.17) v1(168.5,187.15) v1(168.5,186.13) v1(168.56,92.79) v1(168.56,85.37) v1(168.56,83.47) v1(169.13,193.25) v1(169.27,129) v1(169.26,127.09) v1(169.4,188.14) v1(169.4,187.12) v1(169.4,186.11) v1(169.36,125.2) v1(169.36,123.35) v1(169.45,71.33) v1(169.45,69.42) v1(169.64,37.77) v1(170.02,193.25) v1(170.55,188.14) v1(170.55,187.12) v1(170.55,186.11) v1(170.59,92.79) v1(170.59,84.53) v1(170.59,82.63) v1(170.91,193.25) v1(170.91,37.77) v1(171.1,71.96) v1(171.1,70.69) v1(171.1,68.79) v1(171.31,188.14) v1(171.31,187.12) v1(171.31,186.11) v1(171.28,139.59) v1(171.59,150.94) v1(171.8,195.41) v1(171.79,127.09) v1(171.79,125.19) v1(171.79,123.2) v1(171.8,60.66) v1(171.93,193.25) v1(172.07,188.14) v1(172.07,187.12) v1(172.07,186.11) v1(172.18,37.77) v1(172.44,195.41) v1(172.5,92.79) v1(172.5,84.53) v1(172.5,82.63) v1(172.69,193.25) v1(172.83,188.14) v1(172.83,187.12) v1(172.83,186.11) v1(173.07,195.41) v1(173.07,60.66) v1(173.23,71.33) v1(173.23,69.42) v1(173.45,37.77) v1(173.59,188.14) v1(173.59,187.12) v1(174.09,198.45) v1(174.3,128.36) v1(174.36,188.14) v1(174.36,187.12) v1(174.36,186.11) v1(174.4,84.53) v1(174.4,82.63) v1(174.72,37.77) v1(174.85,60.66) v1(175.12,188.14) v1(175.12,187.12) v1(175.12,186.11) v1(175.1,176.1) v1(175.13,69.42) v1(175.2,126.83) v1(175.99,176.1) v1(175.99,175.34) v1(175.99,174.45) v1(175.99,173.43) v1(175.99,37.77) v1(176.1,125.3) v1(176.12,60.66) v1(176.44,92.79) v1(176.44,84.41) v1(176.44,83.14) v1(176.82,128.17) v1(177.26,37.77) v1(177.72,187.07) v1(177.69,186.01) v1(177.9,60.66) v1(178.09,92.79) v1(178.09,82.71) v1(178.09,70.95) v1(178.17,126.82) v1(178.53,191.6) v1(178.53,190.83) v1(178.51,189.08) v1(178.51,188.12) v1(178.51,187.1) v1(178.48,186.06) v1(178.53,37.77) v1(178.91,185.58) v1(179.29,188.12) v1(179.29,187.1) v1(179.29,186.08) v1(179.72,185.58) v1(179.72,125.33) v1(179.74,92.79) v1(179.74,84.66) v1(179.74,82.76) v1(179.74,71.33) v1(179.74,69.42) v1(179.67,60.66) v1(179.8,37.77) v1(179.93,193.25) v1(180.18,188.14) v1(180.18,187.13) v1(180.18,186.11) v1(180.23,128.51) v1(180.82,197.44) v1(180.94,60.66) v1(181.07,59.13) v1(181.07,37.77) v1(181.34,188.14) v1(181.34,187.12) v1(181.34,186.11) v1(181.39,92.79) v1(181.39,84.26) v1(181.39,83.01) v1(181.39,70.95) v1(181.39,69.68) v1(181.57,127.15) v1(181.71,193.25) v1(181.83,197.44) v1(181.83,195.66) v1(182.1,188.14) v1(182.1,187.12) v1(182.1,186.11) v1(182.21,60.66) v1(182.34,37.77) v1(182.72,193.25) v1(182.87,188.14) v1(182.87,187.12) v1(182.87,186.11) v1(182.93,125.81) v1(183.19,128.69) v1(183.29,92.79) v1(183.29,84.28) v1(183.29,83.01) v1(183.29,70.95) v1(183.29,69.68) v1(183.48,193.25) v1(183.63,188.14) v1(183.63,187.12) v1(183.63,186.11) v1(183.61,37.77) v1(183.99,60.66) v1(184.39,188.14) v1(184.39,187.12) v1(184.94,92.79) v1(184.94,84.53) v1(184.94,82.63) v1(184.94,71.2) v1(184.94,69.29) v1(184.88,37.77) v1(185.15,188.14) v1(185.15,187.12) v1(185.15,186.11) v1(185.26,60.66) v1(185.72,128.69) v1(185.91,188.14) v1(185.91,187.12) v1(185.91,186.11) v1(186.15,37.77) v1(186.6,92.79) v1(186.6,84.28) v1(186.6,83.01) v1(186.6,70.95) v1(186.6,69.68) v1(186.79,175.34) v1(186.79,174.07) v1(186.79,172.8) v1(186.79,171.53) v1(186.79,170.26) v1(187.04,140.25) v1(187.04,60.66) v1(187.17,194.77) v1(187.42,37.77) v1(187.88,186.24) v1(188.31,60.66) v1(188.5,92.79) v1(188.5,84.28) v1(188.5,83.01) v1(188.5,70.95) v1(188.5,69.68) v1(188.69,37.77) v1(188.77,189) v1(188.79,188.24) v1(188.79,187.23) v1(188.79,186.21) v1(189.12,185.63) v1(189.4,189) v1(189.45,191.47) v1(189.45,190.71) v1(189.48,188.24) v1(189.48,187.23) v1(189.48,186.21) v1(189.86,185.63) v1(189.96,37.77) v1(190.14,188.14) v1(190.09,60.66) v1(190.16,187.23) v1(190.16,186.21) v1(190.15,92.79) v1(190.15,84.53) v1(190.15,82.63) v1(190.15,76.91) v1(190.15,71.33) v1(190.15,69.42) v1(190.42,193.25) v1(190.6,185.6) v1(190.72,157.56) v1(191,188.22) v1(191,187.2) v1(191,186.19) v1(191.23,37.77) v1(191.36,60.66) v1(191.74,193.25) v1(191.8,92.79) v1(191.8,84.28) v1(191.8,83.01) v1(191.8,76.91) v1(191.8,70.95) v1(191.8,69.68) v1(191.89,153.52) v1(192.14,188.14) v1(192.14,187.12) v1(192.14,186.11) v1(192.37,193.25) v1(192.5,37.77) v1(192.63,134.36) v1(192.63,132.54) v1(192.9,188.14) v1(192.9,187.12) v1(192.9,186.11) v1(193.39,196.29) v1(193.66,188.14) v1(193.66,187.12) v1(193.66,186.11) v1(193.71,92.79) v1(193.71,84.28) v1(193.71,83.01) v1(193.71,70.95) v1(193.71,69.68) v1(193.77,193.25) v1(193.77,37.77) v1(194.03,196.29) v1(194.41,193.25) v1(194.42,188.14) v1(194.42,187.12) v1(194.42,186.11) v1(194.66,196.29) v1(194.79,134.45) v1(194.79,132.54) v1(195.04,37.77) v1(195.18,188.14) v1(195.18,187.12) v1(195.3,196.29) v1(195.3,60.66) v1(195.36,84.28) v1(195.36,82.38) v1(195.36,76.91) v1(195.36,70.95) v1(195.36,69.04) v1(195.95,188.14) v1(195.95,187.12) v1(195.95,186.11) v1(196.31,37.77) v1(196.71,188.14) v1(196.71,187.12) v1(196.71,186.11) v1(197.58,37.77) v1(197.84,185.5) v1(197.84,98.25) v1(198.85,37.77) v1(198.98,175.34) v1(198.98,174.58) v1(198.98,173.69) v1(199,170.77) v1(199,169.75) v1(199,168.86) v1(199.49,152) v1(199.99,165.18) v1(199.99,164.54) v1(199.99,163.91) v1(199.99,163.27) v1(200.12,37.77) v1(200.38,98.25) v1(201.11,187.38) v1(201.39,37.77) v1(201.95,187.4) v1(201.92,97.36) v1(201.98,188.17) v1(202.28,114) v1(202.28,112.47) v1(202.66,37.77) v1(202.92,194.64) v1(202.92,193.25) v1(203.06,188.14) v1(203.06,187.12) v1(203.06,186.11) v1(203.68,193.25) v1(203.82,188.14) v1(203.82,187.12) v1(203.82,186.11) v1(203.93,37.77) v1(204.44,193.25) v1(204.58,188.14) v1(204.58,187.12) v1(204.58,186.11) v1(204.69,195.28) v1(204.69,194.64) v1(205.2,37.8) v1(205.34,188.14) v1(205.34,187.12) v1(205.34,186.11) v1(205.33,158.07) v1(206.11,188.14) v1(206.11,187.12) v1(206.22,158.07) v1(206.87,188.14) v1(206.87,187.12) v1(206.87,186.11) v1(207.63,188.14) v1(207.63,187.12) v1(207.63,186.11) v1(207.87,158.83) v1(207.87,158.07) v1(208.12,108.16) v1(208.71,81.36) v1(208.76,185.5) v1(208.76,82.38) v1(208.76,77.55) v1(208.76,76.28) v1(208.76,75.01) v1(208.76,72.47) v1(208.76,71.2) v1(208.76,69.93) v1(208.76,68.66) v1(209.39,126.06) v1(209.65,174.83) v1(209.65,174.2) v1(209.65,173.56) v1(209.77,171.15) v1(209.77,170.51) v1(209.8,169.75) v1(209.8,168.86) v1(210.03,126.06) v1(210.66,153.37) v1(210.66,126.06) v1(211.3,126.06) v1(211.42,204.93) v1(211.42,201.5) v1(212.06,204.93) v1(212.06,201.5) v1(212.31,205.69) v1(212.29,181.44) v1(212.31,180.42) v1(212.29,179.78) v1(212.29,179.15) v1(212.29,178.51) v1(212.29,177.88) v1(212.29,177.24) v1(212.29,176.61) v1(212.69,204.93) v1(212.69,201.5) v1(212.82,120.73) v1(212.95,205.69) v1(213.08,199.85) v1(213.08,198.96) v1(213.46,198.2) v1(213.58,99.14) v1(213.58,97.87) v1(213.71,205.69) v1(213.84,199.85) v1(213.84,198.96) v1(214.09,120.73) v1(214.22,198.2) v1(214.22,98.5) v1(214.35,37.77) v1(214.47,205.69) v1(214.6,199.85) v1(214.6,198.96) v1(214.85,99.14) v1(214.85,97.87) v1(214.98,198.2) v1(215.23,205.69) v1(215.36,120.73) v1(215.62,37.77) v1(215.92,199.72) v1(215.92,198.83) v1(215.92,197.95) v1(216,205.69) v1(216.5,120.73) v1(216.68,199.72) v1(216.68,198.83) v1(216.68,197.95) v1(216.76,205.69) v1(216.89,37.77) v1(217.14,124.92) v1(217.44,199.72) v1(217.44,198.83) v1(217.44,197.95) v1(217.52,205.69) v1(217.77,124.92) v1(218.21,199.72) v1(218.21,198.83) v1(218.21,197.95) v1(218.16,37.77) v1(218.41,205.69) v1(218.41,124.92) v1(218.92,132.62) v1(218.97,199.72) v1(218.97,198.83) v1(219.04,124.92) v1(219.3,205.69) v1(219.43,37.77) v1(219.55,151.59) v1(219.55,150.96) v1(219.55,132.62) v1(219.68,124.92) v1(219.78,199.72) v1(219.78,198.83) v1(219.78,197.95) v1(219.93,94.06) v1(219.93,92.79) v1(219.93,91.65) v1(220.06,205.69) v1(220.19,132.62) v1(220.31,124.92) v1(220.49,199.72) v1(220.49,198.83) v1(220.49,197.95) v1(220.57,109.93) v1(220.7,157.69) v1(220.7,156.92) v1(220.7,156.16) v1(220.7,155.4) v1(220.7,37.77) v1(220.82,205.69) v1(221.08,94.06) v1(221.08,92.79) v1(221.08,91.65) v1(221.33,157.69) v1(221.33,156.92) v1(221.33,156.16) v1(221.33,155.4) v1(221.58,205.69) v1(221.84,109.91) v1(221.97,37.77) v1(222.35,205.69) v1(222.35,94.06) v1(222.35,92.79) v1(222.35,91.65) v1(222.6,109.91) v1(223.11,205.69) v1(223.24,204.93) v1(223.24,37.77) v1(223.36,109.91) v1(223.62,182.58) v1(223.62,181.82) v1(223.62,181.05) v1(223.62,180.29) v1(223.62,179.53) v1(223.62,178.77) v1(223.62,178.01) v1(223.62,177.24) v1(223.62,176.48) v1(223.62,94.06) v1(223.62,92.79) v1(223.62,91.65) v1(223.87,205.69) v1(223.87,204.93) v1(224.38,182.58) v1(224.38,181.82) v1(224.38,181.05) v1(224.38,180.29) v1(224.38,179.53) v1(224.38,178.77) v1(224.38,178.01) v1(224.38,177.24) v1(224.38,176.48) v1(224.51,204.93) v1(224.51,109.81) v1(224.51,109.05) v1(224.51,37.77) v1(224.63,84.66) v1(224.89,49.61) v1(224.89,48.34) v1(225.01,92.79) v1(225.01,91.9) v1(225.14,205.69) v1(225.14,204.93) v1(225.14,202.39) v1(225.14,201.76) v1(225.14,93.68) v1(225.39,84.66) v1(225.65,199.85) v1(225.65,198.96) v1(225.78,198.07) v1(225.78,92.79) v1(225.78,91.9) v1(225.78,37.77) v1(225.9,205.69) v1(226.16,84.66) v1(226.41,199.85) v1(226.41,198.96) v1(226.54,198.07) v1(226.54,92.79) v1(226.54,91.9) v1(226.66,205.69) v1(226.92,98.38) v1(226.92,97.49) v1(226.92,84.66) v1(227.05,37.77) v1(227.17,199.85) v1(227.17,198.96) v1(227.17,198.07) v1(227.3,92.79) v1(227.3,91.9) v1(227.43,205.69) v1(228.11,199.72) v1(228.11,198.83) v1(228.11,197.95) v1(228.06,95.2) v1(228.06,94.44) v1(228.06,93.42) v1(228.06,92.79) v1(228.06,92.15) v1(228.06,91.52) v1(228.19,205.69) v1(228.32,37.77) v1(228.82,95.2) v1(228.82,94.44) v1(228.82,93.42) v1(228.95,205.69) v1(228.87,199.72) v1(228.87,198.83) v1(228.87,197.95) v1(228.95,92.79) v1(228.95,92.15) v1(228.95,91.52) v1(229.64,199.72) v1(229.64,198.83) v1(229.64,197.95) v1(229.59,93.42) v1(229.59,37.77) v1(229.71,205.69) v1(229.71,92.79) v1(229.71,92.15) v1(229.71,91.52) v1(230.35,93.42) v1(230.4,199.72) v1(230.4,198.83) v1(230.4,197.95) v1(230.47,205.69) v1(230.6,92.79) v1(230.6,92.15) v1(230.6,91.52) v1(230.86,37.77) v1(230.98,93.42) v1(231.16,199.72) v1(231.16,198.83) v1(231.36,205.69) v1(231.87,96.6) v1(231.97,199.72) v1(231.97,198.83) v1(231.97,197.95) v1(232,98.38) v1(232,97.62) v1(232,94.06) v1(232.13,205.69) v1(232.13,92.79) v1(232.13,91.65) v1(232.13,37.77) v1(232.68,199.72) v1(232.68,198.83) v1(232.68,197.95) v1(232.89,205.69) v1(232.91,77.12) v1(232.94,75.57) v1(233.01,74.2) v1(233.14,110.57) v1(233.14,94.06) v1(233.14,92.79) v1(233.14,91.65) v1(233.4,37.77) v1(233.65,205.69) v1(234.21,78.13) v1(234.23,75.64) v1(234.41,205.69) v1(234.41,94.06) v1(234.41,92.79) v1(234.41,91.65) v1(234.67,37.77) v1(235.05,110.57) v1(235.17,205.69) v1(235.55,204.93) v1(235.55,84.66) v1(235.68,182.45) v1(235.68,181.82) v1(235.68,181.18) v1(235.68,180.42) v1(235.68,179.78) v1(235.68,179.15) v1(235.68,160.61) v1(235.68,94.06) v1(235.68,92.79) v1(235.68,91.65) v1(235.68,78.13) v1(235.9,159.84) v1(235.94,37.77) v1(236.19,204.93) v1(236.19,84.66) v1(236.32,205.69) v1(236.44,182.45) v1(236.44,181.82) v1(236.44,181.18) v1(236.44,180.42) v1(236.44,179.78) v1(236.44,179.15) v1(236.7,93.17) v1(236.7,92.28) v1(236.82,204.93) v1(236.82,94.44) v1(236.82,84.66) v1(236.95,110.57) v1(237.17,159.84) v1(237.21,91.52) v1(237.21,37.77) v1(237.33,202.26) v1(237.33,201.63) v1(237.46,205.69) v1(237.46,204.93) v1(237.46,94.06) v1(237.46,93.17) v1(237.46,92.28) v1(237.71,199.85) v1(237.71,198.96) v1(237.97,198.07) v1(238.22,205.69) v1(238.45,76.91) v1(238.48,199.85) v1(238.48,198.96) v1(238.48,37.77) v1(238.73,198.07) v1(238.98,205.69) v1(239.24,199.85) v1(239.24,198.96) v1(239.36,198.07) v1(239.36,92.54) v1(239.36,91.9) v1(239.49,75.64) v1(239.75,205.69) v1(239.77,37.77) v1(240.13,89.49) v1(240.13,88.6) v1(240.13,87.71) v1(240.3,199.72) v1(240.3,198.83) v1(240.3,197.95) v1(240.25,178.9) v1(240.51,205.69) v1(241.04,37.77) v1(241.07,199.72) v1(241.07,198.83) v1(241.07,197.95) v1(241.27,205.69) v1(241.83,199.72) v1(241.83,198.83) v1(241.83,197.95) v1(242.03,205.69) v1(242.29,104.35) v1(242.29,103.71) v1(242.31,37.77) v1(242.54,79.07) v1(242.59,199.72) v1(242.59,198.83) v1(242.59,197.95) v1(242.79,205.69) v1(243.05,76) v1(243.3,77.8) v1(243.35,199.72) v1(243.35,198.83) v1(243.58,37.77) v1(243.68,205.69) v1(244.16,199.72) v1(244.16,198.83) v1(244.16,197.95) v1(244.44,205.69) v1(244.56,76.06) v1(244.83,79.07) v1(244.85,37.77) v1(244.88,199.72) v1(244.88,198.83) v1(244.88,197.95) v1(245.21,205.69) v1(245.97,205.69) v1(246.12,37.77) v1(246.73,205.69) v1(247.37,204.93) v1(247.39,37.77) v1(247.49,205.69) v1(248,204.93) v1(248.38,205.69) v1(248.39,182.45) v1(248.38,180.17) v1(248.39,179.4) v1(248.64,204.93) v1(248.66,37.77) v1(248.76,180.67) v1(249.16,182.45) v1(249.16,180.17) v1(249.16,179.4) v1(249.16,178.64) v1(249.27,204.93) v1(249.27,202.39) v1(249.27,201.76) v1(249.52,205.69) v1(249.78,199.85) v1(249.78,198.96) v1(249.79,64.33) v1(249.91,84.53) v1(249.93,37.77) v1(250.29,205.69) v1(250.29,198.07) v1(250.54,199.85) v1(250.54,198.96) v1(250.86,84.47) v1(250.92,67.52) v1(251.05,205.69) v1(251.05,198.07) v1(251.2,37.77) v1(251.3,199.85) v1(251.3,198.96) v1(251.81,205.69) v1(252.45,37.77) v1(252.5,199.72) v1(252.5,198.83) v1(252.5,197.95) v1(252.57,205.69) v1(253.33,205.69) v1(253.26,199.72) v1(253.26,198.83) v1(253.26,197.95) v1(253.72,37.77) v1(254.02,199.72) v1(254.02,198.83) v1(254.02,197.95) v1(254.1,205.69) v1(254.1,178.64) v1(254.1,177.9) v1(254.1,73.87) v1(254.1,71.96) v1(254.6,68.91) v1(254.78,199.72) v1(254.78,198.83) v1(254.78,197.95) v1(254.99,37.77) v1(255.11,77.17) v1(255.11,62.31) v1(255.54,199.72) v1(255.54,198.83) v1(255.62,73.87) v1(255.62,71.96) v1(256,205.69) v1(256.13,62.31) v1(256.26,37.77) v1(256.36,199.72) v1(256.36,198.83) v1(256.36,197.95) v1(256.76,205.69) v1(256.76,68.91) v1(257.07,199.72) v1(257.07,198.83) v1(257.07,197.95) v1(257.27,73.87) v1(257.27,71.96) v1(257.4,77.17) v1(257.53,205.69) v1(257.53,37.77) v1(258.29,205.69) v1(258.29,83.77) v1(258.54,49.99) v1(258.54,49.36) v1(258.64,50.63) v1(259.05,205.69) v1(259.18,49.99) v1(259.18,49.36) v1(259.28,50.63) v1(259.81,204.93) v1(259.81,49.99) v1(259.81,49.36) v1(259.94,205.69) v1(259.91,50.63) v1(260.22,61.93) v1(260.22,61.14) v1(260.22,60.4) v1(260.22,59.49) v1(260.45,204.93) v1(260.57,67.9) v1(261.08,204.93) v1(261.21,205.69) v1(261.59,44.91) v1(261.72,204.93) v1(261.72,202.39) v1(261.72,201.76) v1(261.97,205.69) v1(262.05,181.69) v1(262.05,180.93) v1(262.05,180.29) v1(262.05,179.4) v1(262.05,178.64) v1(262.1,199.72) v1(262.1,198.83) v1(262.22,67.9) v1(262.48,197.95) v1(262.48,44.91) v1(262.73,205.69) v1(262.81,181.69) v1(262.81,180.93) v1(262.81,180.29) v1(262.81,179.4) v1(262.81,178.64) v1(262.86,199.72) v1(262.86,198.83) v1(263.24,44.91) v1(263.37,197.95) v1(263.49,205.69) v1(263.62,199.72) v1(263.62,198.83) v1(264,27.51) v1(264,26.62) v1(264.26,205.69) v1(264.51,178.64) v1(264.64,177.12) v1(264.64,174.58) v1(264.69,199.72) v1(264.69,198.83) v1(264.69,197.95) v1(264.89,173.31) v1(264.89,172.6) v1(265.02,205.69) v1(265.27,174.61) v1(265.27,171.02) v1(265.45,199.72) v1(265.45,198.83) v1(265.45,197.95) v1(265.78,205.69) v1(265.83,62.34) v1(265.83,61.67) v1(265.81,60.05) v1(265.83,58.96) v1(265.91,63.43) v1(265.88,57.94) v1(265.88,57.03) v1(266.1,172.24) v1(266.21,199.72) v1(266.21,198.83) v1(266.21,197.95) v1(266.92,63.43) v1(266.97,199.72) v1(266.97,198.83) v1(266.97,197.95) v1(267.08,33.4) v1(267.74,199.72) v1(267.74,198.83) v1(268.55,199.72) v1(268.55,198.83) v1(268.55,197.95) v1(268.55,69.42) v1(269.18,69.42) v1(269.26,199.72) v1(269.26,198.83) v1(269.26,197.95) v1(269.46,74.12) v1(269.72,60.1) v1(269.82,69.42) v1(270.43,60.13) v1(270.45,69.42) v1(271.11,35.51) v1(271.11,34.24) v1(271.11,32.97) v1(271.11,31.7) v1(271.11,30.43) v1(271.11,29.16) v1(271.11,27.89) v1(271.88,62.82) v1(271.88,62.06) v1(272.38,77.04) v1(272.38,76.15) v1(272.38,37.54) v1(272.38,36.53) v1(272.38,35.51) v1(272.38,34.24) v1(272.38,32.97) v1(272.38,31.7) v1(272.38,30.43) v1(272.38,29.16) v1(272.38,27.89) v1(272.77,62.82) v1(272.77,62.06) v1(273.65,62.82) v1(273.65,62.06) v1(273.65,35.51) v1(273.65,34.24) v1(273.65,32.97) v1(273.65,31.7) v1(273.65,30.43) v1(273.65,29.16) v1(273.65,27.89) v1(274.29,70.69) v1(274.9,62.41) v1(274.92,29.16) v1(275.05,179.53) v1(275.05,178.77) v1(275.05,177.88) v1(275.05,90.76) v1(275.08,90.04) v1(275.54,105.87) v1(275.54,104.22) v1(275.54,103.46) v1(275.56,105.11) v1(275.56,83.65) v1(275.56,74.76) v1(275.56,74.12) v1(275.81,182.58) v1(275.81,181.05) v1(275.81,180.17) v1(275.81,179.53) v1(275.81,178.77) v1(275.91,62.39) v1(276.22,75.04) v1(276.58,182.58) v1(276.58,181.05) v1(276.58,180.17) v1(276.58,179.53) v1(276.58,178.77) v1(276.58,63.71) v1(277.21,67.01) v1(277.21,64.6) v1(278.48,88.85) v1(278.48,88.09) v1(278.48,87.33) v1(278.48,86.69) v1(278.53,85.02) v1(278.53,84.38) v1(278.53,83.62) v1(278.53,82.99) v1(278.61,67.26) v1(279.12,34.62) v1(280,44.91) v1(281.27,175.59) v1(281.53,65.48) v1(281.53,63.96) v1(282.29,64.72) v1(282.29,52.53) v1(282.29,51.26) v1(282.29,49.99) v1(282.29,48.72) v1(282.29,47.45) v1(282.83,159.29) v1(283.01,158.13) v1(283.05,65.48) v1(283.05,63.96) v1(283.56,52.53) v1(283.56,51.26) v1(283.56,49.99) v1(283.56,48.72) v1(283.56,47.45) v1(285.47,202.39) v1(285.47,200.36) v1(285.47,198.45) v1(286.23,35.51) v1(286.23,34.24) v1(286.23,32.97) v1(286.23,31.7) v1(287.5,35.51) v1(287.5,34.24) v1(287.5,32.97) v1(287.5,31.7) v1(287.88,66.31) v1(288.01,64.47) v1(287.95,62.69) v1(288.64,99.77) v1(288.64,99.01) v1(288.64,98.25) v1(288.64,97.49) v1(288.77,35.51) v1(288.77,34.24) v1(288.77,32.97) v1(288.77,31.7) v1(288.89,55.83) v1(289.53,99.77) v1(289.53,99.01) v1(289.53,98.25) v1(289.53,97.49) v1(290.04,34.24) v1(290.04,32.97) v1(290.04,31.7) v1(290.42,99.77) v1(290.42,99.01) v1(290.42,98.25) v1(290.42,97.49) v1(290.75,85.17) v1(290.8,89.61) v1(290.8,87.33) v1(290.93,184.23) v1(290.93,182.96) v1(291.18,67.64) v1(291.18,66.37) v1(291.18,65.61) v1(291.18,44.66) v1(291.18,43.39) v1(291.31,99.77) v1(291.31,99.01) v1(291.31,98.25) v1(291.31,97.49) v1(291.56,85.04) v1(291.56,79.96) v1(292.2,185.5) v1(292.2,184.23) v1(292.2,182.96) v1(292.32,100.03) v1(292.32,25.1) v1(292.32,24.34) v1(292.32,23.32) v1(292.45,105.11) v1(292.45,104.09) v1(292.45,103.2) v1(292.45,102.31) v1(292.45,101.55) v1(292.45,96.04) v1(292.45,95.33) v1(292.45,94.52) v1(292.45,93.75) v1(292.45,92.87) v1(292.58,98.5) v1(292.58,97.36) v1(292.83,85.04) v1(292.83,79.96) v1(292.96,100.03) v1(293.21,107.04) v1(293.47,184.23) v1(293.47,182.96) v1(293.59,100.03) v1(293.59,98.5) v1(293.59,97.36) v1(293.72,105.11) v1(293.72,104.07) v1(293.72,103.2) v1(293.72,102.31) v1(293.72,101.55) v1(293.72,96.04) v1(293.72,95.33) v1(293.72,94.52) v1(293.72,93.75) v1(293.72,92.87) v1(293.97,106.89) v1(293.97,106) v1(294.1,79.96) v1(294.61,97.36) v1(294.99,105.11) v1(294.99,104.07) v1(294.99,103.18) v1(294.99,102.29) v1(294.99,101.55) v1(294.99,96.04) v1(294.99,95.33) v1(294.99,94.52) v1(294.99,93.75) v1(294.99,92.87) v1(294.99,43.39) v1(294.99,42.12) v1(295.12,38.05) v1(295.37,85.04) v1(295.37,83.77) v1(295.5,143.11) v1(295.45,142.47) v1(295.55,48.59) v1(295.63,45.16) v1(295.75,53.95) v1(295.75,46.69) v1(296.39,38.05) v1(297.02,63.45) v1(297.28,10.87) v1(298.17,10.87) v1(299.18,10.87) v1(299.44,169.37) v1(299.44,168.74) v1(299.44,168.1) v1(299.44,167.47) v1(299.82,182.07) v1(299.82,19) v1(300.07,169.37) v1(300.07,168.74) v1(300.07,168.1) v1(300.07,167.47) v1(300.07,10.87) v1(300.07,9.99) v1(300.71,142.83) v1(300.96,12.53) v1(300.96,11.76) v1(300.96,10.87) v1(301.34,142.83) v1(301.34,98.12) v1(301.47,31.32) v1(301.47,30.69) v1(301.47,30.05) v1(301.98,97.49) v1(302.1,107.26) v1(302.1,105.48) v1(302.1,31.32) v1(302.1,30.69) v1(302.24,136.49) v1(302.35,199.69) v1(302.35,198.17) v1(302.48,30.08) v1(302.61,98.12) v1(302.61,96.85) v1(302.86,31.32) v1(302.86,30.69) v1(303.25,117.68) v1(303.87,199.69) v1(303.87,198.17) v1(304.52,36.27) v1(305.28,39.45) v1(305.28,10.24) v1(305.4,44.15) v1(305.4,42.62) v1(306.04,37.8) v1(306.17,10.24) v1(306.17,9.1) v1(306.29,39.96) v1(307.82,38.56) v1(308.07,75.39) v1(308.2,40.72) v1(308.71,73.99) v1(308.96,77.04) v1(309.6,104.98) v1(309.6,103.95) v1(309.72,107.27) v1(310.23,77.3) v1(310.23,62.06) v1(310.23,60.53) v1(310.61,202.64) v1(310.61,201.88) v1(310.61,200.61) v1(310.61,199.34) v1(310.61,198.07) v1(310.61,196.8) v1(310.61,195.53) v1(310.61,194.26) v1(310.61,192.99) v1(310.61,191.72) v1(310.61,190.45) v1(310.61,189.18) v1(310.61,187.91) v1(310.61,186.64) v1(310.61,185.37) v1(310.61,184.1) v1(310.61,182.83) v1(310.61,172.04) v1(310.61,170.77) v1(310.61,169.5) v1(310.61,168.23) v1(310.61,166.96) v1(310.61,165.69) v1(310.61,164.42) v1(310.61,162.51) v1(310.61,161.24) v1(310.61,159.97) v1(310.61,158.7) v1(310.61,157.43) v1(310.61,156.16) v1(310.61,154.89) v1(310.61,153.62) v1(310.61,152.35) v1(310.61,151.08) v1(310.61,149.81) v1(310.61,148.54) v1(310.61,144.73) v1(310.61,143.46) v1(310.61,142.19) v1(310.61,140.92) v1(310.61,139.65) v1(310.61,138.38) v1(310.61,137.11) v1(310.61,135.84) v1(310.61,134.57) v1(310.61,133.3) v1(310.61,132.03) v1(310.61,130.76) v1(310.61,129.49) v1(310.61,125.68) v1(310.61,124.41) v1(310.61,123.14) v1(310.61,121.87) v1(311.12,113.11) v1(311.12,111.84) v1(311.12,95.96) v1(311.12,94.44) v1(311.12,93.17) v1(311.12,91.9) v1(311.12,90.63) v1(311.12,89.36) v1(311.12,88.09) v1(311.12,86.82) v1(311.12,85.55) v1(311.12,83.9) v1(311.12,82.63) v1(311.12,80.85) v1(311.12,79.58) v1(311.12,78.18) v1(311.12,73.49) v1(311.12,71.07) v1(311.12,68.28) v1(311.12,65.99) v1(311.13,42.34) v1(311.13,40.84) v1(311.13,39.34) v1(311.13,37.84) v1(311.13,36.34) v1(311.13,34.84) v1(311.13,33.34) v1(311.13,31.84) v1(311.13,30.34) v1(311.13,28.84) v1(311.12,26.75) v1(311.09,25.1) v1(311.09,23.83) v1(311.12,22.43) v1(311.12,21.29) v2(19.91,32.21) v2(26.39,73.74) v2(26.39,73.1) v2(26.64,76.53) v2(27.15,74.88) v2(31.25,53.08) v2(33.12,95.46) v2(33.24,53.19) v2(33.24,52.3) v2(33.37,28.27) v2(34.39,36.15) v2(35.28,74.93) v2(40.99,92.28) v2(41.63,92.28) v2(43.53,92.28) v2(45.69,79.07) v2(51.28,78.31) v2(51.91,90.26) v2(53.16,81.88) v2(53.82,82.48) v2(56.36,91.27) v2(60.42,22.81) v2(66.26,12.96) v2(89.89,20.02) v2(100.81,4.02) v2(109.44,56.09) v2(118.71,37.67) v2(119.98,30.31) v2(120.75,96.35) v2(121.13,116.54) v2(128.75,188.93) v2(130.91,165.56) v2(130.96,142.95) v2(132.23,151.18) v2(136.37,136.99) v2(147.92,171.28) v2(153.26,183.47) v2(185.9,43.39) v2(189.45,193.25) v2(191.87,40.85) v2(199.99,42.5) v2(222.22,200.36) v2(234.16,200.23) v2(265.91,32.59) v2(267.3,83.26) v2(270.1,28.91) v2(280.64,53.55) v2(290.55,54.94) v2(293.09,21.8) v2(295.88,94.19) v2(302.74,126.95) v2(302.99,12.91) v2(304.01,122.76) v3(19.15,161.75) v3(19.27,157.15) v3(19.27,155.32) v3(19.27,153.5) v3(19.27,151.46) v3(79.01,14.94) v3(192.63,150.45) v3(199.13,192.74) v3(200.25,192.71) v3(201.59,194.77) v3(211.3,166.07) v3(211.3,165.31) v3(211.3,164.54) v3(211.3,60.66) v3(211.3,59.39) v3(211.93,166.07) v3(211.93,165.31) v3(211.93,164.54) v3(212.57,166.58) v3(212.57,165.94) v3(212.57,165.18) v3(212.57,164.42) v3(212.69,115.27) v3(213.2,165.94) v3(213.2,165.18) v3(213.84,115.27) v3(214.47,115.27) v3(214.47,114.63) v3(215.11,115.27) v3(215.11,114.63) v3(215.11,114) v3(215.11,65.1) v3(215.11,63.71) v3(215.49,68.91) v3(215.62,66.88) v3(215.62,65.61) v3(216.38,74.63) v3(216.76,72.47) v3(216.76,70.95) v3(216.89,69.17) v3(218.41,74.76) v3(224.99,70.92) v3(225.78,50.88) v3(226.54,50.85) v3(230.14,69.65) v3(230.22,61.04) v3(230.27,57.48) v3(230.47,67.77) v3(230.58,71.2) v3(231.54,69.22) v3(231.49,59.9) v3(231.72,117.05) v3(231.74,57.48) v3(231.9,68.13) v3(232.51,67.52) v3(232.51,66.75) v3(232.51,63.33) v3(232.51,61.04) v3(232.51,59.9) v3(232.51,58.63) v3(232.51,57.48) v3(232.63,64.47) v3(232.66,71.15) v3(232.89,120.48) v3(233.14,65.61) v3(233.14,63.33) v3(233.4,64.47) v3(233.4,59.9) v3(233.4,58.63) v3(233.47,128.29) v3(233.65,57.48) v3(233.65,56.59) v3(233.78,61.04) v3(234.06,130.97) v3(234.54,64.09) v3(234.54,61.04) v3(234.54,60.28) v3(234.54,59.52) v3(234.67,58.63) v3(234.67,57.48) v3(234.92,120.48) v3(235.3,64.09) v3(235.3,60.28) v3(235.3,59.52) v3(236.06,61.04) v3(236.06,60.28) v3(236.06,59.52) v3(236.16,67.69) v3(236.95,57.48) v3(237.04,142.57) v3(237.01,140.39) v3(237.02,138.33) v3(237.02,136.21) v3(237.02,132.04) v3(237.01,129.85) v3(237.02,125.65) v3(237.02,121.45) v3(237.28,69.14) v3(237.54,140.57) v3(237.57,138.25) v3(237.57,136.15) v3(237.57,134.05) v3(237.57,131.95) v3(237.57,129.75) v3(237.57,127.75) v3(237.58,125.65) v3(237.59,64.85) v3(237.59,60.28) v3(237.69,142.17) v3(238.35,64.09) v3(238.35,63.33) v3(238.35,61.04) v3(238.35,60.28) v3(238.35,59.52) v3(238.43,152.97) v3(238.41,142.27) v3(238.4,66.63) v3(238.36,64.81) v3(238.48,67.77) v3(238.48,58.12) v3(238.48,56.87) v3(238.99,142.27) v3(239.11,64.09) v3(239.11,63.33) v3(239.11,62.56) v3(239.11,61.04) v3(239.11,60.28) v3(239.49,58.12) v3(239.69,140.77) v3(239.85,59.49) v3(239.87,64.85) v3(239.87,60.28) v3(239.99,177.24) v3(239.99,151.72) v3(240.39,140.87) v3(240.49,140.17) v3(240.88,177.15) v3(240.89,58.75) v3(241.02,66.75) v3(240.98,59.89) v3(241.29,74.22) v3(241.35,65.61) v3(241.27,63.33) v3(241.62,59.87) v3(241.68,151.65) v3(241.7,74.78) v3(241.77,151.1) v3(241.79,138.77) v3(241.78,67.77) v3(242.14,117.42) v3(242.71,65.52) v3(242.71,64.34) v3(242.68,63.33) v3(242.89,138.37) v3(242.97,74.78) v3(243.05,68.79) v3(243.05,67.77) v3(243.43,63.33) v3(243.43,58.5) v3(244.06,66.75) v3(244.14,57.73) v3(244.17,67.66) v3(244.19,63.33) v3(244.47,96.72) v3(244.59,145.07) v3(244.6,70.95) v3(244.69,144.37) v3(244.83,57.74) v3(244.83,55.83) v3(245.08,63.33) v3(245.29,139.42) v3(245.29,135.92) v3(245.29,134.52) v3(245.29,133.12) v3(245.29,132.42) v3(245.29,131.02) v3(245.29,129.62) v3(245.29,128.92) v3(245.29,127.52) v3(245.29,126.12) v3(245.29,124.72) v3(245.29,123.32) v3(245.36,70.49) v3(245.47,55.7) v3(245.59,56.47) v3(245.82,69.42) v3(246.08,117.07) v3(246.35,66.75) v3(246.48,64.47) v3(246.63,69.55) v3(246.69,139.42) v3(246.69,137.32) v3(246.69,133.12) v3(246.69,129.62) v3(246.69,128.92) v3(246.69,127.52) v3(246.69,126.12) v3(246.69,124.72) v3(246.69,123.32) v3(246.69,122.62) v3(246.87,86.32) v3(247.03,67.8) v3(247.05,65.64) v3(247.34,73.46) v3(247.79,150.61) v3(248.09,137.32) v3(248.09,132.42) v3(248.09,129.62) v3(248.09,128.92) v3(248.09,127.52) v3(248.09,126.12) v3(248.09,124.72) v3(248.09,123.32) v3(248.09,122.62) v3(248.51,53.17) v3(248.51,52.15) v3(248.79,119.03) v3(249.02,73.74) v3(249.49,139.42) v3(249.49,138.72) v3(249.49,135.92) v3(249.49,134.52) v3(249.49,129.62) v3(249.49,128.92) v3(249.49,127.52) v3(249.49,126.12) v3(249.49,124.72) v3(249.49,123.32) v3(249.49,122.62) v3(250.32,115.75) v3(250.51,111.48) v3(250.72,87.52) v3(250.89,139.42) v3(250.89,138.72) v3(250.89,135.92) v3(250.89,132.42) v3(250.89,131.02) v3(250.89,129.62) v3(250.89,128.92) v3(250.89,127.52) v3(250.89,126.12) v3(250.89,124.72) v3(250.89,123.32) v3(250.89,122.62) v3(250.87,85.52) v3(251.3,110.29) v3(251.3,109.12) v3(251.67,87.93) v3(251.67,87.12) v3(251.67,86.32) v3(252.24,137.32) v3(252.29,139.42) v3(252.31,138.72) v3(252.29,135.92) v3(252.29,134.52) v3(252.29,133.12) v3(252.29,132.42) v3(252.29,129.62) v3(252.29,128.92) v3(252.29,127.52) v3(252.29,126.12) v3(252.29,124.72) v3(252.44,116.32) v3(252.47,86.32) v3(252.47,85.52) v3(252.99,116.37) v3(253.09,124.72) v3(253.09,123.32) v3(253.09,122.62) v3(253.27,87.12) v3(253.54,108.31) v3(253.69,128.97) v3(254.11,173.95) v3(254.09,110.96) v3(254.09,109.8) v3(254.39,126.82) v3(255.19,139.42) v3(255.19,138.72) v3(255.19,137.32) v3(255.19,135.92) v3(255.19,134.52) v3(255.19,133.12) v3(255.19,132.42) v3(255.19,131.02) v3(255.19,128.92) v3(255.19,127.52) v3(255.19,126.12) v3(255.24,124.72) v3(255.19,123.32) v3(255.19,122.62) v3(256.62,144.32) v3(256.59,139.42) v3(256.59,138.72) v3(256.59,137.32) v3(256.59,135.92) v3(256.59,134.52) v3(256.59,133.12) v3(256.59,132.42) v3(256.59,131.02) v3(256.59,129.62) v3(256.59,128.92) v3(256.59,127.52) v3(256.59,123.32) v3(256.59,122.62) v3(256.69,146.21) v3(257.2,145.71) v3(257.99,137.32) v3(257.99,135.92) v3(257.99,134.52) v3(257.99,133.12) v3(257.99,132.42) v3(257.99,131.02) v3(257.99,129.62) v3(257.99,128.92) v3(257.99,127.52) v3(257.99,123.32) v3(257.99,122.62) v3(259.39,137.32) v3(259.39,135.92) v3(259.39,134.52) v3(259.39,133.12) v3(259.39,132.42) v3(259.39,131.02) v3(259.39,129.62) v3(259.39,128.92) v3(259.39,124.72) v3(259.39,123.32) v3(259.39,122.62) v3(259.56,150.19) v3(259.68,178.9) v3(259.71,174.75) v3(259.82,154.15) v3(259.8,152.18) v3(260.51,174.75) v3(260.79,139.42) v3(260.79,138.72) v3(260.79,137.32) v3(260.79,135.92) v3(260.79,134.52) v3(260.79,133.12) v3(260.79,132.42) v3(260.79,131.02) v3(260.79,129.62) v3(260.79,128.92) v3(260.79,124.72) v3(260.79,123.32) v3(260.79,122.62) v3(261.31,173.95) v3(261.79,154.2) v3(261.79,152.37) v3(262.11,174.75) v3(262.19,139.42) v3(262.19,138.72) v3(262.19,137.32) v3(262.19,135.92) v3(262.19,134.52) v3(262.19,133.12) v3(262.19,132.42) v3(262.19,131.02) v3(262.19,129.62) v3(262.19,128.92) v3(262.19,124.72) v3(262.19,123.32) v3(262.19,122.62) v3(263.87,150.57) v3(265.99,110.85) v3(267.55,151.51) v3(267.93,174.75) v3(268.44,144.34) v3(269.1,111.83) v3(269.1,110.08) v3(269.87,84.71) v3(271.93,173.95) v3(271.93,173.15) v3(272.62,135.72) v3(272.84,118.84) v3(273.03,84.72) v3(273.22,132.77) v3(273.42,135.72) v3(273.56,117) v3(273.83,130.71) v3(273.78,115.01) v3(273.88,134.87) v3(274.58,135.72) v3(274.97,132.77) v3(275.64,134.87) v3(277.39,134.87) v3(278.33,173.95) v3(278.33,169.95) v3(278.33,167.55) v3(278.33,165.95) v3(279.13,177.95) v3(296.1,153.74) v3(297.03,135.92) v3(298.62,121.08) v3(299.49,108.11) v3(300.58,134.7) v3(301.34,158.96) v3(301.59,136.5) v3(301.85,110.7) v3(302.74,152.86) v3(302.74,144.86) v3(302.74,144.22) v3(302.99,154) v3(303.25,121.11) v3(303.75,148.16) v3(303.75,147.53) v3(303.75,130.13) v3(303.75,129.49) v3(310.61,147.27) v3(310.61,146) v3(310.61,128.22) v3(310.61,126.95) v3(311.12,110.57) v3(311.12,109.55)
