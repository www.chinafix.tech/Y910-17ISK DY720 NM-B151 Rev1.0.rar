# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQS_DP4: length 88.2
  TOP w0.102: JDIMM4.179 177.6,67.35 178.38,68.13 179.94,68.13 180.39,68.57 180.39,70.26 180.14,70.51 179.92,70.51 v1(179.74,70.69)
  IN10 w0.076: 178.2,125.79 178.19,125.8 178.08,125.8 178.03,125.85 175.71,128.17 175.71,134.66 175.48,134.89 175.48,136.33 175.55,136.4 175.81,136.4 v1(175.86,136.35)
  IN10 w0.145: 178.2,125.79 178.45,125.54 178.45,124.53 179.92,123.06 179.92,119.38 181.29,118 181.65,118 181.95,117.7 181.95,116.92 181.65,116.62 181.37,116.62 181.24,116.5 181.24,115.92 181.37,115.79 181.73,115.79 182.03,115.49 182.03,114.63 181.73,114.33 181.37,114.33 181.24,114.2 181.24,113.63 181.37,113.5 181.61,113.5 181.92,113.2 181.92,111.92 182.04,111.79 182.32,111.79 182.62,111.49 182.62,88.5 182.21,88.09 182.21,80.72 179.31,77.82 179.31,72.22 179.24,72.15 179.24,70.59 179.36,70.47 179.61,70.47 179.74,70.59 v1(179.74,70.69)
  BOTTOM w0.102: v1(179.74,70.69) 179.74,70.57 179.61,70.44 179.14,70.44 179.06,70.52 179.06,71.08 179.33,71.35 179.33,72.27 179.09,72.52 178.14,72.52 178.01,72.65 178.01,72.85 178.14,72.98 178.79,72.98 179,73.2 179,73.3 179.04,73.34 179.24,73.34 179.29,73.39 179.29,74.37 JDIMM3.179
  BOTTOM w0.14: U1.AA9 v1(175.86,136.35)
M_B_DQS_DP5: length 89.9
  TOP w0.102: JDIMM4.200 182.85,74.37 182.85,73.41 182.79,73.35 182.61,73.35 182.55,73.3 182.55,73.12 182.68,73 183.05,73 183.19,73.14 183.54,73.14 183.85,72.83 183.85,72.14 184.05,71.94 184.25,71.94 184.47,71.71 184.47,70.44 184.6,70.32 184.82,70.32 184.94,70.44 v1(184.94,70.56)
  IN10 w0.076: v1(178.6,136.35) 178.57,136.38 178.3,136.38 178.22,136.3 178.22,129.59 182.56,125.25 182.78,125.25 183.02,125 183.17,125 183.18,125
  IN10 w0.145: 183.18,125 184.13,124.05 184.13,121.62 187.59,118.16 187.59,115.98 187.71,115.85 187.77,115.85 188.07,115.55 188.07,114.74 187.77,114.44 187.71,114.44 187.59,114.31 187.59,113.71 187.71,113.58 188.05,113.58 188.35,113.28 188.35,112.44 188.03,112.12 187.71,112.12 187.59,112 187.59,111.38 187.71,111.25 188.05,111.25 188.35,110.95 188.35,110.09 188.05,109.79 187.71,109.79 187.59,109.66 187.59,109.05 187.71,108.92 188.03,108.92 188.35,108.6 188.35,93.25 188.06,92.95 188.06,87.7 187.28,86.92 187.28,86.36 187.93,85.72 187.93,80.34 185.69,78.11 185.69,76 185.34,75.65 185.34,72.72 184.88,72.26 184.57,72.26 184.44,72.14 184.44,70.47 184.57,70.34 184.82,70.34 184.94,70.47 v1(184.94,70.56)
  BOTTOM w0.102: v1(184.94,70.56) 185.13,70.38 185.9,70.38 186.1,70.18 186.1,68.61 185.49,68 184.64,68 184.55,67.91 JDIMM3.200
  BOTTOM w0.14: U1.V9 v1(178.6,136.35)
M_B_DQS_DP6: length 92.5
  TOP w0.102: JDIMM4.221 188.1,66.97 188.7,67.57 189.07,67.57 189.68,68.18 190.49,68.18 191.26,68.94 191.26,70.23 190.98,70.51 190.33,70.51 v1(190.15,70.69)
  IN10 w0.076: 186.36,126.91 186.35,126.9 186.35,126.92 186.34,126.92 186.31,126.89 186.18,126.89 186.16,126.9 184.46,126.9 180.97,130.4 180.97,136.13 181.19,136.35 v1(181.34,136.35)
  IN10 w0.145: 186.36,126.91 187.12,126.15 188.07,125.2 188.07,123.61 193.54,118.14 193.54,93.98 194.43,93.09 194.43,92.05 194.11,91.74 194.01,91.74 193.85,91.58 193.85,91.03 194.01,90.87 194.11,90.87 194.43,90.55 194.43,87.18 193.85,86.6 193.85,86.26 194.43,85.67 194.43,79.6 194.01,79.18 192.83,79.18 192.63,78.97 192.63,75.9 189.65,72.92 189.65,70.59 189.78,70.47 190.02,70.47 190.15,70.59 v1(190.15,70.69)
  BOTTOM w0.102: JDIMM3.221 189.8,73.41 189.75,73.36 189.56,73.36 189.5,73.3 189.5,73.16 189.58,73.08 189.67,73.08 189.87,72.88 189.87,72.59 189.67,72.39 189.03,72.39 188.91,72.27 188.91,72.04 189.03,71.91 189.5,71.91 189.75,71.67 189.75,71.14 189.5,70.89 189.23,70.89 189.1,70.77 189.1,70.57 189.23,70.44 190.02,70.44 190.15,70.57 v1(190.15,70.69)
  BOTTOM w0.14: U1.P9 v1(181.34,136.35)
M_B_DQS_DP7: length 99.5
  TOP w0.102: JDIMM4.242 193.35,73.4 193.3,73.35 193.11,73.35 193.05,73.3 193.05,73.03 193.44,72.65 194.41,72.65 194.86,72.2 194.86,70.26 195.06,70.06 195.23,70.06 195.36,70.19 v1(195.36,70.31)
  IN10 w0.076: v1(184.06,136.35) 183.74,136.35 183.65,136.26 183.65,134.89 183.85,134.69 184.03,134.69 185,133.71 185,133.31 185.12,133.19 185.13,133.19 185.14,133.18
  IN10 w0.145: 185.14,133.18 185.14,131.34 186.38,130.09 188.47,130.09 194.01,124.55 200.05,124.55 202.14,122.46 202.14,117.12 201.69,116.67 201.69,110.44 202.14,109.99 202.14,98.38 202.79,97.73 202.79,90 203.5,89.29 203.5,86.08 203.22,85.8 203.22,77.47 199.53,73.79 196.36,73.79 194.85,72.28 194.85,70.21 194.98,70.08 195.23,70.08 195.36,70.21 v1(195.36,70.31)
  BOTTOM w0.102: v1(195.36,70.31) 195.51,70.16 196.33,70.16 196.58,69.91 196.58,69.46 196.33,69.21 196.12,69.21 195.97,69.06 195.97,68.9 196.39,68.48 196.39,67.99 196.04,67.64 195.72,67.64 195.05,66.97 JDIMM3.242
  BOTTOM w0.14: U1.L9 v1(184.06,136.35)
MAINON: length 748.2
  TOP w0.089: R299.2 37.23,50.36 v2(36.71,50.88)
  TOP w0.097: v1(108.17,65.61) 107.87,65.92 PR1405.1 ; PR1306.2 v1(23.59,19.38) ; v1(70.84,42.24) 71.6,41.48 74.65,41.48 v2(74.9,41.74) 76.09,42.93 PR623.1 ; v1(277.34,39.7) 276.75,40.29 PR610.1 ; v1(204.44,151.95) 204.67,151.72 205.71,151.72 206.5,152.51 PR1253.2 ; v1(191.74,130.08) 191.74,129.09 191.64,128.98 PR1258.2
  IN03 w0.089: 30.7,49.61 30.07,48.97
  IN03 w0.091: v1(72.87,60.02) 73.36,60.52 86.06,60.52 90.87,65.32 99.12,65.32 99.55,65.76 101.08,65.76 101.73,65.1 107.67,65.1 v1(108.17,65.61) ; v1(58.14,43.26) 56.61,41.74 48.74,41.74 48.26,41.26 40.7,41.26 39.47,42.5 v1(38.07,42.5) ; v2(36.71,50.88) 35.7,49.86 30.96,49.86 30.7,49.61 ; v1(23.59,19.38) 23.59,20.65 27.02,24.08 27.02,25.23 27.78,25.99 27.78,40.62 25.62,42.78 25.62,43.13 25.88,43.39 26.13,43.39 27.91,45.16 27.91,47.58 28.44,48.11 28.82,48.11 29.69,48.97 30.07,48.97
  IN05 w0.091: v1(58.14,43.26) 68.55,43.26 69.57,42.24 v1(70.84,42.24)
  IN08 w0.089: 39.47,46.69 39.47,49.36 38.45,50.37 37.22,50.37 v2(36.71,50.88)
  IN08 w0.091: v1(277.34,39.7) 276.96,39.32 267.43,39.32 263.71,43.05 260.32,43.05 256.63,39.35 214.98,39.35 211.58,42.75 203.73,42.75 201.01,40.03 182.9,40.03 180.74,42.2 170.07,42.2 167.66,44.61 122.22,44.61 117.57,39.96 v1(116.68,39.96) ; v1(70.84,42.24) 71.09,42.5 71.09,51.51 69.95,52.66 69.95,58.63 71.34,60.02 v1(72.87,60.02) ; v1(197.07,130.76) 197.07,130.93 198.6,132.45 198.6,145.75 204.44,151.59 v1(204.44,151.95) 204.44,155.37 201.31,158.5 201.31,165.9 200.12,167.08 200.12,174.96 198.51,176.57 198.51,182.87 199.73,184.09 199.73,190.04 196.31,193.46 196.31,193.88 195.93,194.26 192.63,194.26 192.02,194.87 190.19,194.87 189.42,194.11 186.31,194.11 v1(185.64,194.77) ; 39.47,46.69 39.47,45.04 38.5,44.07 38.5,42.93 v1(38.07,42.5) ; v1(108.17,65.61) 108.55,65.23 115.16,65.23 120.62,59.77 124.25,59.77 126.03,57.99 154.88,57.99 155.39,58.5 166.69,58.5 167.61,59.42 167.61,61.42 166.21,62.82 166.21,63.73 165.13,64.81 165.13,66.44 163.82,67.75 163.82,102.71 191.18,130.08 v1(191.74,130.08)
  IN10 w0.091: v1(185.64,194.77) 185.26,194.39 175.48,194.39 174.04,195.84 170.71,195.84 170,196.55 165.73,196.55 165.22,196.04 164.05,196.04 163.29,195.28 157.34,195.28 156.33,194.26 154.68,194.26 152.37,191.96 152.37,181.18 150.08,178.9 150.08,174.7 147.42,172.04 135.61,172.04 134.53,170.97 134.53,151.14 134.72,150.96 136.57,150.96 137.13,151.51 v1(137.89,151.51) 138.22,151.51 138.4,151.34 138.4,150.7 138.07,150.37 137.43,150.37 137.13,150.07 135.1,150.07 134.34,149.3 134.34,140.67 133.19,139.53 119.35,139.53 117.44,137.62 117.44,130.64 117.95,130.13 121.71,130.13 v1(122.21,130.63) ; v1(116.68,39.96) 117.06,40.34 117.06,42.37 116.3,43.13 116.3,48.19 120.14,52.02 120.14,54.28 119.35,55.07 119.35,56.09 115.54,59.9 115.54,61.67 114.78,62.44 112.24,62.44 111.73,62.94 111.73,64.18 110.3,65.61 v1(108.17,65.61)
  BOTTOM w0.089: v2(36.71,50.88) 36.71,50.96 36.28,51.4 U5.D9
  BOTTOM w0.097: PR1302.2 58.95,43.82 58.39,43.26 v1(58.14,43.26) ; v1(197.07,130.76) 197.07,131.48 196.78,131.78 194.66,131.78 193.77,130.89 193.14,130.89 192.32,130.08 v1(191.74,130.08) ; v1(137.89,151.51) 137.13,151.51 R520.1
  BOTTOM w0.356: v1(122.21,130.63) 122.59,130.25 PR3465.1
MAINON_N: length 5.9
  TOP w0.097: v2(110.97,70.56) PQ1403.2 PQ1403.5 110.97,68.02 111.22,67.77 PR1401.1 110.02,67.47 PQ1401.6 109.56,67.38 109.44,67.26 109.44,67.01 109.57,66.88 PQ1401.5
MBAT_PRES_N: length 178.9
  TOP w0.097: v1(83.92,4.02) 83.71,3.81 PR208.1
  IN03 w0.091: v1(35.78,4.52) 35.78,4.14 36.42,3.51 40.99,3.51 41.63,4.14 50.9,4.14 52.55,5.79 59.28,5.79 61.18,3.89 66.64,3.89 67.41,4.65 71.09,4.65 72.61,3.13 79.22,3.13 80.11,4.02 81.76,4.02 82.27,3.51 83.41,3.51 v1(83.92,4.02)
  IN05 w0.091: v2(40.99,52.78) 41.36,53.16 45.07,53.16 49.25,48.97 52.17,48.97 54.2,46.94 54.2,45.55 56.36,43.39 56.36,41.1 57.75,39.7 57.75,39.07 59.79,37.04 86.08,37.04 v1(88.62,39.58)
  IN08 w0.091: v1(83.92,4.02) 83.92,5.67 83.28,6.3 83.28,14.56 79.47,18.37 79.47,25.48 79.6,25.61 84.68,25.61 87.35,28.27 87.35,32.97 88.62,34.24 v1(88.62,39.58)
  BOTTOM w0.097: v1(35.78,4.52) 35.78,5.03 36.5,5.75 JDBUG1.4 ; v2(40.99,52.78) 40.25,52.78 39.87,52.4 39.59,52.4 39.09,52.91 U5.G13 ; v1(83.92,4.02) 84.81,4.91 89.76,4.91 92.68,7.83 92.68,9.42 94.31,11.05 PR103.2 PR104.1
MBAT_PRES_N_R: length 3
  BOTTOM w0.097: JBAT1.7 96.63,13.55 v2(95.98,12.91) 95.98,12.02 PR104.2
MCT1_TL: length 8.4
  TOP w0.508: v1(20.8,93.48) 21.63,93.48 ; v1(20.8,102.48) 21.6,102.48 ; v1(20.8,99.48) 21.6,99.48 ; v1(20.8,96.48) 21.55,96.48
  BOTTOM w0.457: TL1.21 v1(20.8,99.48) ; TL1.18 v1(20.8,96.48) ; TL1.24 v1(20.8,102.48) ; TL1.15 v1(20.8,93.48)
  vias: v2(21.31,109.93)
MDA0: length 18.6
  IN10 w0.14: v3(259.8,150.96) 260.32,151.49 260.32,156.75 260.96,157.39 260.96,162.83 259.75,164.03 259.75,164.31 v3(259.71,164.35)
  BOTTOM w0.102: 260.57,150.7 260.7,150.58 260.7,148.72 260.39,148.41 G2.U51
  BOTTOM w0.152: v3(259.8,150.96) 260.32,150.96 260.57,150.7 ; U48.U4 v3(259.71,164.35)
MDA1: length 19.9
  IN10 w0.14: v3(261.31,164.35) 261.31,164.35 261.31,164.06 262.07,163.29 262.07,156.92 261.38,156.23 261.38,149.54 260.79,148.94 v3(260.79,147.17)
  BOTTOM w0.152: v3(260.79,147.17) 260.74,147.12 260.74,146.65 260.39,146.3 G2.U48 ; v3(261.31,164.35) U48.U2
MDA2: length 20.9
  IN10 w0.14: v3(259.71,165.15) 259.19,164.63 259.19,163.8 260.4,162.59 260.4,157.62 259.54,156.76 259.54,154.66 258.95,154.07 258.95,152.42 v3(259.8,151.57)
  BOTTOM w0.102: G2.U50 260.39,147.68 260.74,148.03 260.74,148.35 260.92,148.54 260.92,150.99 260.83,151.08
  BOTTOM w0.152: v3(259.71,165.15) 259.31,165.55 U48.T4 ; 260.83,151.08 260.34,151.57 v3(259.8,151.57)
MDA3: length 23.8
  IN10 w0.14: v3(260.51,165.15) 260.11,165.55 258.69,165.55 258.48,165.34 258.48,164.2 258.63,164.04 258.63,163.57 259.84,162.36 259.84,157.85 258.91,156.92 258.91,154.65 258.57,154.31 258.57,150.59 259.39,149.76 259.98,149.76 v3(260.04,149.82)
  BOTTOM w0.102: G2.U49 260.05,147.1 260.05,149.03 260.13,149.1 260.13,149.73 v3(260.04,149.82)
  BOTTOM w0.152: U48.T2 v3(260.51,165.15)
MDA4: length 25.4
  IN10 w0.14: v3(259.71,168.35) 260.11,168.75 262.35,168.75 263.19,167.91 263.19,156.39 262.63,155.83 262.63,153.44 262.19,153.01 v3(261.79,153.01)
  BOTTOM w0.102: G2.R51 261.79,148.33 261.39,148.73 261.39,152.62 v3(261.79,153.01)
  BOTTOM w0.152: U48.N4 v3(259.71,168.35)
MDA5: length 22.8
  IN10 w0.14: v3(261.31,167.55) 261.71,167.15 262.32,167.15 262.63,166.84 262.63,156.68 262,156.05 262,154.74 262.25,154.48 262.25,153.88 262.01,153.64 v3(261.79,153.64)
  BOTTOM w0.102: G2.R50 261.79,147.69 261.44,148.04 261.44,148.28 261.16,148.56 261.16,153.01 261.33,153.19
  BOTTOM w0.152: v3(261.79,153.64) 261.33,153.19 ; v3(261.31,167.55) U48.N2
MDA6: length 30.6
  IN10 w0.14: v3(261.49,145.07) 261.9,145.48 261.9,148.73 262.21,149.04 262.21,152.03 263.03,152.85 263.03,155.39 263.75,156.1 263.75,169.2 263.2,169.75 260.31,169.75 v3(259.71,169.15)
  BOTTOM w0.152: U48.M4 v3(259.71,169.15) ; G2.R47 v3(261.49,145.07)
MDA7: length 25.5
  IN10 w0.14: v3(261.31,168.35) 260.91,167.95 260.91,163.66 261.52,163.06 261.52,157.16 260.88,156.52 260.88,149.63 260.25,149 260.25,145.4 v3(260.69,144.97)
  BOTTOM w0.152: G2.U46 260.39,144.67 v3(260.69,144.97) ; U48.M2 v3(261.31,168.35)
MDA8: length 26.1
  IN03 w0.14: v3(259.38,144.38) 258.98,143.98 258.36,143.98 258.07,144.27 258.07,147.91 257.29,148.69 257.03,148.95 257.03,155.8 257.29,156.06 257.29,157.98 258.25,158.94 258.25,160.21 254.47,164 253.66,164 v3(253.31,164.35)
  BOTTOM w0.152: G2.V46 259.66,144.67 v3(259.38,144.38) ; v3(253.31,164.35) U48.U11
MDA9: length 25.7
  IN03 w0.14: v3(251.71,164.35) 251.93,164.35 252.43,163.85 253.02,163.85 256.73,160.13 256.73,156.24 256.54,156.06 256.54,148.83 257.73,147.64 257.73,144.04 258.21,143.56 v3(258.69,143.56)
  BOTTOM w0.152: v3(251.71,164.35) U48.U13 ; v3(258.69,143.56) G2.Y45
MDA10: length 24.2
  IN03 w0.14: v3(258.69,145.77) 258.33,146.13 258.33,148.4 257.58,149.15 257.58,155.42 257.85,155.69 257.85,157.65 258.82,158.62 258.82,160.43 254.67,164.58 253.87,164.58 v3(253.31,165.15)
  BOTTOM w0.152: v3(258.69,145.77) G2.Y47 ; U48.T11 253.71,165.55 v3(253.31,165.15)
MDA11: length 28.6
  IN03 w0.076: 259.53,145.36 259.01,145.36 v3(258.65,144.99)
  IN03 w0.14: 259.53,145.36 259.8,145.62 259.8,147.67 258.08,149.4 258.08,155.01 258.41,155.34 258.41,157.38 259.39,158.36 259.39,160.66 254.5,165.55 252.11,165.55 v3(251.71,165.15)
  BOTTOM w0.152: G2.Y46 258.32,144.67 v3(258.65,144.99) ; v3(251.71,165.15) 252.11,165.55 U48.T13
MDA12: length 26.3
  IN03 w0.14: v3(259.8,153.4) 259.68,153.28 259.23,153.28 258.92,153.58 258.92,154.14 259.46,154.68 259.46,156.64 260.51,157.68 260.51,161.12 254.48,167.15 253.71,167.15 v3(253.31,167.55)
  BOTTOM w0.102: 259.29,152.9 259.08,152.68 259.08,150.68 258.91,150.51 258.91,149.53 259.07,149.37 259.07,148.63 259.34,148.37 259.34,148.04 259.69,147.69 G2.V50
  BOTTOM w0.152: U48.N11 v3(253.31,167.55) ; v3(259.8,153.4) 259.29,152.9
MDA13: length 29.7
  IN03 w0.14: v3(252.51,167.55) 252.91,167.15 252.91,166.55 253.11,166.35 254.49,166.35 259.95,160.89 259.95,157.95 258.96,156.96 258.96,154.97 258.51,154.52 258.51,152.21 259.06,151.66 259.06,149.29 260.25,148.09 260.25,145.38 259.82,144.94 v3(259.28,144.94)
  BOTTOM w0.152: G2.V47 259.28,144.96 v3(259.28,144.94) ; v3(252.51,167.55) U48.N13
MDA14: length 25.6
  IN03 w0.14: v3(253.31,168.35) 253.71,168.75 254.46,168.75 261.68,161.53 261.68,157.24 260.91,156.48 260.91,155.63 260.48,155.21 260.48,152.18 260.24,151.93 260.24,150.66 260.05,150.47 v3(260.05,150.47)
  BOTTOM w0.102: G2.U52 260.43,148.91 260.43,150.09 v3(260.05,150.47)
  BOTTOM w0.152: v3(253.31,168.35) U48.M11
MDA15: length 27
  IN03 w0.14: v3(251.71,168.35) 252.11,167.95 254.47,167.95 261.08,161.34 261.08,157.45 260.22,156.59 260.22,153.22 v3(259.8,152.79)
  BOTTOM w0.102: 259.51,152.5 259.36,152.35 259.36,150.56 259.16,150.37 259.16,149.66 259.29,149.53 259.29,148.76 259.69,148.37 G2.V51
  BOTTOM w0.152: v3(251.71,168.35) U48.M13 ; v3(259.8,152.79) 259.51,152.5
MDA16: length 45.3
  IN03 w0.076: 252.11,146.91 251.88,146.68 251.88,143.42 v3(252.34,142.97)
  IN03 w0.14: v3(253.31,177.95) 253.31,178.55 252.35,179.51 250.78,179.51 246.79,175.52 246.79,163.1 252.11,157.77 252.11,146.91
  BOTTOM w0.152: v3(252.34,142.97) 252.04,143.27 G2.AJ44 ; U48.A11 v3(253.31,177.95)
MDA17: length 36.6
  IN03 w0.14: v3(251.71,177.95) 251.31,177.55 251.31,176.98 251.08,176.75 250.55,176.75 250.29,176.48 250.29,175.34 248.46,173.52 248.46,163.79 253.83,158.43 253.83,149.57 v3(253.63,149.37)
  BOTTOM w0.152: U48.A13 v3(251.71,177.95) ; G2.AG48 253.73,146.41 253.73,149.27 v3(253.63,149.37)
MDA18: length 46.6
  IN03 w0.076: 253.36,143.27 252.69,143.27 v3(252.29,143.67)
  IN03 w0.14: v3(254.11,177.15) 253.71,177.55 252.9,177.55 252.69,177.76 252.69,178.36 252.11,178.94 251.04,178.94 247.34,175.25 247.34,163.33 252.68,158 252.68,149.79 252.36,149.47 252.36,147.22 253.59,145.98 253.59,143.5 253.36,143.27
  BOTTOM w0.152: v3(252.29,143.67) G2.AJ45 ; v3(254.11,177.15) U48.B11
MDA19: length 38.1
  IN03 w0.14: v3(252.51,177.15) 252.13,177.53 252.13,178.13 251.89,178.37 251.31,178.37 249.65,176.71 249.65,175.59 247.9,173.85 247.9,163.56 253.27,158.19 253.27,149.66 253.19,149.57 253.19,147.17 v3(253.09,147.07)
  BOTTOM w0.152: v3(252.51,177.15) U48.B13 ; G2.AG49 v3(253.09,147.07)
MDA20: length 35.6
  IN03 w0.14: v3(255.09,144.37) 255.97,145.25 255.97,156.64 256.07,156.73 256.07,159.35 251.31,164.11 251.31,168.18 251.31,171 253.71,173.4 U48.E11 v3(253.31,174.75)
  BOTTOM w0.102: G2.AF46 254.09,144.67 254.79,144.67 v3(255.09,144.37)
  BOTTOM w0.152: v3(253.31,174.75) 253.71,174.35 U48.E11
MDA21: length 35.2
  IN03 w0.14: v3(254.38,145.07) 253.99,145.47 253.99,146.3 253.74,146.56 253.74,148.06 254.39,148.71 254.39,158.66 249.02,164.03 249.02,173.19 250.18,174.35 251.31,174.35 v3(251.71,173.95)
  BOTTOM w0.152: v3(251.71,173.95) U48.E13 ; G2.AF47 v3(254.38,145.07)
MDA22: length 34.1
  IN03 w0.14: v3(254.46,146.26) 254.46,147.99 254.95,148.48 254.95,158.89 249.59,164.25 249.59,172.7 250.44,173.55 252.91,173.55 v3(253.31,173.95)
  BOTTOM w0.152: U48.F11 v3(253.31,173.95) ; v3(254.46,146.26) G2.AF48
MDA23: length 31.9
  IN03 w0.14: v3(251.71,173.15) 251.71,172.24 250.51,171.04 250.51,164.12 255.51,159.12 255.51,147.88 255.61,147.78 255.61,145.49 v3(255.19,145.07)
  BOTTOM w0.152: v3(255.19,145.07) G2.AD47 ; v3(251.71,173.15) 252.11,173.55 U48.F13
MDA24: length 34.5
  IN10 w0.14: v3(255.19,147.07) 255.35,147.23 255.35,147.96 254.6,148.71 254.6,171.57 255.49,172.46 255.49,175.31 258.13,177.95 v3(258.91,177.95)
  BOTTOM w0.152: v3(255.19,147.07) G2.AD49 ; U48.A4 v3(258.91,177.95)
MDA25: length 38.4
  IN10 w0.14: v3(260.51,177.95) 260.06,178.4 257.61,178.4 254.56,175.35 254.56,172.95 253.71,172.1 253.71,164.63 254.04,164.3 254.04,148.33 254.45,147.93 254.45,146.92 v3(255.11,146.26)
  BOTTOM w0.152: G2.AD48 v3(255.11,146.26) ; v3(260.51,177.95) U48.A2
MDA26: length 35.6
  IN10 w0.14: v3(258.91,177.15) 258.51,176.75 257.9,176.75 256.09,174.94 256.09,171.48 255.22,170.6 255.22,148.77 255.73,148.26 255.73,145.72 v3(256.48,144.97)
  BOTTOM w0.152: U48.B4 v3(258.91,177.15) ; v3(256.48,144.97) 256.19,144.67 G2.AC46
MDA27: length 35.6
  IN10 w0.14: v3(260.51,177.15) 260.11,176.75 260.11,176.12 259.94,175.95 259.08,175.95 259.08,175.95 258.45,175.95 256.65,174.15 256.65,171.25 255.77,170.37 255.77,148.98 256.08,148.68 256.08,146.07 v3(256.48,145.67)
  BOTTOM w0.152: v3(256.48,145.67) 256.19,145.37 G2.AC47 ; U48.B2 v3(260.51,177.15)
MDA28: length 34
  IN10 w0.14: v3(257.29,145.07) 257.66,145.44 257.66,147.79 256.42,149.03 256.42,158.8 256.88,159.26 256.88,160.19 256.4,160.68 256.4,170.1 257.16,170.86 257.16,173.74 257.76,174.35 259.31,174.35 v3(259.71,173.95)
  BOTTOM w0.152: G2.AA47 v3(257.29,145.07) ; v3(259.71,173.95) U48.E4
MDA29: length 34.9
  IN10 w0.14: v3(260.51,173.95) 260.11,173.55 257.86,173.55 257.69,173.38 257.69,170.61 256.96,169.88 256.96,161.28 258,160.23 258,159.3 256.98,158.28 256.98,149.35 257.95,148.38 257.95,145.03 v3(257.29,144.37)
  BOTTOM w0.152: G2.AA46 v3(257.29,144.37) ; U48.E2 v3(260.51,173.95)
MDA30: length 32.6
  IN10 w0.14: v3(258.91,173.15) 258.45,172.69 258.45,170.57 257.52,169.64 257.52,161.51 258.56,160.47 258.56,159.07 257.54,158.04 257.54,149.68 258.23,148.98 258.23,144.61 v3(257.29,143.67)
  BOTTOM w0.152: G2.AA45 v3(257.29,143.67) ; v3(258.91,173.15) 259.31,173.55 U48.F4
MDA31: length 35
  IN10 w0.076: 259.51,143.27 259.05,143.27 258.75,142.97 v3(258.59,142.97)
  IN10 w0.14: 259.51,143.27 259.8,143.56 259.8,148.62 258.09,150.33 258.09,157.81 259.12,158.84 259.12,160.7 258.08,161.75 258.08,169.38 259.06,170.36 259.06,172.34 259.47,172.75 260.11,172.75 v3(260.51,173.15)
  BOTTOM w0.152: v3(258.59,142.97) G2.Y44 ; U48.F2 v3(260.51,173.15)
MDA32: length 22.8
  IN03 w0.14: v3(235.28,164.35) 234.81,163.89 234.81,157.65 238.13,154.33 238.92,154.33 240.61,152.64 242.11,152.64 245.12,149.63 245.12,148.9 v3(244.69,148.47)
  BOTTOM w0.152: v3(235.28,164.35) U2022.A4 ; G2.AW51 v3(244.69,148.47)
MDA33: length 21.4
  IN03 w0.14: v3(243.29,149.17) 243.29,149.27 242.74,149.82 240.97,149.82 233.44,157.35 233.44,164.12 v3(233.68,164.35)
  BOTTOM w0.152: G2.BA52 v3(243.29,149.17) ; v3(233.68,164.35) U2022.A2
MDA34: length 23.6
  IN03 w0.14: v3(244.69,147.77) 245.38,148.47 245.38,149.92 242.11,153.2 240.9,153.2 236.46,157.64 236.46,160.59 235.76,161.29 235.76,164.67 v3(235.28,165.15)
  BOTTOM w0.152: G2.AW50 v3(244.69,147.77) ; U2022.B4 235.67,165.55 v3(235.28,165.15)
MDA35: length 23.4
  IN03 w0.14: v3(243.88,148.46) 243.69,148.66 243.69,150.57 242.18,152.08 240.3,152.08 238.92,153.46 238.2,153.46 234.08,157.58 234.08,164.75 v3(233.68,165.15)
  BOTTOM w0.152: v3(243.88,148.46) G2.BA51 ; U2022.B2 234.07,165.55 v3(233.68,165.15)
MDA36: length 30.5
  IN03 w0.14: v3(243.29,147.77) 242.89,147.37 241.83,147.37 231.77,157.42 231.77,167.07 232.65,167.95 234.88,167.95 v3(235.28,168.35)
  BOTTOM w0.152: G2.BA50 v3(243.29,147.77) ; U2022.E4 v3(235.28,168.35)
MDA37: length 26.1
  IN03 w0.14: v3(242.59,147.77) 242.23,147.77 232.36,157.64 232.36,166.86 232.65,167.15 233.28,167.15 v3(233.68,167.55)
  BOTTOM w0.152: U2022.E2 234.07,167.95 v3(233.68,167.55) ; G2.BB50 v3(242.59,147.77)
MDA38: length 34.5
  IN03 w0.14: v3(243.29,146.47) 242.87,146.88 240.73,146.88 230.61,157 230.61,167.86 232.4,169.65 234.77,169.65 v3(235.28,169.15)
  BOTTOM w0.152: G2.BA49 v3(243.29,146.47) ; U2022.F4 v3(235.28,169.15)
MDA39: length 32.3
  IN03 w0.14: v3(244.69,146.47) 243.93,146.47 243.28,147.13 241.27,147.13 231.21,157.19 231.21,167.33 232.63,168.75 233.28,168.75 233.68,168.35 v3(233.68,168.35)
  BOTTOM w0.152: v3(233.68,168.35) U2022.F2 ; G2.AW49 v3(244.69,146.47)
MDA40: length 22
  IN10 w0.14: v3(245.99,146.37) 245.09,147.27 245.09,149.34 242.68,151.75 242.2,151.75 240.55,153.4 240.55,163.22 v3(241.68,164.35)
  BOTTOM w0.152: U2022.A11 v3(241.68,164.35) ; G2.AV48 v3(245.99,146.37)
MDA41: length 21.1
  IN10 w0.14: v3(243.28,164.35) 243.28,164.33 241.66,162.72 241.66,153.86 245.85,149.68 245.85,148.79 246.87,147.77 246.87,147.15 v3(246.79,147.07)
  BOTTOM w0.152: G2.AT49 v3(246.79,147.07) ; U2022.A13 v3(243.28,164.35)
MDA42: length 26.4
  IN10 w0.14: v3(246.79,145.07) 247.23,145.51 247.23,147.92 246.22,148.94 246.22,149.82 242.22,153.81 242.22,162.48 243.68,163.94 243.68,165.32 243.45,165.55 242.07,165.55 v3(241.68,165.15)
  BOTTOM w0.152: U2022.B11 v3(241.68,165.15) ; G2.AT47 v3(246.79,145.07)
MDA43: length 23.5
  IN10 w0.14: v3(243.28,165.15) 242.88,164.75 242.29,164.75 242.08,164.54 242.08,163.93 241.1,162.96 241.1,153.63 242.51,152.23 242.79,152.23 245.5,149.52 245.5,147.65 v3(246.79,146.37)
  BOTTOM w0.152: G2.AT48 v3(246.79,146.37) ; v3(243.28,165.15) 242.88,165.55 U2022.B13
MDA44: length 28.6
  IN10 w0.14: v3(241.68,167.55) 242.08,167.15 242.08,166.54 242.26,166.35 243.45,166.35 243.92,165.88 243.92,163.39 242.78,162.25 242.78,153.76 246.55,149.99 246.55,149.25 247.63,148.18 247.63,145.21 v3(246.79,144.37)
  BOTTOM w0.152: v3(246.79,144.37) G2.AT46 ; U2022.E11 v3(241.68,167.55)
MDA45: length 28.6
  IN10 w0.14: v3(240.46,151.35) 240.77,151.66 240.77,152.38 239.99,153.17 239.99,167.25 240.69,167.95 U2022.E13 v3(243.28,168.35)
  BOTTOM w0.102: 240.89,150.72 241.2,150.41 245.16,150.41 246.01,149.56 246.01,148.72 245.69,148.39 G2.AV51
  BOTTOM w0.152: 240.89,150.72 240.46,151.15 v3(240.46,151.35) ; v3(243.28,168.35) U2022.E13
MDA46: length 27.5
  IN10 w0.14: v3(239.53,152.09) 239.66,152.23 239.66,152.66 239.43,152.89 239.43,168.04 240.14,168.75 241.28,168.75 v3(241.68,168.35)
  BOTTOM w0.102: 240.76,150.26 240.91,150.11 244.89,150.11 245.69,149.31 G2.AV52
  BOTTOM w0.152: v3(239.53,152.09) 239.53,151.49 240.76,150.26 ; v3(241.68,168.35) U2022.F11
MDA47: length 32.7
  IN10 w0.14: v3(243.28,169.15) 242.87,169.55 239.82,169.55 238.87,168.59 238.87,152.59 v3(238.98,152.48)
  BOTTOM w0.102: 243.05,149.62 243.09,149.58 244.88,149.58 245.34,149.12 245.34,147.12 G2.AV49
  BOTTOM w0.152: U2022.F13 v3(243.28,169.15) ; v3(238.98,152.48) 238.89,152.38 238.89,151.49 240.55,149.83 242.84,149.83 243.05,149.62
MDA48: length 41.8
  IN10 w0.14: v3(241.67,177.95) 241.52,178.11 241.52,178.65 242.34,179.48 245.09,179.48 248.39,176.18 248.39,168.39 248.63,168.15 248.63,161.37 252.38,157.63 252.38,153.88 252.29,153.79 v3(252.29,146.37)
  BOTTOM w0.152: v3(252.29,146.37) G2.AJ48 ; v3(241.67,177.95) U2022.U11
MDA49: length 38.8
  IN10 w0.14: v3(243.28,177.95) 243.68,178.35 244.24,178.35 247.27,175.32 247.27,167.93 247.51,167.69 247.51,160.9 251.26,157.16 251.26,148.71 251.42,148.55 251.42,145.84 v3(252.29,144.97)
  BOTTOM w0.152: U2022.U13 v3(243.28,177.95) ; v3(252.29,144.97) 251.99,144.67 G2.AJ46
MDA50: length 41.4
  IN10 w0.14: v3(252.29,145.67) 251.81,146.14 251.81,154.43 251.82,154.43 251.82,157.39 248.07,161.14 248.07,167.92 247.83,168.16 247.83,175.55 244.47,178.91 242.83,178.91 242.07,178.16 242.07,177.55 v3(241.68,177.15)
  BOTTOM w0.152: U2022.T11 v3(241.68,177.15) ; v3(252.29,145.67) G2.AJ47
MDA51: length 34.6
  IN10 w0.14: v3(250.84,147.22) 250.86,147.24 250.86,148.16 250.7,148.32 250.7,156.92 246.95,160.67 246.95,167.45 246.71,167.69 246.71,174.28 244.24,176.75 243.68,176.75 v3(243.28,177.15)
  BOTTOM w0.152: G2.AK49 v3(250.84,147.22) ; U2022.T13 242.88,176.75 v3(243.28,177.15)
MDA52: length 35.9
  IN10 w0.14: v3(250.19,145.67) 249.87,145.99 249.87,147.69 250.14,147.96 250.14,156.69 246.39,160.44 246.39,167.22 246.16,167.46 246.16,173.31 244.32,175.15 242.08,175.15 v3(241.68,174.75)
  BOTTOM w0.152: v3(250.19,145.67) 249.89,145.37 G2.AM47 ; U2022.N11 v3(241.68,174.75)
MDA53: length 34.2
  IN10 w0.14: v3(250.29,144.92) 249.58,145.62 249.58,156.45 245.84,160.2 245.84,166.98 245.6,167.22 245.6,173.08 244.32,174.35 243.68,174.35 v3(243.28,173.95)
  BOTTOM w0.152: G2.AM46 250.14,144.92 v3(250.29,144.92) ; v3(243.28,173.95) U2022.N13
MDA54: length 35.8
  IN10 w0.14: v3(248.89,146.37) 249.3,146.78 249.3,148.33 248.92,148.71 248.92,151.21 248.27,151.87 245.69,151.87 243.98,153.58 243.98,156.59 245.28,157.89 245.28,166.75 244.73,167.3 244.73,173.16 244.33,173.55 242.08,173.55 v3(241.68,173.95)
  BOTTOM w0.152: v3(241.68,173.95) U2022.M11 ; G2.AN48 v3(248.89,146.37)
MDA55: length 31.9
  IN10 w0.14: v3(243.28,173.15) 243.28,171.88 243.8,171.35 243.8,167.01 244.06,166.75 244.48,166.75 244.72,166.51 244.72,158.12 243.42,156.82 243.42,153.63 245.73,151.32 247.77,151.32 248.45,150.64 248.45,148.27 248.89,147.83 v3(248.89,147.06)
  BOTTOM w0.152: G2.AN49 v3(248.89,147.06) ; v3(243.28,173.15) U2022.M13
MDA56: length 45.6
  IN03 w0.14: v3(235.28,177.15) 235.73,177.61 237.31,177.61 239.07,175.84 239.07,172.58 240.42,171.23 240.42,162.89 243.26,160.06 246.64,160.06 250.11,156.58 250.11,148.76 249.53,148.18 249.53,143.62 v3(250.19,142.97)
  BOTTOM w0.152: U2022.U4 v3(235.28,177.15) ; G2.AM44 v3(250.19,142.97)
MDA57: length 47.5
  IN03 w0.14: v3(250.19,143.67) 249.77,144.08 249.77,147.62 250.59,148.44 250.59,156.9 246.75,160.73 243.37,160.73 241.28,162.83 241.28,170.16 241.05,170.39 241.05,171.46 239.62,172.88 239.62,176.14 237.83,177.93 235.39,177.93 235,177.55 U2022.U2 v3(233.68,177.15)
  BOTTOM w0.152: U2022.U2 234.07,177.55 v3(233.68,177.15) ; G2.AM45 v3(250.19,143.67)
MDA58: length 42.9
  IN03 w0.14: v3(248.89,143.67) 249.29,144.07 249.29,148.73 249.67,149.11 249.67,156.23 246.54,159.36 243.01,159.36 239.72,162.65 239.72,170.72 238.56,171.88 238.56,175.36 237.17,176.75 236.47,176.75 v3(236.07,177.15)
  BOTTOM w0.152: v3(248.89,143.67) G2.AN45 ; U2022.T4 v3(236.07,177.15)
MDA59: length 45.3
  IN03 w0.14: v3(248.89,144.37) 248.03,144.37 247.24,143.58 247.24,142.91 246.94,142.61 246.34,142.61 245.48,143.47 245.48,146.67 245.86,147.06 245.86,149.97 241.96,153.87 241.7,153.87 241.47,154.09 241.47,156.94 236.7,161.72 236.7,169.1 235.86,169.93 235.86,170.73 235.44,171.15 235.11,171.15 233.92,171.15 233.28,171.79 233.28,175.21 233.68,175.61 v3(233.68,176.35)
  BOTTOM w0.152: v3(248.89,144.37) G2.AN46 ; v3(233.68,176.35) U2022.T2
MDA60: length 35.7
  IN03 w0.14: v3(235.28,173.95) 235.68,173.55 236.26,173.55 236.48,173.33 236.48,172.9 237.44,171.93 237.44,171.13 238.38,170.18 238.38,162.4 243.15,157.63 243.15,154.2 245.99,151.37 247.73,151.37 248.19,150.91 248.19,148.74 247.69,148.23 247.69,146.76 v3(248.08,146.37)
  BOTTOM w0.152: v3(248.08,146.37) G2.AR48 ; v3(235.28,173.95) U2022.N4
MDA61: length 40
  IN03 w0.076: 248.49,146.67 248.49,145.47 v3(248.89,145.07)
  IN03 w0.14: v3(234.48,173.95) 234.88,174.35 237.05,174.35 238.01,173.38 238.01,171.52 239.05,170.49 239.05,162.53 243.71,157.87 243.71,154.18 246.09,151.81 248.19,151.81 248.76,151.24 248.76,148.67 247.93,147.84 247.93,146.99 248.14,146.77 248.38,146.77 248.49,146.67
  BOTTOM w0.152: v3(248.89,145.07) G2.AN47 ; v3(234.48,173.95) U2022.N2
MDA62: length 33.4
  IN03 w0.14: v3(236.07,173.15) 236.07,172.32 236.99,171.41 236.99,170.71 237.82,169.88 237.82,162.17 242.59,157.4 242.59,154.27 246.53,150.33 246.53,149.01 247.45,148.09 247.45,146.3 v3(248.08,145.67)
  BOTTOM w0.152: v3(236.07,173.15) 235.67,173.55 U2022.M4 ; v3(248.08,145.67) 247.79,145.37 G2.AR47
MDA63: length 36
  IN03 w0.14: v3(248.08,144.97) 247.2,145.85 247.2,147.39 246.26,148.34 246.26,150.1 242.03,154.32 242.03,157.17 237.27,161.94 237.27,169.42 236.44,170.24 236.44,171.02 235.51,171.95 234.64,171.95 234.64,171.95 234.12,171.95 233.68,172.39 v3(233.68,173.15)
  BOTTOM w0.152: U2022.M2 234.07,173.55 v3(233.68,173.15) ; v3(248.08,144.97) 247.79,144.67 G2.AR46
MDB0: length 27.1
  IN10 w0.14: v3(287.22,148.47) 287.04,148.65 286.44,148.65 275.74,137.96 272.78,137.96 270.3,135.48 267.9,135.48 v3(266.99,134.57)
  BOTTOM w0.152: U2023.U4 287.29,148.54 v3(287.22,148.47) ; v3(266.99,134.57) G2.H32
MDB1: length 23.7
  IN10 w0.14: v3(273.3,134.87) 273.73,135.3 276.25,135.3 287.3,146.34 287.3,146.53 v3(287.3,146.54)
  BOTTOM w0.102: G2.D32 269.84,135.22 271.81,135.22 271.9,135.31 272.86,135.31 v3(273.3,134.87)
  BOTTOM w0.152: U2023.U2 v3(287.3,146.54)
MDB2: length 22.3
  IN10 w0.14: v3(288.1,148.14) 287.7,147.74 287.11,147.74 276.19,136.82 273.14,136.82 v3(272.04,135.72)
  BOTTOM w0.152: v3(272.04,135.72) 271.88,135.57 G2.A33 ; v3(288.1,148.14) U2023.T4
MDB3: length 23.8
  IN10 w0.14: v3(272.71,134.87) 273.02,135.17 273.02,136.03 273.24,136.25 276.41,136.25 287.1,146.94 287.7,146.94 v3(288.1,146.54)
  BOTTOM w0.102: G2.B32 271.07,134.87 271.49,134.45 272.3,134.45 v3(272.71,134.87)
  BOTTOM w0.152: U2023.T2 v3(288.1,146.54)
MDB4: length 31.9
  IN10 w0.14: v3(269.94,134.42) 269.98,134.47 270.7,134.47 271.27,133.9 278.42,133.9 288,143.48 290.3,143.48 291.7,144.88 291.7,147.74 v3(291.3,148.14)
  BOTTOM w0.152: G2.E32 268.99,134.87 269.33,134.52 269.84,134.52 v3(269.94,134.42) ; U2023.N4 v3(291.3,148.14)
MDB5: length 31.4
  IN10 w0.14: v3(290.5,146.54) 290.1,146.94 290.1,148.41 289.97,148.54 287.89,148.54 287.41,148.05 286.63,148.05 275.96,137.38 272.88,137.38 270.68,135.18 268.39,135.18 v3(267.69,134.49)
  BOTTOM w0.152: U2023.N2 v3(290.5,146.54) ; v3(267.69,134.49) 267.39,134.8 G2.G32
MDB6: length 36.3
  IN10 w0.14: v3(292.1,148.14) 292.69,147.55 292.69,145.08 290.53,142.92 288.24,142.92 278.66,133.34 266.11,133.34 265.69,133.77 v3(265.69,133.77)
  BOTTOM w0.152: U2023.M4 v3(292.1,148.14) ; G2.J30 v3(265.69,133.77)
MDB7: length 29.9
  IN10 w0.14: v3(268.39,134.57) 268.68,134.86 270.74,134.86 271.15,134.46 278.19,134.46 287.77,144.04 290.07,144.04 290.9,144.87 290.9,146.14 v3(291.3,146.54)
  BOTTOM w0.152: v3(268.39,134.57) G2.F32 ; U2023.M2 v3(291.3,146.54)
MDB8: length 30.9
  IN03 w0.14: v3(287.3,154.54) 287.3,153.42 284.31,150.43 284.31,148.73 274.71,139.12 272.55,139.12 270.53,137.1 266.66,137.1 266.39,137.37 v3(266.39,137.37)
  BOTTOM w0.152: G2.H36 v3(266.39,137.37) ; v3(287.3,154.54) U2023.U11
MDB9: length 30.9
  IN03 w0.076: 267.38,139.22 267.38,138.26 v3(267.09,137.97)
  IN03 w0.14: v3(287.3,156.14) 287.3,156.13 286.66,156.13 285.49,154.96 285.49,154.07 282.64,151.22 282.64,149.43 274.01,140.81 271.87,140.81 270.7,139.64 267.8,139.64 267.38,139.22
  BOTTOM w0.152: G2.G36 267.39,137.67 v3(267.09,137.97) ; U2023.U13 v3(287.3,156.14)
MDB10: length 32.6
  IN03 w0.14: v3(265.69,137.97) 265.87,137.78 266.62,137.78 266.91,137.49 270.31,137.49 272.5,139.68 274.48,139.68 283.75,148.96 283.75,150.72 286.63,153.6 286.63,154.49 287.08,154.94 287.7,154.94 v3(288.1,154.54)
  BOTTOM w0.152: v3(288.1,154.54) U2023.T11 ; G2.J36 265.99,137.67 v3(265.69,137.97)
MDB11: length 30.8
  IN03 w0.076: v3(267.79,137.97) 267.79,138.11 268.17,138.49 268.17,139.05
  IN03 w0.14: 268.17,139.05 268.39,139.27 271.19,139.27 272.17,140.24 274.24,140.24 283.19,149.2 283.19,150.96 286.06,153.83 286.06,154.72 287.08,155.74 287.7,155.74 v3(288.1,156.14)
  BOTTOM w0.152: v3(267.79,137.97) 268.09,137.67 G2.F36 ; U2023.T13 v3(288.1,156.14)
MDB12: length 33.2
  IN03 w0.076: v3(267.69,135.97) 267.95,135.7 268.8,135.7 268.94,135.55 270.38,135.55
  IN03 w0.14: v3(290.5,154.54) 290.1,154.14 290.1,153.51 288.84,152.24 287.93,152.24 285.43,149.75 285.43,148.26 275.18,138.01 272.83,138.01 270.38,135.55
  BOTTOM w0.152: v3(267.69,135.97) 268.09,135.57 G2.F33 ; v3(290.5,154.54) U2023.N11
MDB13: length 32.5
  IN03 w0.14: v3(290.5,156.14) 290.1,155.74 289.49,155.74 289.3,155.54 289.3,153.5 288.75,152.95 287.74,152.95 284.87,150.08 284.87,148.49 274.94,138.57 272.69,138.57 272.28,138.15 270.76,136.63 270.15,136.63 269.83,136.31 v3(269.83,135.94)
  BOTTOM w0.152: U2023.N13 v3(290.5,156.14) ; v3(269.83,135.94) 269.83,135.91 269.49,135.57 G2.D33
MDB14: length 37.2
  IN03 w0.076: v3(265.69,134.57) 266.33,135.21 268.65,135.21 268.79,135.07 270.8,135.07
  IN03 w0.14: 270.8,135.07 272.62,136.89 275.65,136.89 286.65,147.9 286.65,148.96 288.28,150.59 289.56,150.59 291.7,152.73 291.7,154.14 v3(291.3,154.54)
  BOTTOM w0.152: v3(291.3,154.54) U2023.M11 ; v3(265.69,134.57) G2.J32
MDB15: length 36.3
  IN03 w0.076: v3(267.09,135.87) 267.5,135.46 268.75,135.46 268.9,135.31 270.61,135.31
  IN03 w0.14: 270.61,135.31 272.74,137.45 275.41,137.45 286.03,148.06 286.03,149.3 288.14,151.41 289.2,151.41 290.9,153.11 290.9,155.74 v3(291.3,156.14)
  BOTTOM w0.152: U2023.M13 v3(291.3,156.14) ; G2.G33 267.39,135.57 v3(267.09,135.87)
MDB16: length 50.9
  IN03 w0.14: v3(300.9,153.74) 302.51,155.35 302.51,157.15 297.34,162.33 284.43,162.33 280.55,158.44 280.55,156.01 274.08,149.54 274.08,147.32 271.72,144.96 269.78,144.96 269.46,144.64 v3(269.08,144.27)
  BOTTOM w0.152: U2023.A11 v3(300.9,153.74) ; v3(269.08,144.27) G2.E45
MDB17: length 46
  IN03 w0.14: v3(300.9,155.34) 301.25,155.69 301.25,157.31 297.45,161.11 284.01,161.11 281.11,158.22 281.11,155.77 274.68,149.34 274.68,147.11 272.02,144.45 271.04,144.45 270.7,144.12 269.94,144.12 v3(269.79,144.27)
  BOTTOM w0.152: G2.D45 v3(269.79,144.27) ; v3(300.9,155.34) U2023.A13
MDB18: length 48.5
  IN03 w0.14: v3(267.79,144.27) 268.26,143.8 272.16,143.8 275.32,146.96 275.32,149.19 281.67,155.54 281.67,157.5 284.72,160.55 297.22,160.55 300.69,157.09 300.69,155.99 300.5,155.8 300.5,154.14 v3(300.1,153.74)
  BOTTOM w0.152: U2023.B11 v3(300.1,153.74) ; v3(267.79,144.27) G2.F45
MDB19: length 45.4
  IN03 w0.14: v3(300.1,156.14) 299.7,156.54 299.7,157.19 296.91,159.98 285.63,159.98 282.23,156.58 282.23,155.31 276.43,149.51 276.43,147.27 272.55,143.39 272.28,143.39 272.28,143.39 267.41,143.39 v3(266.91,143.88)
  BOTTOM w0.152: v3(266.91,143.88) 266.99,143.97 G2.G45 ; U2023.B13 v3(300.1,156.14)
MDB20: length 41.2
  IN03 w0.14: v3(297.7,154.54) 297.3,154.94 297.3,157.37 295.83,158.84 286.07,158.84 283.35,156.12 283.35,154.85 277.55,149.05 277.55,146.8 273.31,142.56 271.15,142.56 270.58,141.99 269.96,141.99 v3(269.79,142.17)
  BOTTOM w0.152: v3(297.7,154.54) U2023.E11 ; G2.D42 v3(269.79,142.17)
MDB21: length 41.6
  IN03 w0.14: v3(269.09,142.17) 269.89,142.98 272.93,142.98 276.99,147.03 276.99,149.28 282.79,155.08 282.79,156.35 285.86,159.42 296.28,159.42 298.1,157.6 298.1,156.54 v3(297.7,156.14)
  BOTTOM w0.152: v3(297.7,156.14) U2023.E13 ; v3(269.09,142.17) G2.E42
MDB22: length 41.6
  IN03 w0.14: v3(296.9,154.54) 296.5,154.94 296.5,157.16 296.07,157.59 285.61,157.59 283.91,155.89 283.91,154.61 278.11,148.81 278.11,146.56 273.57,142.03 271.52,142.03 271.08,141.59 268.37,141.59 v3(267.79,142.17)
  BOTTOM w0.152: U2023.F11 v3(296.9,154.54) ; G2.F42 v3(267.79,142.17)
MDB23: length 39.6
  IN03 w0.14: v3(296.1,156.14) 296.1,156.14 295.7,156.54 294.43,156.54 294.43,156.54 285.35,156.54 284.47,155.66 284.47,154.38 278.67,148.58 278.67,146.33 273.7,141.37 271.72,141.37 271.48,141.13 269.45,141.13 269.29,141.29 266.8,141.29 v3(266.39,140.87)
  BOTTOM w0.152: G2.H41 v3(266.39,140.87) ; v3(296.1,156.14) U2023.F13
MDB24: length 42.7
  IN10 w0.14: v3(300.1,148.14) 301.14,149.17 301.14,151.19 300.34,151.99 296.03,151.99 295.35,152.67 294.7,153.32 285.08,153.32 274,142.24 272.63,142.24 271.37,140.98 269.28,140.98 v3(269.1,140.8)
  BOTTOM w0.152: v3(269.1,140.8) 269.1,140.85 G2.E41 ; U2023.A4 v3(300.1,148.14)
MDB25: length 46.9
  IN10 w0.14: v3(300.9,147.34) 301.95,148.39 301.95,151.45 300.99,152.42 299.17,152.42 298.3,153.29 295.9,153.29 295.05,154.14 285.11,154.14 274.03,143.05 272.67,143.05 270.87,141.25 268.47,141.25 268.03,140.81 268.03,140.47 267.79,140.23 v3(267.79,140.07)
  BOTTOM w0.152: U2023.A2 v3(300.9,147.34) ; G2.F39 v3(267.79,140.07)
MDB26: length 40.5
  IN10 w0.14: v3(300.1,148.94) 300.1,148.94 300.55,149.39 300.55,150.62 299.78,151.4 294.49,151.4 293.13,152.76 285.31,152.76 274.23,141.68 272.66,141.68 271.7,140.72 269.74,140.72 v3(269.09,140.07)
  BOTTOM w0.152: v3(269.09,140.07) G2.E39 ; v3(300.1,148.94) U2023.B4
MDB27: length 39.8
  IN10 w0.14: v3(269.79,140.07) 269.94,139.92 271.52,139.92 272.72,141.12 274.46,141.12 285.55,152.2 292.86,152.2 294.25,150.81 298.82,150.81 299.7,149.93 299.7,147.74 v3(300.1,147.34)
  BOTTOM w0.152: G2.D39 v3(269.79,140.07) ; U2023.B2 v3(300.1,147.34)
MDB28: length 40.2
  IN10 w0.14: v3(296.9,148.14) U2023.E4 298.03,148.54 298.23,148.74 298.23,150.06 298.05,150.25 293.96,150.25 292.56,151.64 285.78,151.64 274.7,140.56 272.86,140.56 271.84,139.54 268.87,139.54 268.54,139.21 v3(268.54,138.61)
  BOTTOM w0.152: v3(268.54,138.61) G2.F38 ; v3(296.9,148.14) U2023.E4
MDB29: length 36.2
  IN10 w0.14: v3(296.9,147.34) 296.5,147.74 296.5,149.16 296.3,149.36 295.94,149.36 295.57,149.73 293.65,149.73 292.47,150.92 285.84,150.92 274.8,139.88 272.9,139.88 272.15,139.13 269.53,139.13 v3(269.1,138.7)
  BOTTOM w0.152: v3(269.1,138.7) 268.79,139.02 G2.E38 ; U2023.E2 v3(296.9,147.34)
MDB30: length 33.2
  IN10 w0.14: v3(269.79,137.97) 270.14,137.61 271.22,137.61 272.83,139.22 274.94,139.22 285.97,150.25 292.37,150.25 293.37,149.25 295.4,149.25 295.72,148.94 v3(296.1,148.94)
  BOTTOM w0.152: v3(296.1,148.94) 296.5,148.54 U2023.F4 ; v3(269.79,137.97) 269.49,137.67 G2.D36
MDB31: length 34.7
  IN10 w0.14: v3(269.09,137.97) 269.92,137.14 271.35,137.14 272.87,138.65 275.16,138.65 286.02,149.52 292.23,149.52 293,148.75 295.31,148.75 295.7,148.36 295.7,147.74 v3(296.1,147.34)
  BOTTOM w0.152: v3(269.09,137.97) 268.79,137.67 G2.E36 ; v3(296.1,147.34) U2023.F2
MDB32: length 20.6
  IN03 w0.14: v3(263.87,151.21) 263.88,151.21 263.88,152.22 268.94,157.29 268.94,162.52 270.33,163.9 v3(270.33,164.35)
  BOTTOM w0.102: v3(263.87,151.21) 263.87,151.21 263.42,150.75 263.42,149.94 263.29,149.81 263.29,148.57 263.54,148.32 263.54,148.02 263.89,147.67 G2.M50
  BOTTOM w0.152: U55.A4 v3(270.33,164.35)
MDB33: length 21.6
  IN03 w0.14: v3(268.73,164.35) 267.77,163.4 267.77,157.7 262.78,152.71 262.78,146.42 v3(262.89,146.32)
  BOTTOM w0.152: G2.P48 262.74,146.32 v3(262.89,146.32) ; U55.A2 v3(268.73,164.35)
MDB34: length 21
  IN03 w0.14: v3(263.87,149.94) 264.57,150.64 264.57,152.05 269.5,156.97 269.5,162 270.82,163.32 270.82,164.65 v3(270.33,165.15)
  BOTTOM w0.102: v3(263.87,149.94) 263.49,149.56 263.49,148.75 263.89,148.36 G2.M51
  BOTTOM w0.152: U55.B4 v3(270.33,165.15)
MDB35: length 22.1
  IN03 w0.14: v3(269.53,165.15) 269.13,164.75 269.13,163.74 268.38,163 268.38,157.52 263.34,152.48 263.34,149.22 263.92,148.63 263.92,147.61 v3(263.48,147.17)
  BOTTOM w0.152: G2.M49 v3(263.48,147.17) ; U55.B2 v3(269.53,165.15)
MDB36: length 30.3
  IN03 w0.14: v3(270.33,168.35) 269.93,167.95 267.51,167.95 266.59,167.03 266.59,158.1 263.22,154.74 261.72,154.74 261.35,154.36 261.35,149.14 262.48,148.01 262.48,145.97 v3(262.79,145.67)
  BOTTOM w0.152: v3(262.79,145.67) 262.49,145.37 G2.P47 ; v3(270.33,168.35) U55.E4
MDB37: length 22.8
  IN03 w0.14: v3(268.73,167.55) 268.33,167.15 267.7,167.15 267.19,166.64 267.19,157.91 262.22,152.94 262.22,150.9 v3(261.79,150.47)
  BOTTOM w0.102: v3(261.79,150.47) 262.49,149.77 G2.P52
  BOTTOM w0.152: U55.E2 v3(268.73,167.55)
MDB38: length 34
  IN03 w0.14: v3(261.49,144.37) 261.89,144.78 261.89,147.67 260.52,149.05 260.52,151.28 260.77,151.53 260.77,154.94 261.75,155.91 262.82,155.91 265.46,158.55 265.46,168.27 266.84,169.65 269.83,169.65 v3(270.33,169.15)
  BOTTOM w0.152: v3(261.49,144.37) G2.R46 ; U55.F4 v3(270.33,169.15)
MDB39: length 30.8
  IN03 w0.14: v3(262.89,144.82) 262.18,145.52 262.18,147.84 260.93,149.08 260.93,151.03 261.05,151.15 261.05,154.61 261.75,155.31 263.01,155.31 266.03,158.33 266.03,167.53 267.24,168.75 268.33,168.75 v3(268.73,168.35)
  BOTTOM w0.152: G2.P46 262.64,144.82 v3(262.89,144.82) ; v3(268.73,168.35) U55.F2
MDB40: length 23.4
  IN10 w0.076: 264.76,152.84 264.76,150.25
  IN10 w0.14: v3(276.73,164.35) 276.26,164.35 273.8,161.89 273.8,161.88 264.76,152.84 ; 264.76,150.25 v3(265.49,149.52)
  BOTTOM w0.102: v3(265.49,149.52) 265.49,149.17 265.18,148.87 265.18,148.56 264.94,148.31 264.94,148.06 264.59,147.71 G2.L50
  BOTTOM w0.152: U55.A11 v3(276.73,164.35)
MDB41: length 24.1
  IN10 w0.14: v3(278.33,164.35) 278.33,164.35 278.54,164.13 278.54,162.38 271.37,155.21 270.64,155.21 266.97,151.54 266.97,150.46 266.48,149.96 265.77,149.96 v3(265.54,150.19)
  BOTTOM w0.102: 265.04,149.98 264.92,149.86 264.92,148.76 264.59,148.42 G2.L51
  BOTTOM w0.152: 265.04,149.98 265.25,150.19 v3(265.54,150.19) ; v3(278.33,164.35) U55.A13
MDB42: length 23
  IN10 w0.076: 265,152.29 265,151.36
  IN10 w0.14: v3(276.73,165.15) 277.13,164.75 277.13,164.02 276.58,163.47 276.18,163.47 265,152.29 ; 265,151.36 v3(265.53,150.83)
  BOTTOM w0.102: G2.L52 264.59,150.11 264.77,150.29
  BOTTOM w0.152: v3(276.73,165.15) 276.33,165.55 U55.B11 ; 264.77,150.29 265.31,150.83 v3(265.53,150.83)
MDB43: length 26.2
  IN10 w0.14: v3(278.33,165.15) 277.93,164.75 277.93,162.56 271.24,155.87 269.37,155.87 265.86,152.35 265.65,152.35 v3(265.4,152.1)
  BOTTOM w0.102: G2.L49 264.24,147.12 264.24,149.02 264.29,149.08 264.29,150.54
  BOTTOM w0.152: U55.B13 v3(278.33,165.15) ; v3(265.4,152.1) 265.27,152.1 264.53,151.36 264.53,150.77 264.29,150.54
MDB44: length 33.6
  IN10 w0.076: 264.27,153.95 264.27,149.56
  IN10 w0.14: 264.27,149.56 264.51,149.33 264.51,148.62 264.27,148.39 264.27,144.36 v3(263.47,143.55) ; 264.27,153.95 268.63,158.31 268.63,158.31 274.42,164.09 274.42,167.26 275.1,167.95 U55.E11 v3(276.73,167.55)
  BOTTOM w0.1: v3(263.47,143.55) 263.53,143.61 263.97,143.61 264.19,143.84 264.19,144.36 G2.M46
  BOTTOM w0.152: U55.E11 v3(276.73,167.55)
MDB45: length 31.2
  IN10 w0.076: 264.52,153.39 264.52,149.86
  IN10 w0.14: 264.52,149.86 265.11,149.27 265.11,148.37 264.52,147.78 264.52,146.04 v3(264.89,145.67) ; 264.52,153.39 268.87,157.75 268.87,157.75 275.35,164.23 275.35,166.77 275.73,167.15 277.74,167.15 277.93,167.34 U55.E13 v3(278.33,168.35)
  BOTTOM w0.152: G2.L47 264.59,145.37 v3(264.89,145.67) ; U55.E13 v3(278.33,168.35)
MDB46: length 30.6
  IN10 w0.14: v3(263.48,146.34) 263.89,146.75 263.89,147.72 263.47,148.14 263.47,151.63 263.9,152.07 263.9,154.37 273.47,163.94 273.47,167.33 274.89,168.75 276.33,168.75 v3(276.73,168.35)
  BOTTOM w0.152: U55.F11 v3(276.73,168.35) ; G2.M48 263.62,146.34 v3(263.48,146.34)
MDB47: length 35.5
  IN10 w0.14: v3(263.59,145.07) 263.39,145.27 262.6,145.27 262.38,145.49 262.38,147.48 263.03,148.13 263.03,152 263.48,152.45 263.48,154.74 272.65,163.91 272.65,167.82 274.37,169.55 277.93,169.55 v3(278.33,169.15)
  BOTTOM w0.152: U55.F13 v3(278.33,169.15) ; v3(263.59,145.07) G2.M47
MDB48: length 49.1
  IN10 w0.14: v3(269.19,145.77) 272.2,145.77 274.05,147.61 274.05,150.55 282.1,158.6 282.86,158.6 283.73,159.47 283.73,165.16 284.09,165.53 284.09,174.4 282.5,175.99 282.5,177.37 280.36,179.51 278.01,179.51 276.73,178.23 v3(276.73,177.95)
  BOTTOM w0.152: v3(276.73,177.95) U55.U11 ; G2.D48 v3(269.19,145.77)
MDB49: length 39
  IN10 w0.14: v3(278.33,177.95) 278.73,177.55 279.29,177.55 279.71,177.13 279.71,175.22 280.85,174.08 280.85,173.18 282.32,171.72 282.32,166.96 281.88,166.52 281.88,160.83 272.37,151.32 272.37,148.32 272.09,148.05 271.66,148.05 271.5,148.21 270.93,148.21 v3(270.49,147.77)
  BOTTOM w0.152: G2.C50 v3(270.49,147.77) ; U55.U13 v3(278.33,177.95)
MDB50: length 45.6
  IN10 w0.14: v3(276.73,177.15) 277.13,177.55 277.13,178.14 277.93,178.94 279.76,178.94 281.55,177.15 281.55,176.15 283.5,174.2 283.5,166.18 283.14,165.83 283.14,160.44 273.49,150.78 273.49,147.72 272.55,146.78 270.9,146.78 v3(270.49,146.37)
  BOTTOM w0.152: U55.T11 v3(276.73,177.15) ; G2.C48 v3(270.49,146.37)
MDB51: length 42.7
  IN10 w0.14: v3(278.33,177.15) 277.93,177.55 277.93,178.15 278.15,178.37 279.52,178.37 280.49,177.4 280.49,175.57 282.94,173.12 282.94,166.64 282.54,166.24 282.54,160.63 272.93,151.02 272.93,147.75 272.24,147.07 v3(270.49,147.07)
  BOTTOM w0.152: v3(278.33,177.15) 277.93,176.75 U55.T13 ; G2.C49 v3(270.49,147.07)
MDB52: length 38
  IN10 w0.14: v3(276.73,174.75) 276.75,174.75 277.13,174.37 277.13,173.73 277.31,173.55 279.36,173.55 279.68,173.23 279.68,172.51 281.11,171.08 281.11,167.72 280.58,167.19 280.58,161.11 269.92,150.45 269.79,150.45 269.1,149.76 269.1,149.48 268.28,148.66 268.28,148.11 268.55,147.84 268.55,147 v3(269.09,146.47)
  BOTTOM w0.152: U55.N11 v3(276.73,174.75) ; G2.E49 v3(269.09,146.47)
MDB53: length 36.3
  IN10 w0.14: v3(278.33,174.75) 278.73,174.35 279.72,174.35 280.27,173.8 280.27,172.93 281.68,171.52 281.68,167.16 281.25,166.73 281.25,160.98 270.81,150.54 270.81,149.43 270.27,148.89 268.92,148.89 268.66,148.63 268.66,148.2 v3(269.09,147.77)
  BOTTOM w0.152: v3(278.33,174.75) 277.93,174.35 U55.N13 ; G2.E50 v3(269.09,147.77)
MDB54: length 35.9
  IN10 w0.076: 266.84,146.77 267.28,146.77 v3(267.69,146.37)
  IN10 w0.14: 266.84,146.77 266.48,147.13 266.48,148.64 279.33,161.48 279.33,163.87 278.84,164.36 278.84,171.05 276.72,173.16 276.72,173.95 v3(276.73,173.95)
  BOTTOM w0.152: G2.F49 v3(267.69,146.37) ; U55.M11 v3(276.73,173.95)
MDB55: length 34.3
  IN10 w0.14: v3(278.33,173.15) 278.33,172.5 279.9,170.93 279.9,161.22 268.52,149.83 268.52,149.33 267.81,148.63 267.81,148.06 268.09,147.78 G2.F48 v3(267.79,145.77)
  BOTTOM w0.152: U55.M13 278.33,173.15 v3(278.33,173.15) ; v3(267.79,145.77) G2.F48
MDB56: length 37.9
  IN03 w0.14: v3(271.13,177.15) 271.57,177.59 272.41,177.59 274.17,175.83 274.17,172.69 275.41,171.45 275.41,161.13 275.76,160.78 275.76,155.97 270.34,150.55 269.94,150.55 269.39,150.01 269.39,149.5 268.62,148.72 268.62,148.1 v3(267.69,147.17)
  BOTTOM w0.152: v3(271.13,177.15) U55.U4 ; G2.F50 267.79,147.17 v3(267.69,147.17)
MDB57: length 38.1
  IN03 w0.14: v3(269.53,177.15) 270.38,178.01 272.86,178.01 274.65,176.22 274.65,173.02 276.33,171.34 276.33,156.36 276.32,156.36 276.32,155.75 270.7,150.12 270.09,150.12 v3(269.91,149.95)
  BOTTOM w0.152: v3(269.53,177.15) U55.U2 ; G2.D52 269.44,148.91 269.44,149.48 v3(269.91,149.95)
MDB58: length 34.8
  IN03 w0.14: v3(271.13,176.35) 271.53,175.95 272.13,175.95 273.18,174.9 273.18,171.38 274.02,170.54 274.02,156.86 270.68,153.53 270.68,152.4 268.66,150.38 268.36,150.38 265.74,147.77 v3(265.69,147.77)
  BOTTOM w0.152: U55.T4 v3(271.13,176.35) ; G2.J50 v3(265.69,147.77)
MDB59: length 39.9
  IN03 w0.14: v3(266.99,146.37) 266.61,146.74 266.61,147.4 268.67,149.46 268.67,149.8 275.15,156.28 275.15,160.11 274.67,160.6 274.67,170.74 273.73,171.68 273.73,175.25 272.23,176.75 269.13,176.75 v3(268.73,177.15)
  BOTTOM w0.152: G2.H48 v3(266.99,146.37) ; U55.T2 v3(268.73,177.15)
MDB60: length 32.6
  IN03 w0.14: v3(270.33,173.95) 270.77,174.39 272.15,174.39 272.62,173.92 272.62,171.11 273.33,170.39 273.33,160.84 272.56,160.07 272.56,156.28 270.09,153.81 270.09,152.47 268.55,150.92 v3(267.59,150.92)
  BOTTOM w0.102: 267.27,149.34 267.27,148.97 266.69,148.39 G2.H51
  BOTTOM w0.152: v3(270.33,173.95) U55.N4 ; 267.27,149.34 267.27,150.32 267.59,150.64 v3(267.59,150.92)
MDB61: length 31.7
  IN03 w0.14: v3(269.53,173.95) 269.93,173.55 271.3,173.55 271.53,173.32 271.53,172.75 271.95,172.33 271.95,170.92 272.74,170.13 272.74,161.1 272,160.36 272,156.63 267.1,151.73 267.1,149.95 265.71,148.57 v3(265.59,148.57)
  BOTTOM w0.152: G2.J51 v3(265.59,148.57) ; v3(269.53,173.95) U55.N2
MDB62: length 30.3
  IN03 w0.14: v3(266.51,150.83) 266.51,151.97 271.44,156.9 271.44,160.68 272.18,161.42 272.18,169.85 271.08,170.96 271.08,172.33 270.33,173.08 v3(270.33,173.15)
  BOTTOM w0.152: v3(266.51,150.83) 266.51,149.3 266.35,149.13 266.35,147.1 G2.H49 ; U55.M4 v3(270.33,173.15)
MDB63: length 30.4
  IN03 w0.14: v3(268.72,173.95) 269.13,173.55 269.13,170.57 269.35,170.35 270.85,170.35 271.58,169.62 271.58,161.68 270.89,160.98 270.89,157.24 266.08,152.43 v3(266.08,152.02)
  BOTTOM w0.102: 266.92,149.3 266.92,149.1 G2.H52
  BOTTOM w0.152: 266.92,149.3 266.92,151.17 v3(266.08,152.02) ; v3(268.72,173.95) 269.12,173.55 U55.M2
MDC0: length 20.2
  IN10 w0.14: v3(287.43,113.09) 283.71,113.09 280.82,115.99 272.27,115.99 272.03,116.22 270.67,116.22 v3(269.89,117)
  BOTTOM w0.152: U2025.U4 287.82,113.48 v3(287.43,113.09) ; v3(269.89,117) 270.19,116.71 G2.C6
MDC1: length 20.7
  IN10 w0.14: v3(273.22,115.43) 280.58,115.43 284.52,111.49 287.04,111.49 287.04,111.49 v3(287.43,111.49)
  BOTTOM w0.152: v3(273.22,115.43) 272.34,116.31 269.85,116.31 G2.D6 ; U2025.U2 287.82,111.88 v3(287.43,111.49)
MDC2: length 20.5
  IN10 w0.14: v3(288.23,113.09) 288.63,113.49 288.63,114.06 288.35,114.34 284.05,114.34 281.23,117.16 274.71,117.16 274.4,117.47 272.88,117.47 v3(272.41,117.01)
  BOTTOM w0.152: v3(288.23,113.09) 288.62,113.48 U2025.T4 ; v3(272.41,117.01) 272.07,116.67 G2.A6
MDC3: length 21.1
  IN10 w0.14: v3(271.19,116.97) 271.55,116.6 280.99,116.6 283.9,113.69 287.42,113.69 287.83,113.29 287.83,111.89 v3(288.23,111.49)
  BOTTOM w0.152: v3(288.23,111.49) 288.62,111.88 U2025.T2 ; v3(271.19,116.97) G2.B6
