# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWM4_VCC: length 63.3
  TOP w0.203: 130.44,190.8 PU1101.31
  TOP w0.254: v1(131.13,190.55) 130.89,190.8 130.44,190.8
  IN03 w0.254: v1(188.06,190.45) 187.55,190.96 185.39,190.96 184.22,192.13 166.34,192.13 163.52,189.31 152.75,189.31 151.66,190.4 136.06,190.4 134.28,188.62 133.07,188.62 v1(131.13,190.55)
  BOTTOM w0.254: PR1629.2 v1(188.06,190.45)
PWR_LED_W: length 314.9
  IN05 w0.089: 41.5,57.99 41.12,58.37 41.12,58.63
  IN05 w0.091: 41.12,58.63 41.12,59.39 39.59,60.91 37.82,60.91 36.67,59.77 36.04,59.77 34.77,61.04 v1(34.39,61.04) ; 41.5,57.99 41.81,57.68 45.38,57.68 46.5,58.8 52.12,58.8 53.06,57.86 53.06,55.2 55.21,53.04 55.6,53.04 58.39,50.24 58.39,49.36 59.41,48.34 66.9,48.34 67.62,47.61 71.94,47.61 72.82,46.74 89.4,46.74 90.25,45.88 94.25,45.88 98.14,41.99 98.14,39.93 101.97,36.1 110.53,36.1 113.35,38.92 v1(114.52,38.92) ; v1(302.86,32.08) 302.43,32.52 300.78,32.52 300.32,32.97 300.32,35.64 297.15,38.81 295.8,38.81 293.34,41.28 287.81,41.28 287.09,41.99 278.71,41.99 276.93,43.77 275.33,43.77 273.55,41.99 270.2,41.99 267.41,44.78 264.13,44.78 263.61,44.27 258.61,44.27 257.88,43.54 256.61,43.54 v1(256.21,43.13)
  IN08 w0.091: v1(256.21,43.13) 255.78,42.7 255.01,42.7 254.55,43.16 252.85,43.16 252.57,42.88 235.81,42.88 235.2,43.49 223.77,43.49 222.78,42.5 215.83,42.5 212.79,45.55 202.66,45.55 199.83,42.72 192.99,42.72 190.22,45.49 170.71,45.49 168.82,47.38 119.37,47.38 114.14,42.15 114.14,39.3 v1(114.52,38.92)
  BOTTOM w0.076: 34.53,56.21 34.53,55.67 34.27,55.42 U5.M5
  BOTTOM w0.097: v1(302.86,32.08) 302.42,32.52 JIO1.52 ; v1(34.39,61.04) 33.96,60.61 33.96,58.55 34.53,57.98 34.53,56.21
PWR_LEVEL: length 285.3
  TOP w0.097: D2011.1 238.5,116.92 v3(238.35,117.07)
  IN03 w0.091: v1(66.14,66.28) 66.02,66.39 59.81,66.39 55.6,62.18 51.79,62.18 51.15,62.82 49.63,62.82 49.12,63.33 45.05,63.33 44.67,62.94 32.1,62.94 27.27,58.12 v2(26.64,58.12) v1(26,57.48)
  IN05 w0.091: v3(238.35,117.07) 238.43,116.99 240.43,116.99 240.89,116.54 240.89,113.49 240.51,113.11 239.99,113.11 239.75,112.87 239.75,108.66 239.11,108.03 239.11,105.56 238.09,104.54 238.09,91.5 237.69,91.09 218.33,91.09 216.58,92.84 213.66,92.84 213.33,93.17 213.33,93.93 210.28,96.98 204.75,96.98 204.24,96.47 138.4,96.47 135.35,93.42 135.35,92.28 133.7,90.63 133.7,88.6 133.07,87.96 129.26,87.96 127.96,86.67 127.96,80.44 123.77,76.24 109.66,76.24 108.43,75.01 105.3,75.01 104.67,74.37 103.64,74.37 100.97,71.71 100.3,71.71 96.14,67.55 96.14,65.8 93.52,63.17 93.52,61.93 91.58,59.99 74.99,59.99 74.14,59.13 72.61,59.13 71.85,59.9 71.85,60.91 68.88,63.88 67.74,63.88 67.41,64.21 67.41,65.01 v1(66.14,66.28)
  BOTTOM w0.089: U5.N1 32.27,56.93 31.08,58.12 29.81,58.12
  BOTTOM w0.097: v1(26,57.48) v2(26.64,58.12) 28.11,58.12 R255.1 28.67,58.63 29.18,58.12 29.81,58.12
PWR_LEVEL_R: length 257.5
  TOP w0.097: D2011.2 239.73,116.92 v3(240.39,116.27) 240.39,116.19 240.01,115.81 240.01,115.49 240.23,115.27 240.37,115.27 240.77,114.87 240.77,114.85 241.5,114.13 243.43,114.13 243.64,113.92 245.41,113.92 245.97,113.36 248.51,113.36 248.76,113.11 250.89,113.11 250.99,113.21 251.58,113.21 252.19,112.6 R983.1 ; v1(73.63,60.02) 73.12,59.52 71.22,59.52 70.45,58.75 70.45,56.21 v1(70.96,55.71)
  IN03 w0.091: v1(45.56,49.48) 46.45,49.48 46.96,48.97 54.96,48.97 56.48,50.5 58.59,50.5 63.8,55.71 v1(70.96,55.71)
  IN05 w0.091: v3(240.39,116.27) 239.99,116.67 239.62,116.67 239.24,116.28 239.24,116.03 239.49,115.78 239.49,115.4 238.86,114.76 238.86,112.6 238.48,112.22 238.22,112.22 237.42,111.42 236.56,111.42 236.22,111.08 236.22,109.77 233.59,107.14 233.59,105.57 232.71,104.68 219.76,104.68 217.39,102.31 211.17,102.31 208.15,99.29 208.15,98.73 207.66,98.25 201.87,98.25 200.6,96.98 138.19,96.98 134.84,93.64 134.84,92.49 133.19,90.84 133.19,88.81 132.85,88.47 129.04,88.47 127.46,86.88 127.46,80.6 123.61,76.75 109.37,76.75 108.41,75.79 104.33,75.79 100.76,72.22 100.09,72.22 95.67,67.8 95.67,65.98 93.09,63.39 93.09,62.21 91.3,60.43 74.03,60.43 v1(73.63,60.02)
  BOTTOM w0.097: v3(240.39,116.27) G2.BE6 ; D2016.2 v1(45.56,49.48)
PWR_SRC_CRTCAL_N: length 6.4
  BOTTOM w0.097: PU5.9 300.43,197.95 300.17,197.69 v2(300.17,195.28) 299.75,194.87 PR35.1 PR25.1 PR27.1
PWR_SRC_WARN_N: length 2.8
  BOTTOM w0.097: PU5.8 302.14,195.15 PR32.1 PR31.1
REGN: length 21
  TOP w0.254: 88.67,9.1 88.36,9.4 PU201.20 ; PR223.2 v1(90.14,3.64) ; PR222.2 v1(82.95,4.02)
  TOP w0.508: v1(91.79,8.21) 91.98,8.4 PC215.1 91.92,9.29 PR214.2 90.14,9.29 89.95,9.1 v2(89.66,9.1) 88.67,9.1
  IN03 w0.254: v1(82.95,4.02) 83.71,4.78 86.58,4.78 87.22,4.14 89.63,4.14 v1(90.14,3.64) 91.79,5.29 v1(91.79,8.21)
REMOTE1_N: length 136.4
  BOTTOM w0.254: Q10.3 143.56,161.75 C635.2 143.56,160.35 143.23,160.02 143.23,158.07 142.46,157.31 142.46,147.65 140.56,145.75 140.56,136.73 138.65,134.83 134.46,134.83 129.51,129.87 129.51,117.3 133.95,112.86 197.33,112.86 199.74,115.27 202.92,115.27 204.97,117.33 v2(205.79,117.33) 205.84,117.33 206.04,117.12 C634.1 206.04,115.69 206.09,115.64 U25.3
REMOTE1_P: length 140.2
  BOTTOM w0.254: U25.2 205.59,115.39 205.12,115.85 C634.2 204.57,116.28 203.04,114.76 199.87,114.76 197.45,112.35 133.7,112.35 129.13,116.92 129.13,130.13 134.21,135.21 138.4,135.21 140.18,136.99 140.18,146 142.08,147.91 142.08,157.56 142.82,158.3 142.82,160.23 142.64,160.4 C635.1 142.64,161.45 141.89,162.19 Q10.1 141.32,163.21 v2(141.32,163.83) 143.25,163.83 Q10.2
REMOTE2_N: length 9
  TOP w0.254: v1(207.11,118.14) 207.19,118.14 v2(207.61,118.57) 207.61,120.09 207.28,120.42 C638.2 206.77,120.63 Q24.3
  BOTTOM w0.254: U25.5 207.09,114.84 207.94,115.7 C636.1 207.94,117.56 207.36,118.14 v1(207.11,118.14)
REMOTE2_P: length 9
  TOP w0.254: Q24.1 204.98,119.33 Q24.2 206.11,119.51 C638.1 206.98,119.08 206.6,118.7 v2(206.6,117.81) 206.98,117.43 v1(207.11,117.43)
  BOTTOM w0.254: v1(207.11,117.43) 207.03,117.35 C636.2 207.03,115.52 206.59,115.09 206.59,114.93 206.59,114.92 U25.4
RF_KILL_BT_N: length 40.2
  TOP w0.097: R484.2 v1(256.76,66.12)
  IN03 w0.091: v1(256.76,66.12) 256.38,66.12 256.05,65.79 256.05,65.48 256,65.48 252.95,62.44 252.95,62.06 252.32,61.42 252.32,49.1 v3(251.56,48.34)
  IN05 w0.091: v3(237.08,53.04) 237.08,52.53 238.48,51.13 239.62,51.13 240.38,50.37 244.29,50.37 245.04,51.13 249.28,51.13 251.56,48.85 v3(251.56,48.34)
  BOTTOM w0.097: v3(251.56,48.34) 251.43,48.21 R102.1 ; U2.BC23 237.3,52.82 v3(237.08,53.04)
RF_KILL_WIFI_N: length 39.7
  TOP w0.097: R517.2 v1(256.76,67.39)
  IN03 w0.091: v1(250.29,48.34) 252.06,50.12 252.06,61.55 252.7,62.18 252.7,62.64 255.8,65.74 255.8,66.42 v1(256.76,67.39)
  IN05 w0.091: v3(236.82,51.13) 237.46,51.13 239.11,49.48 244.57,49.48 245.33,50.24 248.94,50.24 250.29,48.9 v1(250.29,48.34)
  BOTTOM w0.097: v3(236.82,51.13) 236.82,51.14 U2.BD24 ; v1(250.29,48.34) 250.54,48.09 R99.1
ROM_CS: length 86.2
  TOP w0.097: v1(242.41,101.93) 242.84,102.36 242.84,103.16 242.71,103.28 242.71,104.7 243.3,105.29 243.3,106.34 242.92,106.73 242.92,109.96 241.8,111.08 239.87,111.08 238.86,112.09 238.35,112.09 237.84,112.6 237.84,114.13 237.69,114.28 v3(237.69,114.97)
  IN10 w0.091: v1(273.65,80.72) 273.65,80.22 273.22,79.78 259.37,79.78 258.94,79.35 251.09,79.35 249.33,81.11 241.65,81.11 240.06,82.69 238.73,84.03 238.73,98.12 242.41,101.81 v1(242.41,101.93)
  BOTTOM w0.097: v1(273.65,80.72) 274.54,79.84 278.86,79.84 v2(279.88,80.85) 280.26,81.23 280.26,84.23 R2168.2 ; v3(237.69,114.97) G2.BJ4
ROM_CS_R: length 2.7
  BOTTOM w0.097: U2021.1 R944.1 R2168.1
ROM_SCLK: length 84.8
  TOP w0.097: v3(236.99,114.27) 236.97,114.27 236.57,113.87 236.57,113.24 236.6,113.2 236.6,112.31 238.48,110.44 238.48,107.52 238.98,107.01 238.98,106.76 239.49,106.25 239.92,106.25 R2155.2 ; R2154.2 240.2,107.12 240.43,106.89 240.43,106 R2155.2 ; v1(241.51,102.7) 241.14,103.06 241.14,104.98 240.89,105.24 240.63,105.24 240.3,105.57 R2155.2
  IN10 w0.091: v1(276.45,80.72) 274.85,79.12 260.5,79.12 259.99,78.62 250.74,78.62 249.02,80.34 241.33,80.34 240.86,80.82 237.97,83.71 237.97,99.14 239.49,100.66 239.49,100.68 v1(241.51,102.7)
  BOTTOM w0.097: R2209.1 279.37,83.95 279.42,83.9 v2(279.42,83.26) 279.42,81.92 277.97,80.47 276.7,80.47 v1(276.45,80.72) ; v3(236.99,114.27) G2.BK3
ROM_SCLK_R: length 13.6
  BOTTOM w0.097: R2209.2 v2(279.37,86.95) 279.37,87.84 280.51,88.98 285.47,88.98 286.68,87.76 286.68,86.87 287.12,86.44 U2021.6
ROM_SI: length 84.6
  TOP w0.097: v1(241.52,101.93) 241.98,102.39 241.98,102.87 241.52,103.33 241.52,104.85 241.88,105.21 242.59,105.21 242.84,105.46 242.84,105.82 v2(242.41,106.25) 242.03,106.63 241.27,106.63 240.76,107.14 240.76,108.03 240.38,108.41 R2150.2 R2151.2 240.2,109.86 239.19,110.87 238.42,110.87 236.82,112.47 236.82,113.11 236.99,113.27 v3(236.99,113.57)
  IN10 w0.091: v1(275.18,80.72) 275.18,80.22 274.3,79.34 259.83,79.34 259.39,78.91 250.81,78.91 249.12,80.6 241.44,80.6 239.63,82.41 238.22,83.82 238.22,98.63 v1(241.52,101.93)
  BOTTOM w0.097: R929.1 277.72,83.26 v1(275.18,80.72) ; v3(236.99,113.57) G2.BK2
ROM_SI_R: length 13.4
  BOTTOM w0.097: R929.2 v2(277.72,90.12) 278.61,90.12 279.5,89.23 285.97,89.23 287.5,87.71 U2021.5
ROM_SO: length 87.5
  TOP w0.097: v3(236.99,114.97) 237,114.97 237.46,114.51 237.46,113.74 237.59,113.61 237.59,112.47 238.25,111.81 238.75,111.81 241.19,109.38 R2153.2 R2152.2 241.19,107.22 241.52,106.89 242.41,106.89 242.89,106.4 242.89,106.15 243.06,105.98 243.06,105.37 242.68,104.98 242.03,104.98 241.78,104.73 241.78,103.46 242.41,102.82 v1(242.41,102.7)
  IN10 w0.091: v1(242.41,102.7) 241.95,102.24 241.95,101.73 238.48,98.25 238.48,83.92 240.3,82.09 241.55,80.85 249.23,80.85 250.95,79.13 259.23,79.13 259.66,79.56 273.91,79.56 274.42,80.07 v1(274.42,80.72)
  BOTTOM w0.097: v1(274.42,80.72) 274.92,80.22 278.23,80.22 280,81.99 280,85.42 280.26,85.68 R928.1 ; v3(236.99,114.97) G2.BK4
ROM_SO_R: length 2
  BOTTOM w0.097: U2021.2 282.24,85.17 R928.2
RTCRST_N: length 82.4
  TOP w0.097: v3(244.57,52.76) 244.29,52.49 244.29,51.92 v2(244.32,51.9) 244.32,50.24 244.65,49.91 C188.1 244.65,48.59 R163.1 245.33,47.91 245.33,47.32 244.83,46.82 Q12.1
  IN05 w0.091: v3(244.57,52.76) 244.57,52.03 245.08,51.51 249.27,51.51 249.65,51.13 251.05,51.13 251.68,51.77 251.68,54.69 252.62,55.62 257.19,55.62 262.1,60.53 266.03,60.53 267.3,59.26 275.05,59.26 275.94,58.37 287.62,58.37 v1(287.75,58.25)
  BOTTOM w0.097: TP77.1 307,58.7 304.26,55.96 302.26,55.96 300.73,54.44 293.09,54.44 289.28,58.25 v1(287.75,58.25) ; v3(244.57,52.76) 244.55,52.78 243.94,52.78 243.54,52.39 U2.BC10
RTD3_CIO_PWR_EN_R: length 21.3
  TOP w0.097: R2041.1 R2042.1 v1(61.82,92.92) 61.44,93.3 R2282.1
  IN03 w0.089: 55.09,91.27 49.63,91.27 48.84,92.05
  IN03 w0.091: v2(47.87,92.15) 48.74,92.15 48.84,92.05 ; v1(61.82,92.92) 61.18,92.28 61.18,91.52 58.64,88.98 56.74,88.98 55.6,90.12 55.6,90.76 55.09,91.27
  BOTTOM w0.102: U2005.F1 48.14,91.49 47.87,91.75 v2(47.87,92.15)
RTD3_USB_PWR_EN_R: length 3.5
  TOP w0.102: R2043.1 44.34,88.37 45.21,88.37 45.44,88.6 45.44,88.8 R2044.1 46.52,89.44 v2(46.72,89.63)
  BOTTOM w0.178: U2005.D4 47,89.91 v2(46.72,89.63)
SATA_A_DE: length 2.9
  TOP w0.097: U14.9 282.79,61.38 R472.2 R466.1
SATA_A_EQ1: length 4.8
  TOP w0.097: v2(285.21,67.52) R470.1 R476.2 283.46,67.85 283.46,67.75 282.79,67.08 U14.17
SATA_A_EQ2: length 3.3
  TOP w0.097: U14.18 282.29,67.08 282.87,67.67 282.87,68.38 R469.1 R475.2
SATA_B_DE: length 2.7
  TOP w0.097: U14.8 R471.2 R465.1
SATA_B_EQ1: length 3.4
  TOP w0.097: v1(282.44,67.9) 281.79,67.25 U14.19
  BOTTOM w0.097: v1(282.44,67.9) 282.75,68.2 R468.1 282.93,68.71 R474.2
SATA_B_EQ2: length 6.5
  TOP w0.097: U14.13 v1(285.21,64.72)
  IN08 w0.091: v1(286.48,67.9) 285.21,66.63 v1(285.21,64.72)
  BOTTOM w0.097: R467.1 R473.2 286.35,68.02 v1(286.48,67.9)
SATA_REXT: length 3.2
  TOP w0.097: R463.1 279.62,61.9 279.85,62.13 281.05,62.13 281.29,62.38 U14.6
SATA_RX__R_N0: length 2.2
  TOP w0.104: U14.12 284.58,64.22 284.7,64.1 284.95,64.1 285.34,63.71 285.65,63.71 R2234.1
SATA_RX__R_P0: length 2.1
  TOP w0.104: U14.11 284.58,63.72 284.7,63.84 284.84,63.84 285.23,63.45 285.77,63.45 R2115.1
SATA_RX_C_DN0: length 1.9
  TOP w0.104: U14.4 279.98,64.22 279.85,64.09 279.64,64.09 279.39,63.84 279.19,63.84 C567.2
SATA_RX_C_DP0: length 1.9
  TOP w0.104: C571.2 279.19,63.58 279.49,63.58 279.75,63.83 279.88,63.83 279.98,63.72 U14.5
SATA_RX_C_N0: length 2.2
  BOTTOM w0.104: JHDD1.4 293.61,86.58 293.34,86.31 292.54,86.31 C569.2
SATA_RX_C_P0: length 2.3
  BOTTOM w0.104: JHDD1.5 293.61,85.78 293.34,86.05 292.57,86.05 C570.2
SATA_RX_DN0: length 69.6
  TOP w0.104: v1(277.21,63.96) 277.46,64.21 C567.1
  IN03 w0.114: v1(277.21,63.96) 277.45,63.72 277.96,63.72 278.23,63.45 278.23,62.94 277.72,62.44 276.7,62.44 274.8,64.34 274.8,66.38 270.88,70.3 251.19,70.3 248.9,72.58 246.87,72.58 246.08,73.38 246.08,74.18 245.13,75.13 244.48,75.13 244.29,75.32 241.33,75.32 240.51,74.5 240.51,73.36 239.73,72.58 238.08,72.58 236.85,71.36 235.71,71.36 235.6,71.25 235.6,69.85 235.19,69.44 234.68,69.44 234.35,69.11 234.35,67.2 233.19,66.04 232.21,66.04 231.82,66.43 231.82,66.7 230.97,67.55 230.97,68.42 230.62,68.77 229.72,68.77 229.45,69.04 229.45,69.38 229.29,69.54 229.29,69.54 229.11,69.54 v3(228.7,69.42)
  BOTTOM w0.104: U2.H42 228.61,69.5 v3(228.7,69.42) ; C567.1 277.46,64.21 v1(277.21,63.96)
SATA_RX_DP0: length 69.5
  TOP w0.104: C571.1 277.84,63.14 277.39,63.14 v1(277.2,63.33)
  IN03 w0.114: v3(229.2,70.34) 228.82,70.34 228.67,70.19 228.67,69.94 228.8,69.81 229.36,69.81 229.46,69.75 229.71,69.49 229.71,69.16 229.83,69.04 230.73,69.04 231.24,68.53 231.24,67.66 232.09,66.81 232.09,66.54 232.32,66.31 233.08,66.31 234.08,67.31 234.08,69.22 234.57,69.71 235.08,69.71 235.34,69.96 235.34,71.36 235.6,71.62 236.74,71.62 237.97,72.85 239.62,72.85 240.24,73.47 240.24,74.61 241.22,75.59 244.4,75.59 244.59,75.4 245.24,75.4 246.35,74.29 246.35,73.49 246.98,72.85 249.01,72.85 251.3,70.56 270.99,70.56 275.06,66.49 275.06,64.45 276.81,62.7 277.61,62.7 277.96,63.06 277.96,63.34 277.85,63.45 277.33,63.45 v1(277.2,63.33)
  BOTTOM w0.104: v3(229.2,70.34) 229.29,70.25 229.29,70.01 229.11,69.83 U2.H40 ; v1(277.2,63.33) 277.33,63.2 C571.1
SATA_RX_N0: length 32.5
  TOP w0.104: v1(287.57,63.96) 287.57,63.83 287.5,63.76 287.04,63.76 286.94,63.86 R2234.2
  IN08 w0.114: v1(290.29,86.69) 289.92,86.32 289.54,86.32 289.14,85.92 289.14,81.75 290.67,80.22 290.67,78.88 292.82,76.73 292.82,72.18 292.18,71.55 292.18,65.6 290.3,63.71 287.82,63.71 v1(287.57,63.96)
  BOTTOM w0.104: R2234.2 286.94,63.93 287.16,63.71 287.35,63.71 287.57,63.93 v1(287.57,63.96) ; C569.1 291.01,86.29 290.69,86.29 v1(290.29,86.69)
SATA_RX_P0: length 32.5
  TOP w0.104: v1(287.57,63.2) 287.57,63.32 287.39,63.5 287.05,63.5 286.94,63.39 R2115.2
  IN08 w0.114: v1(287.57,63.2) 287.57,63.33 287.69,63.45 290.41,63.45 292.45,65.48 292.45,71.44 293.09,72.07 293.09,76.84 290.94,78.99 290.94,80.33 289.4,81.86 289.4,85.81 289.65,86.05 289.92,86.05 v1(290.29,85.68)
  BOTTOM w0.104: R2115.2 287.19,63.45 287.5,63.45 287.57,63.38 v1(287.57,63.2) ; C570.1 291.01,86.03 290.65,86.03 v1(290.29,85.68)
SATA_TX__R_N0: length 2
  TOP w0.104: U14.14 284.83,65.22 284.96,65.34 285.22,65.34 285.34,65.23 285.77,65.23 R2113.1
SATA_TX__R_P0: length 2.1
  TOP w0.104: R2112.1 285.65,65.49 285.44,65.49 285.33,65.6 284.96,65.6 284.83,65.72 U14.15
SATA_TX_C_DN0: length 1.8
  TOP w0.104: U14.2 280.01,65.22 279.85,65.39 279.62,65.39 279.46,65.55 279.13,65.55 C566.2
SATA_TX_C_DP0: length 1.8
  TOP w0.104: C565.2 279.25,65.81 279.57,65.81 279.7,65.67 279.96,65.67 280,65.72 U14.1
SATA_TX_C_N0: length 2.2
  BOTTOM w0.104: JHDD1.2 293.61,88.18 293.34,88.45 292.61,88.45 C568.2
SATA_TX_C_P0: length 2.2
  BOTTOM w0.104: JHDD1.1 293.61,88.98 293.34,88.71 292.56,88.71 C564.2
SATA_TX_DN0: length 70.7
  TOP w0.104: v1(277.22,65.33) 277.32,65.23 C566.1
  IN03 w0.114: v1(277.22,65.33) 277.84,65.33 279.38,66.87 279.38,68.9 276.83,71.45 253.08,71.45 250.79,73.74 250.79,74.76 250.15,75.4 247.6,75.4 245.66,77.35 240.2,77.35 239.81,77.74 237.4,77.74 236.68,77.03 236.68,73.47 236.45,73.23 234.92,73.23 234.03,72.34 229.84,72.34 229.33,72.85 227.22,72.85 225.67,71.3 v3(225.44,71.3)
  BOTTOM w0.104: C566.1 277.32,65.23 v1(277.22,65.33) ; U2.E45 226.28,71.03 225.71,71.03 v3(225.44,71.3)
SATA_TX_DP0: length 70.7
  TOP w0.104: C565.1 277.85,66.2 277.26,66.2 v1(277.21,66.25)
  IN03 w0.114: v1(277.21,66.25) 277.21,65.96 277.58,65.6 277.73,65.6 279.12,66.98 279.12,68.79 276.72,71.19 252.97,71.19 250.53,73.63 250.53,74.65 250.04,75.14 247.49,75.14 245.55,77.08 240.09,77.08 239.7,77.48 237.51,77.48 236.95,76.92 236.95,73.36 236.56,72.97 235.03,72.97 234.14,72.08 229.73,72.08 229.22,72.58 227.33,72.58 225.83,71.08 225.83,70.68 225.7,70.56 v3(225.44,70.56)
  BOTTOM w0.104: C565.1 v1(277.21,66.25) ; U2.F45 226.26,70.77 225.66,70.77 v3(225.44,70.56)
SATA_TX_N0: length 32.6
  TOP w0.104: v1(287.57,64.98) 287.57,65.15 287.5,65.23 287.19,65.23 R2113.2
  IN08 w0.114: v1(287.57,64.98) 287.83,65.23 290.04,65.23 290.43,65.62 290.43,71.59 291.82,72.98 291.82,76.8 289.92,78.69 289.92,79.95 288.4,81.47 288.4,87.34 289.4,88.34 289.92,88.34 v1(290.29,87.96)
  BOTTOM w0.104: v1(290.29,87.96) 290.72,88.4 291.06,88.4 C568.1 ; v1(287.57,64.98) 287.57,65.13 287.45,65.26 287.22,65.26 R2113.2
SATA_TX_P0: length 32.5
  TOP w0.104: R2112.2 286.94,65.79 287.24,65.49 287.35,65.49 287.57,65.71 v1(287.57,65.75)
  IN08 w0.114: v1(287.57,65.75) 287.83,65.5 289.93,65.5 290.16,65.73 290.16,71.7 291.55,73.09 291.55,76.69 289.66,78.58 289.66,79.84 288.13,81.36 288.13,87.45 289.29,88.61 289.92,88.61 v1(290.29,88.98)
  BOTTOM w0.104: v1(290.29,88.98) 290.62,88.65 291.01,88.65 C564.1 ; v1(287.57,65.75) 287.57,65.68 287.41,65.51 287.29,65.51 R2112.2
SENSOR_INT_N: length 357.1
  TOP w0.097: U24.C2 274.04,10.75 v1(274.67,11.38) 274.97,11.08 R552.2 v1(278.48,11.08) ; U23.C2 84.05,97.24 84.3,97.49 v2(84.3,98) 84.3,98.63 v1(83.79,99.14)
  IN03 w0.091: v1(200.76,38.43) 161.13,38.43 149.55,50.01 119.14,50.01 107.56,38.43 99.79,38.43 98.18,40.04 89.97,40.04 89.05,39.12 71.04,39.12 68.17,41.99 63.72,41.99 63.09,42.62 v1(63.09,44.53) ; v1(278.48,11.08) 278.18,11.38 v1(274.67,11.38)
  IN10 w0.091: v1(83.79,99.14) 84.3,98.63 84.3,93.3 81.25,90.25 79.91,90.25 77.82,88.16 77.82,81.36 77.31,80.85 66.14,80.85 61.51,76.22 61.51,68.21 62.33,67.39 62.33,57.74 64.36,55.71 69.06,55.71 70.33,54.44 70.33,49.61 66.64,45.93 64.49,45.93 v1(63.09,44.53) ; v1(200.76,38.43) 201.52,39.2 205.68,39.2 208.47,41.99 210.53,41.99 213.86,38.65 256.65,38.65 260.58,42.59 263.83,42.59 265.27,41.15 265.27,34.62 264.26,33.61 264.26,28.4 264.76,27.89 264.76,26.24 264,25.48 264,22.56 269.34,17.22 276.45,17.22 277.72,15.95 277.72,11.84 v1(278.48,11.08)
SERIRQ: length 256.2
  TOP w0.097: v3(239.62,53.55) 239.87,53.29 R179.1
  IN03 w0.091: v1(42.39,37.42) 42.39,37.29 43.48,36.2 45,36.2 47.59,33.61 57.88,33.61 58.52,32.97 70.79,32.97 73.84,29.92 84.81,29.92 85.19,30.31 95.75,30.31 96.44,31 96.44,32.64 96.77,32.97 107.65,32.97 119.92,45.24 135.02,45.24 139.8,40.47 139.8,39.45 v1(140.43,38.81)
  IN05 w0.091: v1(26.13,51.01) 26.26,51.01 26.77,50.5 26.77,40.21 26.94,40.04 27.45,40.04 28.38,39.11 28.38,38.41 30.89,35.89 39.21,35.89 40.74,37.42 v1(42.39,37.42)
  IN10 w0.091: v1(140.43,38.81) 141.07,39.45 141.07,41.81 149.63,50.37 170.03,50.37 171.04,51.38 174.79,51.38 175.69,52.28 179.67,52.28 180.11,51.84 194.75,51.84 196.11,53.2 196.11,54.17 197.01,55.07 204.52,55.07 205.33,55.89 220.37,55.89 220.97,55.29 220.97,55.28 223.48,52.77 225.15,52.77 225.52,52.4 226.48,52.4 227.62,51.26 228.59,51.26 229.1,51.77 231.98,51.77 232.17,51.95 234.44,51.95 235.59,53.1 236.13,53.1 236.44,53.42 237.59,53.42 237.97,53.04 238.86,53.04 239.36,53.55 v3(239.62,53.55)
  BOTTOM w0.097: U2.BA17 239.86,53.55 v3(239.62,53.55) ; R294.1 26.26,51.13 v1(26.13,51.01)
SERIRQ_R: length 6
  BOTTOM w0.076: 31.77,53.17 32.51,53.17 32.77,52.91 U5.G2
  BOTTOM w0.097: R294.2 28.7,51.13 v2(30.48,52.91) 31.01,53.44 31.49,53.44 31.77,53.17
SLP_S3_N: length 277.6
  TOP w0.097: R144.2 238.35,46.94 v1(238.6,46.69) ; R2033.1 v1(26.13,87.07)
  IN03 w0.091: v1(238.6,46.69) 235.68,43.77 223.87,43.77 222.77,42.67 217.27,42.67 216.76,43.18 216.76,46.94 217.9,48.09 217.9,48.47 216.5,49.86 201.26,49.86 201.01,49.61 176.17,49.61 175.4,50.37 161.01,50.37 155.42,55.96 127.42,55.96 125.89,57.48 105.88,57.48 104.78,56.39 89.97,56.39 87.01,53.42 75.03,53.42 71.12,49.52 63.5,49.52 60.71,46.72 53.39,46.72 52.91,46.24 47.09,46.24 46.63,46.69 45.79,46.69 45.44,46.33 43.94,46.33 43.4,45.8 v1(41.75,45.8)
  IN10 w0.089: 36.29,68.91 36.29,70.44 35.91,70.82 35.91,76.43 34.26,78.08 34.26,78.87 33.88,79.25 33.65,79.25 32.18,80.72 ; v2(38.2,48.97) 38.07,48.85 33.24,48.85 31.59,50.5 31.59,54.18 33.81,56.4 36.48,56.4 37.18,57.1 37.18,58.63
  IN10 w0.091: v1(26.13,87.07) 26.7,86.5 26.83,86.5 27.97,85.36 30.89,85.36 31.97,84.28 31.97,80.93 32.18,80.72 ; 36.29,68.91 36.29,64.6 37.18,63.71 37.18,58.63
  BOTTOM w0.089: v2(38.2,48.97) 37.82,48.59 37.82,48.21 38.7,47.32 39.59,47.32 40.23,46.69
  BOTTOM w0.097: v2(38.2,48.97) 37.78,49.4 U5.A12 ; v1(41.75,45.8) 41.12,45.8 40.23,46.69
SLP_S3_N_R: length 9.1
  TOP w0.097: R144.1 238.35,48.34 240,49.99 v2(240.51,49.99) 241.02,50.5 241.02,52.53 240.13,53.42 240.13,53.93 v3(240.76,54.56)
  BOTTOM w0.097: v3(240.76,54.56) 241.29,54.03 U2.AW15
SLP_S4_N: length 290.3
  IN03 w0.089: 39.93,47.24 v3(38.83,48.34)
  IN03 w0.091: v1(239.87,46.69) 239.24,47.32 238.6,47.32 235.35,44.07 223.67,44.07 222.48,42.89 217.65,42.89 217.14,43.4 217.14,47.01 218.28,48.16 218.28,48.85 216.5,50.63 212.69,50.63 212.19,51.13 v1(200.93,51.13) 199.66,49.86 176.25,49.86 175.48,50.63 161.13,50.63 155.54,56.21 127.63,56.21 126.11,57.74 105.68,57.74 104.55,56.6 89.64,56.6 86.71,53.67 74.9,53.67 70.96,49.74 63.22,49.74 60.43,46.94 53.3,46.94 52.92,46.56 47.21,46.56 46.78,46.99 43.83,46.99 43.58,47.24 39.93,47.24
  BOTTOM w0.097: PD401.1 208.63,109.23 208.63,108.03 207.64,107.04 207.64,102.68 207.41,102.44 206.09,102.44 205.58,101.93 205.58,96.85 204.44,95.71 204.44,87.2 207.49,84.15 209.01,84.15 209.27,83.9 209.27,68.53 203.55,62.82 203.55,57.48 200.93,54.87 v1(200.93,51.13) ; U5.A13 38.78,49.41 38.78,48.39 v3(38.83,48.34) ; R145.2 240.13,46.94 v1(239.87,46.69)
SLP_S4_N_R: length 4
  BOTTOM w0.097: R145.1 240.51,48.67 240.51,48.97 241.27,49.74 241.27,51.17 241.36,51.26 U2.BD15
SLP_S5_N: length 2.3
  TOP w0.097: v3(241.9,53.8) 241.4,54.31 TP71.1
  BOTTOM w0.097: U2.BA13 242.28,53.43 v3(241.9,53.8)
SLP_SUS_N: length 1.4
  TOP w0.097: TP74.1 v3(242.79,53.42)
  BOTTOM w0.097: U2.BB13 242.28,52.78 242.79,53.29 v3(242.79,53.42)
SMB_CLK: length 220.1
  TOP w0.097: v1(104.74,81.87) 105,82.13 105,84.08 PR430.1 ; R153.1 v3(224,54.05)
  IN08 w0.091: v1(98.14,32.46) 98.78,32.46 99.16,32.08 99.16,29.11 101.26,27 113.25,27 114.9,28.65 121.38,28.65 121.64,28.91 121.64,40.97 123.25,42.59 135.99,42.59 138.53,40.05 138.53,39.45 v1(139.16,38.81)
  IN10 w0.091: v1(98.14,32.46) 98.14,35.39 105.63,42.88 105.63,60.66 103.99,62.3 103.99,79.59 104.74,80.34 v1(104.74,81.87) ; v1(139.16,38.81) 139.67,39.32 139.67,41.55 149.17,51.06 169.31,51.06 170.53,52.28 174.72,52.28 175.36,52.91 176.19,52.91 177.52,54.23 179.62,54.23 180.94,52.91 192.63,52.91 v1(193.14,53.42) 195.88,56.16 203.98,56.16 204.67,56.85 221.63,56.85 222.91,55.57 222.91,55.09 223.95,54.05 v3(224,54.05)
  BOTTOM w0.097: U2.AW44 226.86,54.24 226.54,54.56 224.76,54.56 224.51,54.31 224.25,54.31 v3(224,54.05) ; Q1.6 195.04,53.8 195.04,53.16 194.79,52.91 193.64,52.91 v1(193.14,53.42)
SMB_CLK_GPU: length 24.1
  TOP w0.097: Q80.1 218.35,120.72 218.57,120.5 218.57,119.49 219.23,118.82 220.31,118.82 v2(220.44,118.95) 220.82,119.33 223.87,119.33 224.88,118.32 228.44,118.32 229.2,117.55 233.45,117.55 233.52,117.48 233.52,116.66 233.77,116.41 234.31,116.41 R2294.1 235.96,118.06 237.39,118.06 v3(237.69,117.77)
  BOTTOM w0.1: G2.BJ8 v3(237.69,117.77)
SMB_DATA: length 224.4
  TOP w0.097: v3(227.81,53.04) 227.68,52.91 224.84,52.91 R155.1 ; PR426.1 104.57,84.13 v1(104.57,82.5)
  IN08 w0.091: v1(140.43,40.08) 137.71,42.81 123.16,42.81 121.42,41.06 121.42,29 121.29,28.87 114.65,28.87 113.29,27.51 101.35,27.51 99.54,29.32 99.54,32.46 99.03,32.97 98.01,32.97 v1(97.51,32.46)
  IN10 w0.091: v1(104.57,82.5) 104.32,82.25 104.32,80.43 103.7,79.81 103.7,61.19 105.38,59.52 105.38,43.42 97.51,35.54 v1(97.51,32.46) ; v3(227.81,53.04) 227.68,53.17 225.75,53.17 225.37,53.55 223.75,53.55 220.68,56.62 204.83,56.62 204.12,55.91 196.03,55.91 194.41,54.28 v1(194.41,53.42) 193.64,52.66 180.82,52.66 179.55,53.93 177.64,53.93 176.37,52.66 175.48,52.66 174.72,51.9 170.78,51.9 169.64,50.75 149.5,50.75 140.43,41.68 v1(140.43,40.08)
  BOTTOM w0.097: v3(227.81,53.04) 227.49,53.04 U2.BB43 ; Q1.3 193.89,55.19 194.03,55.05 194.03,53.93 194.41,53.55 v1(194.41,53.42)
SMB_DATA_GPU: length 22.8
  TOP w0.097: Q80.4 220.2,119.85 220.57,120.22 220.57,120.73 220.82,120.98 221.33,120.98 221.97,121.62 222.85,121.62 223.62,120.86 224.12,120.86 224.51,120.48 224.51,119.97 225.27,119.21 225.52,119.21 v2(225.65,119.08) 229.33,119.08 230.25,118.16 233.24,118.16 233.37,118.29 234.44,118.29 R2295.1 235.3,118.29 237.86,118.29 v3(238.39,117.77)
  BOTTOM w0.1: v3(238.39,117.77) G2.BH8
SMBALERT_N: length 6.4
  TOP w0.097: v3(227.55,52.4) 227.43,52.28 v2(227.43,51.01) 227.43,49.86 225.65,48.09 R169.2
  BOTTOM w0.097: v3(227.55,52.4) 227.73,52.58 U2.BB41
SML0_CLK: length 4.2
  BOTTOM w0.097: U2.AY44 226.69,53.64 226.69,53.83 226.49,54.03 225.5,54.03 225.14,53.67 223.69,53.67 R150.1
SML0_DATA: length 7.6
  TOP w0.097: v3(229.08,53.22) 229.15,53.22 229.71,52.66 229.71,50.73 v2(228.59,49.61) 227.43,48.44 R151.1
  BOTTOM w0.097: U2.BB39 229.08,52.82 229.08,53.17 v3(229.08,53.22)
SML0ALERT_N: length 9.4
  TOP w0.097: v3(229.08,53.93) 229.46,53.55 229.46,53.42 230.47,52.4 230.47,50.63 228.32,48.47 v3(228.32,48.09) R372.1
  BOTTOM w0.097: R372.1 v3(228.32,48.09) ; v3(229.08,53.93) 228.62,53.47 U2.BA40
SML1_CLK: length 29.5
  TOP w0.097: v3(227.81,53.8) v2(227.31,53.3) 227.17,53.17 224.2,53.17 R158.1
  IN08 w0.091: v1(222.6,43.9) 223.23,44.53 224.38,44.53 226.92,47.07 229.59,47.07 230.86,48.34 230.86,51.51 229.84,52.53 228.82,52.53 228.44,52.91 228.44,53.17 v3(227.81,53.8)
  BOTTOM w0.097: U2.AW42 227.97,53.96 v3(227.81,53.8) ; Q2.6 217.91,44.28 218.08,44.11 218.08,43.36 218.3,43.13 221.83,43.13 v1(222.6,43.9)
SML1_DATA: length 15.2
  TOP w0.097: v3(224.89,54.05) 224.51,53.67 223.82,53.67 R159.1
  IN08 w0.091: v3(224.89,54.05) 223.31,52.48 v1(221.58,52.48)
  BOTTOM w0.097: v1(221.58,52.48) 221.53,52.48 219.02,49.97 219.02,46.31 218.91,46.2 Q2.3 ; v3(224.89,54.05) 225.12,54.29 U2.AW45
SNUB_3V: length 1.3
  TOP w0.457: PR310.2 PC313.1
SNUB_5V: length 1.6
  TOP w0.508: PC314.1 37.69,6.62 PR311.2
SPDIF_OUT: length 2
  TOP w0.254: TP103.1 283.03,36.3 283.53,36.3 284.03,35.81 U7.2
SPK_CON_L+: length 35.7
  TOP w0.508: C356.2 294.74,60.91 v1(294.61,61.04)
  TOP w0.762: R68.1 279.88,40.4 279.88,40.47 v1(280.26,40.85)
  IN03 w0.762: v1(294.61,61.04) 295.24,61.04 295.63,60.66 295.63,59.52 294.99,58.88 292.83,58.88 291.43,57.48 291.43,52.62 289.28,50.46 289.28,44.02 287.37,42.12 281.53,42.12 v1(280.26,40.85)
  BOTTOM w0.508: v1(294.61,61.04) JSPKR1.2
SPK_CON_L-: length 34
  TOP w0.508: C357.2 294.71,59.9 v1(294.61,59.79)
  TOP w0.762: R69.1 v1(278.35,40.85)
  IN03 w0.762: v1(278.35,40.85) 278.99,40.85 281.15,43.01 286.86,43.01 288.39,44.53 288.39,51.01 290.42,53.04 290.42,57.74 292.47,59.79 v1(294.61,59.79)
  BOTTOM w0.508: JSPKR1.1 v1(294.61,59.79)
SPK_CON_R+: length 48.8
  TOP w0.508: C359.2 v1(294.74,63.45)
  TOP w0.762: R66.1 265.4,40.62 v2(266.05,41.27) 267.41,42.62 v1(268.07,42.62)
  IN03 w0.762: v1(268.07,42.62) 268.19,42.5 272.51,42.5 274.16,44.15 274.16,53.8 278.81,58.45 278.81,60.02 280.72,61.93 292.58,61.93 294.1,63.45 v1(294.74,63.45)
  BOTTOM w0.508: v1(294.74,63.45) 294.65,63.54 JSPKR1.4
SPK_CON_R-: length 46.6
  TOP w0.508: C355.2 v1(294.63,62.44)
  TOP w0.762: R67.1 267.98,41.35 v1(268.07,41.35)
  IN03 w0.762: v1(294.63,62.44) 293.23,61.04 281.09,61.04 279.75,59.7 279.75,57.1 275.05,52.4 275.05,43.77 272.89,41.61 268.32,41.61 v1(268.07,41.35)
  BOTTOM w0.508: v1(294.63,62.44) 294.48,62.29 JSPKR1.3
SPK_L+: length 2.7
  TOP w0.097: U7.49 288.33,37.65 287.8,38.18 287.8,38.59 288.39,39.17 v2(288.39,39.32)
SPK_L-: length 3.5
  TOP w0.097: U7.50 287.93,37.69 287.42,38.21 v2(287.42,38.36) 287.42,38.56 287.92,39.06 287.92,39.49 TP92.1
SPK_R+: length 18.6
  TOP w0.279: v3(289.3,38.38) 289.13,38.21 U7.47
  TOP w0.508: v1(276.7,42.9) 276.75,42.9 277.24,42.42 R343.2
  IN10 w0.762: v1(276.7,42.9) 277.06,43.26 286.99,43.26 288.64,41.61 288.64,39.44 289.3,38.78 289.3,38.38 v3(289.3,38.38)
SPK_R-: length 17.2
  TOP w0.279: v1(288.21,38.43) 288.34,38.43 288.73,38.04 U7.48
  TOP w0.508: v1(276.65,41.89) 276.4,41.89 275.86,42.42 R339.2
  IN10 w0.762: v1(276.65,41.89) 277.24,41.89 277.59,42.24 286.48,42.24 287.62,41.1 287.62,39.02 v1(288.21,38.43)
SPKR_LED_GND: length 1.1
  BOTTOM w0.457: v1(306.55,101.17) 306.77,100.95 JSPBL1.6
SRTCRST_N: length 5.8
  TOP w0.097: R160.1 243.17,48.59 v3(242.79,48.97)
  BOTTOM w0.097: U2.BB10 243.3,52.55 243.3,51.32 242.97,50.99 242.97,50.27 243.17,50.07 243.17,49.63 242.79,49.25 v3(242.79,48.97) C187.1
SSD1_DAS: length 3.5
  TOP w0.097: TP99.1 96.06,43.28 v1(95.7,43.64)
  BOTTOM w0.097: v1(95.7,43.64) 95.92,43.42 96.93,43.42 96.93,43.42 JSSD1.10
SSD2_DAS_DSS: length 2.8
  TOP w0.097: TP100.1 100.6,67.39 v1(100.17,67.39)
  BOTTOM w0.097: v1(100.17,67.39) 99.77,67.79 JSSD2.10
STRAP0: length 17.9
  TOP w0.097: R2156.2 221.53,112.6 223.24,112.6 223.44,112.8 R2162.1 224,113.11 v2(224.51,113.62) 225.9,115.01 230.09,115.01 231.24,113.87 233.9,113.87 234.16,113.62 235.55,113.62 236.2,114.27 v3(236.29,114.27)
  BOTTOM w0.097: v3(236.29,114.27) G2.BL3
STRAP1: length 17.5
  TOP w0.097: v3(236.29,114.97) 235.83,114.51 235.17,114.51 234.79,114.13 231.49,114.13 230.38,115.24 225.36,115.24 v2(225.01,114.89) 224.12,114 R2163.1 223.44,114.18 223.16,114.45 221.48,114.45 R2157.2
  BOTTOM w0.097: v3(236.29,114.97) G2.BL4
STRAP2: length 16.6
  TOP w0.097: v3(235.59,114.97) 235.25,114.97 234.67,114.38 231.62,114.38 230.53,115.46 227.3,115.46 226.98,115.78 v2(226.41,115.78) 226.1,115.46 224.11,115.46 223.92,115.27 R2164.1 223.44,114.96 223.24,114.76 221.53,114.76 R2158.2
  BOTTOM w0.097: v3(235.59,114.97) G2.BM4
STRAP3: length 16.6
  TOP w0.097: v3(235.59,115.67) 235.31,115.4 235.3,115.4 234.54,114.63 231.74,114.63 230.69,115.69 227.75,115.69 227.28,116.16 v2(224.63,116.16) R2165.1 223.44,116.46 223.24,116.67 222.22,116.67 221.71,116.16 R2159.2
  BOTTOM w0.097: v3(235.59,115.67) G2.BM5
STRAP4: length 19
  TOP w0.097: v3(236.99,115.67) 236.55,116.11 235.49,116.11 234.27,114.89 231.87,114.89 230.85,115.91 228.06,115.91 226.8,117.17 v2(226.03,117.17) 225.52,116.67 224.51,116.67 223.74,117.43 R2166.1 222.9,116.89 222.06,116.89 221.84,116.67 221.41,116.67 R2160.2
  BOTTOM w0.097: v3(236.99,115.67) G2.BK5
STRAP5: length 19.9
  TOP w0.097: v3(237.69,115.67) 237.04,116.31 235.41,116.31 234.24,115.14 232,115.14 231.01,116.13 228.21,116.13 226.66,117.68 v2(224.51,117.68) 224.43,117.76 224,117.76 R2167.1 223.44,118.6 223.24,118.8 221.89,118.8 R2161.2
  BOTTOM w0.097: v3(237.69,115.67) G2.BJ5
SUSACK_N: length 3.8
  BOTTOM w0.097: U2.BB19 238.97,52.67 239.34,52.3 239.34,51.62 238.98,51.26 238.98,49.96 239.34,49.61 TP72.1
SUSCLK: length 22.1
  TOP w0.097: v3(241.78,56.85) 241.9,56.98 R148.1 ; v1(256.31,63.45) 256.43,63.58 R456.2
  IN05 w0.091: v1(256.31,63.45) 255.62,62.77 255.62,62.06 255.11,61.55 252.7,61.55 251.05,59.9 248.38,59.9 248.13,59.64 248.13,59.26 247.11,58.25 244.95,58.25 244.06,59.13 242.41,59.13 242.03,58.75 242.03,58.25 241.78,57.99 v3(241.78,56.85)
  BOTTOM w0.097: v3(241.78,56.85) 241.53,56.85 U2.AN15
SUSON: length 604.1
  TOP w0.097: PR425.2 208.27,111.18 v1(208.12,111.33) ; v1(205.2,150.45) 205.33,150.57 v2(205.33,151.26) PR1317.1 ; v1(21.69,68.41) 21.13,68.96 R496.1 ; v1(118.21,64.21) 118.71,64.72 PR1408.1 ; v2(28.67,48.49) 28.29,48.87 R258.2
  IN05 w0.091: v1(193.14,45.42) 193.93,46.22 212.55,46.22 212.87,45.89 214.52,45.89 215.35,45.06 224.53,45.06 225.25,44.34 228.9,44.34 229.45,43.79 233.77,43.79 236.05,41.51 249.93,41.51 254.39,45.96 264.89,45.96 266.76,47.83 272.13,47.83 274.38,45.58 276.79,45.58 279.33,43.04 290.1,43.04 290.51,42.62 293.72,42.62 294.99,41.35 296.9,41.35 297.53,40.72 297.53,40.59 301.59,36.53 301.59,36.27 303.12,34.75 303.37,34.75 v1(304.13,33.99) ; v2(28.67,48.49) 29.08,48.09 29.08,45.95 28.71,45.58 28.71,42.08 29.99,40.8 32.53,40.8 34.39,38.94 38.63,38.94 39.29,39.6 39.62,39.6 40.48,40.47 46.45,40.47 48.74,38.18 48.99,38.18 49.5,37.67 49.5,33.86 55.07,28.29 56.21,28.29 57.12,27.38 62.45,27.38 64.1,25.73 71.95,25.73 74.33,28.11 82.23,28.11 82.8,28.68 93.87,28.68 94.83,29.64 97.85,29.64 99.77,31.55 110.86,31.55 111.28,31.97 v1(114.65,31.97)
  IN08 w0.091: v1(206.09,60.15) 205.94,60 204.19,60 200.37,56.18 200.37,46.46 197.91,44 194.55,44 v1(193.14,45.42) 191.93,46.62 171.39,46.62 168.91,49.1 119.5,49.1 113.38,42.98 113.38,34.24 114.65,32.97 v1(114.65,31.97) ; v1(208.12,111.33) 208,111.2 200.25,111.2 193.52,117.94 193.52,123.78 199.36,129.62 199.36,144.61 v1(205.2,150.45) ; v2(28.67,48.49) 28.67,49.1 25.61,52.16 25.61,54.2 24.61,55.2 23.59,55.2 22.83,55.96 22.83,67.01 21.69,68.15 v1(21.69,68.41)
  IN10 w0.091: v1(118.21,64.21) 121.89,60.53 121.89,54.94 122.02,54.82 122.02,52.15 117.95,48.09 117.95,37.16 114.52,33.73 114.52,32.09 v1(114.65,31.97) ; v1(58.39,8.72) 57.96,8.29 50.94,8.29 49.75,9.48 49.75,9.99 47.85,11.89 46.83,11.89 45.72,13 45.72,17.19 44.04,18.88 44.04,19.38 40.74,22.69 34.77,22.69 33.5,23.96 31.85,23.96 30.83,24.97 30.83,37.67 28.67,39.83 28.67,45.29 28.16,45.8 28.16,47.98 v2(28.67,48.49)
  BOTTOM w0.076: 31.97,52.17 32.51,52.17 32.77,51.91 U5.E2
  BOTTOM w0.097: v1(304.13,33.99) 303.37,34.75 301.82,34.75 301.44,34.37 301.11,34.37 300.96,34.52 JIO1.47 ; 31.97,52.17 31.95,52.17 30.51,50.73 29.71,50.73 29.43,50.45 29.43,49.99 28.8,49.36 28.8,48.62 v2(28.67,48.49) ; v1(206.09,60.15) 206.09,64.6 210.2,68.71 210.2,83.72 209.27,84.66 207.87,84.66 205.07,87.46 205.07,95.2 206.09,96.22 206.09,101.68 206.37,101.96 207.58,101.96 208.12,102.51 208.12,106.76 209.62,108.25 209.62,110.47 208.76,111.33 v1(208.12,111.33) ; R873.1 58.34,8.77 v1(58.39,8.72)
SUSON_N: length 3.1
  TOP w0.097: PR1406.1 117.7,66.88 117.49,67.08 117.49,67.36 PQ1404.6 116.88,67.4 116.76,67.52 v2(116.76,67.62) 116.76,67.77 116.89,67.9 PQ1404.5
SUSPWRDNACK: length 3.2
  BOTTOM w0.097: TP73.1 239.01,49.23 239.01,49.66 238.78,49.88 238.78,51.45 U2.BD19
SW1_3PH_A: length 45
  TOP w0.254: v1(133.34,194.24) 133.4,194.29 PR1185.1 ; v1(125.7,200.99) 125.7,201.25 125,201.95 PR1145.2
  IN05 w0.203: v1(151.35,178.26) 151.07,177.98 150.77,177.98 150.57,178.18 150.57,180.01 149.98,180.6 141.14,180.6 132.18,189.56 132.18,191.98 132.43,192.23 132.43,193.37 133.29,194.24 v1(133.34,194.24)
  IN05 w0.254: v1(133.34,194.24) 133.34,194.36 131.29,196.42 129.51,196.42 128.24,197.69 127.73,197.69 126.72,198.71 126.72,199.98 v1(125.7,200.99)
  BOTTOM w0.254: PR1504.2 151.4,178.31 v1(151.35,178.26)
SW1_5V: length 1
  TOP w0.097: v2(40.41,12.02) 39.49,12.02 39.47,11.99
SW2_3PH_A: length 55.2
  IN03 w0.254: v1(130.99,199) 131.8,198.2 131.8,195.28 130.04,193.53 130.04,188.37 131.24,187.18 135.07,187.18 145.89,176.36 151.45,176.36 153.1,178.01 163.8,178.01 164.41,178.62 v1(164.41,178.64)
  BOTTOM w0.203: v1(164.41,178.64) 164.74,178.31 PR1513.2
  BOTTOM w0.254: v1(130.99,199) 131.34,198.66 PR1184.1 PR1149.2
SW2_3V:
  vias: v2(50.39,10.52)
SW3_3PH_A: length 88.5
  IN03 w0.254: v1(188.44,178.51) 188.44,178.26 188.18,178.01 186.84,178.01 184.86,176.03 184.86,171.83 184.05,171.02 151.61,171.02 148.56,174.07 143.86,174.07 133.19,184.74 131.41,184.74 131.16,184.48 130.19,184.48 129.1,185.58 129.1,197.03 129.64,197.56 129.64,198.45 v1(129.13,198.96)
  BOTTOM w0.203: v1(188.44,178.51) 188.64,178.31 PR1604.2
  BOTTOM w0.254: PR1183.1 PR1151.2 129.13,199.15 v1(129.13,198.96)
SW4_3PH_A: length 85.7
  TOP w0.254: PR1147.2 122.59,201.95 122.14,201.5 v1(122.14,200.99) ; v1(130.7,185.07) 130.65,185.12 PR1205.1
  IN03 w0.254: v1(176.37,178.51) 176.78,178.1 177.29,178.1 178.15,177.24 178.15,173.94 176.5,172.29 151.86,172.29 149.32,174.83 144.5,174.83 133.95,185.37 131.39,185.37 131.19,185.17 130.8,185.17 v1(130.7,185.07)
  IN05 w0.254: v1(122.14,200.99) 121.91,200.76 121.91,196.27 123.54,194.64 128.24,194.64 129,193.88 129,186.31 130.25,185.07 v1(130.7,185.07)
  BOTTOM w0.203: v1(176.37,178.51) 176.58,178.31 PR1612.2
SW_1PH: length 89.3
  TOP w0.254: PR1212.1 131.54,183.85 v1(131.74,183.65)
  IN03 w0.254: v1(131.74,183.65) 131.92,183.47 131.92,182.96 142.36,172.52 147.95,172.52 151.73,168.74 186.43,168.74 187.29,167.87 199.51,167.87 200.1,168.46 200.1,177.78 v1(199.36,178.51)
  BOTTOM w0.203: v1(199.36,178.51) 199.56,178.31 PR1618.2
  BOTTOM w0.254: v1(131.74,183.65) 130.79,183.65 PR1154.2
SWD_CLK: length 4.8
  TOP w0.089: R2092.1 29.81,72.47 v2(30.2,72.85) 30.32,72.72 32.35,72.72 v2(32.99,73.36)
  BOTTOM w0.089: v2(32.99,73.36) 33.25,73.62 U2007.G4
SWD_DAT: length 3.4
  TOP w0.089: v2(33.5,73.36) 33.36,73.23 33.36,73.2 33.14,72.98 33.12,72.98 32.48,72.34 v2(32.25,72.34) 31.77,72.34 R2091.1
  BOTTOM w0.089: v2(33.5,73.36) 33.75,73.61 U2007.F4
SWF_AVDD: length 12.2
  TOP w0.254: v1(278.86,50.12) 279.06,50.32 U9.7
  BOTTOM w0.356: C366.2 278.99,50.24 v1(278.86,50.12)
  BOTTOM w0.457: R329.1 282.79,46.13 R335.1 280.18,46.13 279.62,46.69 278.35,46.69 277.34,47.7 277.34,49.48 277.97,50.12 v2(278.07,50.12) v1(278.86,50.12)
SWF_CON_R+: length 4.6
  TOP w0.254: v2(294.48,50.88) 294.02,50.42 v1(293.85,50.42)
  TOP w0.508: v1(293.85,50.42) C377.2 292.34,50.42 R71.1
  BOTTOM w0.762: v1(293.85,50.42) 293.84,50.42 293.25,51.01 JSWF1.2
SWF_CON_R-: length 6
  TOP w0.254: v1(293.85,49.37) 294.09,49.37 v2(294.48,48.97)
  TOP w0.508: R70.1 292.34,49.56 C378.2 293.65,49.56 v1(293.85,49.37)
  BOTTOM w0.762: v1(293.85,49.37) 294.11,49.37 294.74,49.99 294.74,51.13 294.5,51.37 JSWF1.1
SWF_GAIN0: length 4.5
  TOP w0.254: U9.5 279.14,51.62 278.73,52.02 278.73,53.04 278.28,53.5 R345.2 R341.1
SWF_GAIN1: length 3.4
  TOP w0.254: U9.6 278.82,50.97 278.15,50.3 R348.2 R342.1
SWF_PLIMIT: length 3.9
  TOP w0.254: v1(278.86,48.21) 279.01,48.37 U9.10
  BOTTOM w0.254: v1(278.86,48.21) 279.5,47.58 R331.1 ; v1(278.86,48.21) 278.66,48.01 R332.2 ; v1(278.86,48.21) 279.12,48.47 C375.2
SWF_R+: length 9.1
  TOP w0.305: C374.1 288.18,51.51 v2(288.18,52.25) 288.2,52.27 U9.25 ; 287.37,51.34 287.07,51.34 286.69,50.97 U9.23
  TOP w0.457: 287.37,51.34 C374.1
  TOP w0.508: C374.1 288.56,51.34 289.48,50.42 R333.1 290.53,50.42 R71.2
SWF_R-: length 8.5
  TOP w0.305: C376.1 288.01,48.21 287.75,47.96 286.98,47.96 286.74,47.72 U9.18 ; 287.37,48.64 287.07,48.64 286.69,49.02 U9.20
  TOP w0.457: 287.37,48.64 C376.1
  TOP w0.508: R70.2 290.53,49.56 R334.1 289.35,49.56 288.44,48.64 C376.1
SWF_RINN: length 4.8
  TOP w0.305: v2(276.58,47.96) 277.85,47.96 278.15,47.65 279.12,47.65 279.18,47.72 U9.11
  TOP w0.635: C381.2 276.19,47.58 v2(276.58,47.96)
SWF_RINP: length 2.9
  TOP w0.254: U9.12 v2(278.3,47.07) 277.26,47.07 C384.2
SWF_SD_N: length 4.2
  TOP w0.254: U9.1 278.57,54.22 ; 278.57,54.22 278.57,53.83 278.84,53.57 U9.2 ; 278.57,54.22 278.35,54.44 R330.1
SWF_VCLAMP: length 3
  TOP w0.254: U9.9 279.07,49.02 v1(278.86,49.23)
  BOTTOM w0.254: C373.2 278.99,49.36 v1(278.86,49.23) 278.56,48.92 R332.1
SYS_PEX_RST_MON_N: length 130.1
  TOP w0.097: v3(240.13,112.63) 240.61,113.11 240.89,113.11 241.14,112.86 243.27,112.86 244.16,111.97 245.08,111.97 245.84,111.2 246.98,111.2 v1(247.62,110.57) 248.38,109.81 R999.2 ; R2171.1 300.2,73.49 299.44,74.25 v2(299.44,75.26) 300.07,75.9 301.48,75.9 v1(301.83,76.25) 301.99,76.41 302.86,76.41 303.12,76.15 U62.2
  IN10 w0.091: v1(301.83,76.25) 301.87,76.28 305.4,76.28 307.18,78.06 307.18,83.9 306.04,85.04 303.63,85.04 303.37,85.3 298.85,85.3 296.43,82.88 281.66,82.88 278.99,85.55 278.23,85.55 275.69,83.01 266.16,83.01 265.69,82.54 251.56,82.54 250.93,83.17 243.39,83.17 241.9,84.66 241.9,97.94 244.95,100.99 244.95,104.85 245.43,105.34 245.43,108.39 v1(247.62,110.57)
  BOTTOM w0.1: G2.BE2 240.79,113.72 240.44,113.37 240.44,113.17 240.38,113.11 240.38,112.88 v3(240.13,112.63)
SYS_PWROK: length 249.7
  TOP w0.089: 34.51,46.69 R263.2
  TOP w0.097: R146.1 248.58,53.85 v3(248.51,53.93) ; v1(37.31,41.61) 36.42,42.5 36.42,44.78 v2(34.61,46.59) 34.51,46.69
  IN03 w0.091: v1(37.31,41.61) 37.69,41.99 39.59,41.99 40.61,40.97 42.13,40.97 44.42,38.69 46.83,38.69 47.85,37.67 47.85,36.78 48.23,36.4 50.13,36.4 50.26,36.27 63.47,36.27 64.49,35.26 80.49,35.26 82.52,33.23 86.96,33.23 87.56,33.83 95.24,33.83 95.98,34.56 107.22,34.56 120.18,47.52 146.58,47.52 152.37,41.74 152.37,39.58 v1(153.13,38.81)
  IN10 w0.091: v3(248.51,53.93) 249.05,53.39 249.05,50.44 247.58,48.97 245.59,48.97 244.57,47.96 242.92,47.96 242.29,47.32 242.29,46.05 238.35,42.12 216.43,42.12 212.67,45.89 206.26,45.89 203,42.62 155.67,42.62 153.64,40.59 153.64,39.32 v1(153.13,38.81)
  BOTTOM w0.097: v3(248.51,53.93) 248.22,53.93 U2.AY1
SYS_PWROK_R: length 2
  TOP w0.089: R263.1 34.22,50.11 v2(34.22,50.88)
  BOTTOM w0.089: U5.D6 34.63,51.41 34.22,50.99 v2(34.22,50.88)
SYS_RESET_N: length 5.5
  TOP w0.097: R143.1 v3(250.54,51.64)
  BOTTOM w0.097: R143.1 v3(250.54,51.64) 249.27,52.91 249.27,53.72 248.68,54.31 248.04,54.31 U2.AW1
TBT_BATLOW_N: length 4.6
  TOP w0.097: v2(47.85,92.79) 47.98,92.79 48.48,93.3 48.48,93.81 48.74,94.06 R2036.1
  BOTTOM w0.076: 48.36,91.58 48.36,90.89 U2005.F2
  BOTTOM w0.102: v2(47.85,92.79) 48.36,92.27 48.36,91.58
TBT_CIO_PLUG_EVENT_N: length 204.4
  TOP w0.097: v1(56.27,96.54) 56.03,96.3 R2031.1
  IN03 w0.091: v3(224.12,67.14) 222.6,65.61 221.08,65.61 217.9,62.44 214.6,62.44 210.15,66.88 129.51,66.88 127.6,68.79 119.35,68.79 118.46,69.68 115.67,69.68 114.27,71.07 103.86,71.07 103.22,70.44 89.12,70.44 85.82,67.14 81.38,67.14 78.46,70.06 73.88,70.06 73.12,70.82 68.8,70.82 68.42,71.2 67.03,71.2 v1(66.39,70.56)
  IN08 w0.091: v1(66.39,70.56) 65.5,71.45 65.5,74.88 62.07,78.31 62.07,84.66 60.17,86.57 60.17,92.79 60.8,93.42 60.8,95.96 60.55,96.22 56.59,96.22 v1(56.27,96.54)
  BOTTOM w0.097: v3(224.12,67.14) 224.51,67.14 224.89,67.52 225.65,67.52 226.26,68.13 227.05,68.13 U2.L43
TBT_CIO_PLUG_EVENT_N_R: length 8.3
  TOP w0.097: v1(55.98,94.44) 56.94,95.41 R2031.2
  BOTTOM w0.076: U2005.W2 54.35,90.89 54.35,91.29 55.62,92.56
  BOTTOM w0.097: R2053.1 55.98,94.62 v1(55.98,94.44)
  BOTTOM w0.102: 55.62,92.56 v2(55.62,92.84) 55.6,92.87 55.6,94.06 v1(55.98,94.44)
TBT_CIO_PWR_EN: length 204.2
  TOP w0.097: R2041.2 63.42,93.88 64.05,94.52 v1(64.23,94.52)
  IN03 w0.091: v3(231.62,65.61) 231.11,65.1 228.17,65.1 227.91,65.36 225.65,65.36 224.38,64.09 220.19,64.09 218.16,62.06 214.6,62.06 210.03,66.63 129.43,66.63 127.52,68.53 119.22,68.53 118.32,69.43 115.4,69.43 115.16,69.68 111.58,69.68 110.56,70.69 106.34,70.69 105.7,70.06 89.12,70.06 85.95,66.88 81.25,66.88 79.6,68.53 78.2,68.53 77.95,68.28 75.03,68.28 72.74,70.56 v1(67.15,70.56)
  IN08 w0.091: v1(64.23,94.52) 64.18,94.52 64.1,94.44 62.45,94.44 60.93,92.92 60.93,89.49 61.18,89.23 61.18,88.47 60.68,87.96 60.68,86.44 62.45,84.66 62.45,79.07 66.26,75.26 66.26,71.45 v1(67.15,70.56)
  BOTTOM w0.097: v3(231.62,65.61) 231.62,66.05 U2.R35
TBT_EE_CLK: length 56.1
  IN03 w0.091: v2(57.12,89.74) 57.5,90.12 58.9,90.12 59.15,90.38 59.15,94.82 58.26,95.71 56.48,95.71 55.21,96.98 52.67,96.98 v1(50.52,99.14)
  IN08 w0.091: v2(39.16,69.85) 39.14,69.88 39.14,70.64 38.58,71.2 38.58,75.14 39.09,75.64 39.21,75.64 42.39,78.82 42.39,79.84 43.78,81.23 55.34,81.23 57.12,83.01 v2(57.12,89.74)
  BOTTOM w0.076: 56.54,89.51 55.72,89.51 U2005.AB4
  BOTTOM w0.097: U2012.6 v1(50.52,99.14) ; 56.54,89.51 56.77,89.74 v2(57.12,89.74) ; v2(39.16,69.85) 39.16,69.88 39.59,70.31 39.59,70.77 R2287.1
TBT_EE_CS_N: length 56.2
  TOP w0.097: v1(52.04,94.95) 53.06,95.96 R2019.1
  IN03 w0.091: v1(52.04,94.95) 52.04,95.2 53.06,96.22 54.65,96.22 55.47,95.4 55.47,93.3 56.74,92.03 56.74,90.88 v2(57.12,90.5)
  IN08 w0.091: v2(37.84,68.51) 38.42,68.51 39.59,69.68 39.59,70.95 38.83,71.71 38.83,74.76 43.07,79 43.07,79.96 44.09,80.98 55.72,80.98 57.47,82.73 57.47,90.15 v2(57.12,90.5)
  BOTTOM w0.076: 56.5,90.2 U2005.AC3
  BOTTOM w0.089: 56.76,90.46 56.5,90.2
  BOTTOM w0.097: v2(37.84,68.51) 39.31,68.51 39.54,68.74 R2290.1 ; U2012.1 53.06,93.93 v1(52.04,94.95) ; 56.76,90.46 56.81,90.5 v2(57.12,90.5)
TBT_EE_DI: length 61.7
  IN03 w0.091: v1(49.25,99.14) 51.66,96.73 54.96,96.73 56.23,95.46 58.01,95.46 58.77,94.69 58.77,92.15 v2(57.88,91.27)
  IN08 w0.091: v2(40.74,68.91) 40.36,69.29 40.36,73.1 40.74,73.49 40.74,75.52 43.78,78.57 44.17,78.57 44.42,78.82 56.48,78.82 59.66,81.99 59.66,84.79 58.64,85.8 58.64,90.88 58.26,91.27 v2(57.88,91.27)
  BOTTOM w0.076: U2005.AB3 55.63,90.2 55.86,90.43 56.41,90.43 56.76,90.78
  BOTTOM w0.097: v2(57.88,91.27) 57.5,90.88 56.87,90.88 56.76,90.78 ; U2012.5 v1(49.25,99.14) ; R2288.1 40.05,71.71 40.74,71.02 v2(40.74,70.44) v2(40.74,68.91)
TBT_EE_DO: length 53.7
  TOP w0.097: R2018.1 52.17,96.09 v1(51.53,95.46)
  IN03 w0.091: v2(57.88,90.5) 57.5,90.88 57.5,92.28 58.14,92.92 58.14,94.69 57.88,94.95 56.36,94.95 54.83,96.47 52.8,96.47 51.79,95.46 v1(51.53,95.46)
  IN08 w0.091: v2(57.88,90.5) 58.26,90.12 58.26,81.23 56.36,79.33 44.42,79.33 44.05,78.96 43.67,78.96 39.47,74.76 v2(39.47,73.36)
  BOTTOM w0.076: 56.61,89.87 56.48,89.74 U2005.AC4
  BOTTOM w0.089: 56.76,90.02 56.61,89.87
  BOTTOM w0.097: v1(51.53,95.46) 51.53,94.44 51.79,94.19 U2012.2 ; v2(57.88,90.5) 57.55,90.17 56.92,90.17 56.76,90.02 ; v2(39.47,73.36) 40.36,73.36 v2(40.74,72.98) 40.36,72.6 R2289.1
TBT_EE_WP_N: length 15.1
  TOP w0.097: R2017.1 51.28,96.22 v1(51.15,96.09)
  IN03 w0.091: v2(53.94,92.15) 55.21,93.42 55.21,95.33 54.88,95.66 54.02,95.66 53.82,95.46 53.82,95.33 52.93,94.44 51.66,94.44 51.02,95.08 51.02,95.96 v1(51.15,96.09)
  BOTTOM w0.076: 53.94,92.05 53.94,91.8 53.66,91.51 U2005.V1
  BOTTOM w0.097: v2(53.94,92.15) 53.94,92.05 ; U2012.3 50.52,95.46 v1(51.15,96.09)
TBT_FORCE_PWR: length 241.6
  TOP w0.089: R2097.1 27.86,80.67 v1(27.66,80.47)
  TOP w0.097: v1(24.99,86.19) 24.28,86.9 R2039.2
  IN03 w0.089: 27.4,80.72 v1(27.66,80.47)
  IN03 w0.091: v1(24.99,86.19) 24.99,85.17 26.64,83.52 26.64,81.49 27.4,80.72 ; v1(26.39,67.64) 30.83,63.2 43.66,63.2 45.31,64.85 50.26,64.85 52.42,62.69 55.6,62.69 59.91,67.01 74.39,67.01 75.41,68.02 78.2,68.02 78.84,67.39 80.23,67.39 81.12,66.5 86.08,66.5 89.24,69.66 105.62,69.66 106.4,70.44 110.46,70.44 111.48,69.42 114.95,69.42 115.16,69.21 117.91,69.21 119.6,67.52 127.35,67.52 128.49,66.37 209.9,66.37 214.47,61.8 218.28,61.8 220.31,63.83 224.51,63.83 225.78,65.1 227.81,65.1 228.06,64.85 231.24,64.85 v3(231.62,64.47)
  IN08 w0.089: v1(27.66,80.47) 27.91,80.22 27.91,71.07 26.97,70.13
  IN08 w0.091: v1(26.39,67.64) 26.39,69.55 26.97,70.13
  BOTTOM w0.097: U2.U35 231.62,64.94 v3(231.62,64.47)
TBT_FORCE_PWR_R: length 28
  TOP w0.097: R2039.1 R2040.1 v1(25.19,88.93)
  IN05 w0.089: v2(48.62,89.63) 48.62,90.49 48.23,90.88 44.92,90.88 44.92,90.89 44.9,90.89
  IN05 w0.091: v1(25.19,88.93) 36.11,88.93 38.58,91.39 44.29,91.39 44.8,90.89 44.9,90.89
  BOTTOM w0.178: v2(48.62,89.63) 48.95,89.96 U2005.H4
TBT_HDMI_DDC_CLK: length 6.5
  BOTTOM w0.076: 55.76,92.19 54.8,91.24 54.8,90.89 U2005.Y2
  BOTTOM w0.097: R2283.1 57.63,93.73 57.63,94.19 v1(57.37,94.44) 56.74,93.81 v2(56.74,93.68) 56.74,93.17 56.1,92.54
  BOTTOM w0.102: 56.1,92.54 55.76,92.19
TBT_HDMI_DDC_DATA: length 7.5
  BOTTOM w0.076: U2005.Y1 54.58,91.26 56.03,92.71
  BOTTOM w0.097: 56.03,92.92 56.03,93.86 v1(56.61,94.44) 56.61,94.82 v2(57.37,95.58) 58.19,94.77 R2284.1
  BOTTOM w0.102: 56.03,92.92 56.03,92.71
TBT_HOLD_N: length 2.2
  TOP w0.097: v1(51.79,99.14) 51.96,99.32 R2020.1
  BOTTOM w0.097: U2012.7 v1(51.79,99.14)
TBT_I2C_SCL: length 51.3
  TOP w0.097: v1(54.71,95.13) 55.16,95.58 R2028.1
  IN03 w0.089: 37.94,80.72 37.82,80.6 37.82,73.64 36.77,72.6 35.91,72.6 35.02,71.71 35.02,70.69 v2(34.64,70.31)
  IN03 w0.091: 37.94,80.72 41.12,83.9 41.12,86.19 39.72,87.58 39.72,93.04 40.48,93.81 46.07,93.81 46.45,94.19 53.94,94.19 54.25,94.49 54.25,94.67 v1(54.71,95.13)
  BOTTOM w0.076: 35,71.83 35,72.63 U2007.D2 ; U2005.U2 53.42,90.89 53.42,91.29
  BOTTOM w0.102: 53.42,91.29 53.42,91.61 53.56,91.75 53.56,92.33 54.2,92.97 54.2,94.06 54.26,94.13 54.26,94.68 v1(54.71,95.13) ; v2(34.64,70.31) 35.08,70.76 35.08,71.74 35,71.83
TBT_I2C_SDA: length 47
  TOP w0.102: v3(53.18,91.9) 52.93,92.15 R2026.1
  IN03 w0.089: v2(33.99,70.31) 34.33,69.97 34.78,69.97 35.28,70.47 35.28,71.58 36.04,72.34 37.84,72.34 38.4,72.9 ; 38.4,73.79 38.07,74.12 38.07,80.34 38.36,80.64
  IN03 w0.091: 38.4,73.79 38.45,73.74 38.45,72.95 38.4,72.9 ; v3(53.18,91.9) 52.67,92.41 50.62,92.41 49.09,93.93 47.21,93.93 46.58,93.3 40.61,93.3 40.23,92.92 40.23,87.58 41.37,86.44 41.37,83.65 38.36,80.64
  BOTTOM w0.076: 34.67,70.93 34.89,71.16 34.89,71.58 34.77,71.71
  BOTTOM w0.089: 34.77,71.71 34.75,71.72 U2007.D1
  BOTTOM w0.102: 34.67,70.93 34.62,70.93 34.01,70.31 v2(33.99,70.31) ; v3(53.18,91.9) 53.2,91.89 U2005.U1
TBT_PROC_GPIO1: length 24.8
  TOP w0.097: v1(61.82,95.46) 61.82,95.38 R2024.1
  IN03 w0.089: 54.83,91.52 50.13,91.52 49.6,92.05
  IN03 w0.091: 49.6,92.05 48.48,93.17 47.59,93.17 v2(47.21,92.79) ; 54.83,91.52 55.47,91.52 55.85,91.14 55.85,90.12 56.74,89.23 58.52,89.23 60.68,91.39 60.68,92.66 61.06,93.04 61.06,94.69 v1(61.82,95.46)
  BOTTOM w0.076: 47.54,91.7 47.9,91.34 47.9,90.89 U2005.E2
  BOTTOM w0.102: 47.54,91.7 47.54,92.46 v2(47.21,92.79)
TBT_RBIAS: length 1.1
  TOP w0.254: v2(48.62,88.98) 48.62,88.98 R2035.2
  BOTTOM w0.178: v2(48.62,88.98) 48.95,88.66 U2005.H6
TBT_RESET_N: length 17.4
  TOP w0.097: R2030.2 v1(26.13,87.96)
  IN10 w0.089: 33.12,80.72 33.12,80.14 33.73,79.53 v2(34.08,79.53)
  IN10 w0.091: 33.12,80.72 33.12,84.03 28.42,88.73 26.89,88.73 v1(26.13,87.96)
  BOTTOM w0.089: U2007.F11 33.75,78.29 34.08,78.62 v2(34.08,79.53)
TBT_RESET_N_R: length 22.2
  TOP w0.097: R2030.1 v1(28.54,87.96)
  IN05 w0.089: 44.9,90.63 44.92,90.63 44.92,90.63 47.57,90.63 v2(47.97,90.23)
  IN05 w0.091: 44.9,90.63 44.67,90.63 44.17,91.14 38.7,91.14 35.53,87.96 v1(28.54,87.96)
  BOTTOM w0.178: U2005.F4 48.02,90.23 v2(47.97,90.23)
