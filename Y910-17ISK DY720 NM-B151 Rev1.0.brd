# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ38: length 70
  TOP w0.102: JDIMM2.187 179.4,80.2 179.66,80.46 180.1,80.46 181.81,82.17 181.81,83.22 v3(181.39,83.65)
  IN03 w0.076: v1(176.37,131.16) 175.56,130.34 175.56,127.59 179.37,123.78 179.62,123.78
  IN03 w0.13: 179.62,123.78 182.26,121.14 182.98,121.14 184.45,119.66 184.45,107.82 184.27,107.64 183.94,107.64 183.81,107.51 183.81,107.25 183.94,107.12 184.27,107.12 184.4,106.99 184.4,106.73 184.27,106.6 183.94,106.6 183.81,106.47 183.81,106.21 183.94,106.09 184.27,106.09 184.4,105.96 184.4,105.7 184.27,105.57 183.94,105.57 183.81,105.44 183.81,105.18 183.94,105.05 184.27,105.05 184.4,104.92 184.4,104.66 184.27,104.53 183.92,104.53 183.79,104.4 183.79,104.14 183.92,104.02 184.27,104.02 184.4,103.89 184.4,103.48 183.81,102.9 183.81,96.68 180.97,93.84 180.97,91.02 181.1,90.89 181.35,90.89 181.48,90.76 181.48,90.5 181.35,90.37 181.1,90.37 180.97,90.24 180.97,83.95 181.27,83.65 v3(181.39,83.65)
  BOTTOM w0.076: U1.AA2 176.05,131.47 176.25,131.27 v1(176.37,131.16)
  BOTTOM w0.102: v3(181.39,83.65) 181.39,83.55 181.26,83.42 180.98,83.42 180.85,83.55 180.85,85.24 180.98,85.37 181.47,85.37 181.6,85.49 181.6,85.91 181.47,86.04 181.3,86.04 181.07,86.27 JDIMM1.187
M_A_DQ39: length 70.2
  TOP w0.102: JDIMM2.186 179.15,86.62 180.2,85.57 180.2,85.34 180.3,85.24 180.41,85.24 180.51,85.14 180.51,84.93 180.41,84.83 180.3,84.83 180.2,84.73 180.2,84.43 180.33,84.31 180.86,84.31 180.98,84.43 180.98,84.8 181.08,84.91 v1(181.39,84.91)
  IN03 w0.076: v1(176.37,130.52) 175.79,129.94 175.79,127.68 179.41,124.06 179.72,124.06
  IN03 w0.13: 179.72,124.06 182.32,121.47 183.2,121.47 184.88,119.79 184.88,102.8 184.75,102.67 184.5,102.67 184.37,102.54 184.37,102.28 184.5,102.15 184.75,102.15 184.88,102.02 184.88,101.76 184.75,101.64 184.3,101.64 184.23,101.57 184.17,101.51 184.17,101.24 184.3,101.12 184.75,101.12 184.88,100.99 184.88,100.73 184.75,100.6 184.3,100.6 184.17,100.47 184.17,100.21 184.3,100.08 184.75,100.08 184.88,99.95 184.88,99.69 184.75,99.56 184.3,99.56 184.17,99.44 184.17,99.18 184.3,99.05 184.73,99.05 184.86,98.92 184.86,98.66 184.73,98.53 184.3,98.53 184.17,98.4 184.17,98.15 184.3,98.02 184.7,98.02 184.83,97.89 184.83,97.63 184.7,97.5 184.3,97.5 184.17,97.37 184.17,96.53 181.81,94.17 181.81,92.05 181.68,91.92 181.43,91.92 181.3,91.8 181.3,91.53 181.43,91.41 181.68,91.41 181.81,91.28 181.81,88.81 181.3,88.3 181.3,84.99 v1(181.39,84.91)
  BOTTOM w0.076: v1(176.37,130.52) 176.05,130.82 U1.AA1
  BOTTOM w0.102: JDIMM1.186 180.82,81.23 181.79,82.21 181.79,84.45 181.39,84.86 v1(181.39,84.91)
M_A_DQ40: length 72.6
  TOP w0.102: v1(183.29,82.38) 182.56,83.11 182.56,84.31 180.15,86.72 JDIMM2.190
  IN03 w0.076: v1(176.37,129.25) 176,128.88 176,127.71 179.4,124.32 179.8,124.32
  IN03 w0.13: v1(183.29,82.38) 183.29,82.17 183.17,82.05 182.33,82.05 182.21,82.17 182.21,93.52 185.67,96.98 185.67,119.51 183.46,121.72 182.43,121.72 179.83,124.32 179.8,124.32
  BOTTOM w0.076: U1.V5 177.09,132.8 177.09,129.97 v1(176.37,129.25)
  BOTTOM w0.102: v1(183.29,82.38) 183.01,82.38 182.89,82.5 182.89,82.88 182.78,82.99 182.64,82.99 182.53,82.88 182.53,81.99 182.66,81.87 182.8,81.87 182.93,81.74 182.93,81.54 182.8,81.41 182.39,81.41 182.26,81.28 182.26,81.05 182.39,80.93 182.6,80.93 182.72,80.8 182.72,80.62 182.6,80.5 182.14,80.5 181.82,80.17 JDIMM1.190
M_A_DQ41: length 73.7
  TOP w0.102: JDIMM2.191 180.4,80.17 180.66,80.43 181.12,80.43 181.64,80.95 182.5,80.95 183.72,82.17 183.72,84.49 v1(183.29,84.92)
  IN03 w0.076: v1(177.27,127.72) 177.27,126.93 179.47,124.73 179.67,124.73
  IN03 w0.13: 179.67,124.73 180.1,124.73 182.61,122.23 183.97,122.23 186.84,119.36 186.84,112.79 186.71,112.66 186.53,112.66 186.4,112.54 186.4,112.27 186.53,112.15 186.71,112.15 186.84,112.02 186.84,111.72 186.71,111.6 186.54,111.6 186.41,111.47 186.41,111.21 186.54,111.08 186.71,111.08 186.84,110.95 186.84,110.69 186.71,110.56 186.54,110.56 186.41,110.43 186.41,110.17 186.54,110.04 186.71,110.04 186.84,109.91 186.84,109.65 186.71,109.52 186.54,109.52 186.41,109.39 186.41,109.13 186.54,109 186.71,109 186.84,108.87 186.84,108.62 186.71,108.49 186.54,108.49 186.41,108.36 186.41,108.1 186.54,107.97 186.73,107.97 186.86,107.84 186.86,107.58 186.73,107.45 186.54,107.45 186.41,107.32 186.41,107.06 186.54,106.93 186.73,106.93 186.86,106.8 186.86,106.54 186.73,106.41 186.54,106.41 186.41,106.28 186.41,106.03 186.54,105.9 186.73,105.9 186.86,105.77 186.86,105.51 186.73,105.38 186.54,105.38 186.41,105.25 186.41,96.71 182.87,93.17 182.87,85.04 183,84.92 v1(183.29,84.92)
  BOTTOM w0.076: v1(177.27,127.72) 177.3,127.72 177.43,127.84 177.43,130.96 177.43,130.96 177.43,131.19 U1.V2
  BOTTOM w0.102: JDIMM1.191 182.07,86.78 182.43,86.42 182.65,86.42 182.76,86.3 182.76,86.13 182.65,86.01 182.46,86.01 182.34,85.89 182.34,85.73 182.46,85.61 182.83,85.61 182.95,85.49 182.95,85.29 182.86,85.2 182.66,85.2 182.53,85.07 182.53,83.42 182.64,83.32 182.78,83.32 182.89,83.42 182.89,84.76 183.04,84.92 v1(183.29,84.92)
M_A_DQ42: length 73.1
  TOP w0.102: v1(186.6,84.92) 187,84.51 187,82.21 186.76,81.97 185.95,81.97 184.4,80.42 JDIMM2.207
  IN03 w0.076: 183.2,124.16 178.46,128.9 178.46,130.11 v1(178.89,130.54)
  IN03 w0.13: v1(186.6,84.92) 186.37,85.14 186.37,88.16 187.02,88.81 187.02,91.59 186.89,91.72 186.55,91.72 186.42,91.85 186.42,92.11 186.55,92.24 186.89,92.24 187.02,92.37 187.02,93.4 191.23,97.62 191.23,97.97 191.1,98.1 191.03,98.1 190.9,98.23 190.9,98.49 191.03,98.62 191.1,98.62 191.23,98.75 191.23,99.01 191.1,99.14 191.03,99.14 190.9,99.27 190.9,99.53 191.03,99.65 191.1,99.65 191.23,99.78 191.23,100.04 191.1,100.17 191.03,100.17 190.9,100.3 190.9,100.56 191.03,100.69 191.1,100.69 191.23,100.82 191.23,101.08 191.1,101.21 191.03,101.21 190.9,101.34 190.9,101.6 191.03,101.73 191.1,101.73 191.23,101.86 191.23,102.12 191.1,102.25 191.03,102.25 190.9,102.38 190.9,102.63 191.03,102.76 191.1,102.76 191.23,102.89 191.23,103.15 191.1,103.28 191.03,103.28 190.9,103.41 190.9,103.67 191.03,103.8 191.1,103.8 191.23,103.93 191.23,104.19 191.1,104.32 191.03,104.32 190.9,104.45 190.9,104.71 191.03,104.84 191.1,104.84 191.23,104.97 191.23,115.55 190.48,116.3 190.48,119.45 185.77,124.16 183.2,124.16
  BOTTOM w0.102: JDIMM1.207 186.07,86.78 185.43,86.13 185.19,86.13 185.06,86.01 185.06,85.83 185.19,85.7 185.6,85.7 185.72,85.58 185.72,85.41 185.6,85.29 185.44,85.29 185.34,85.19 185.34,85.05 185.44,84.95 185.95,84.95 186.05,84.85 186.05,84.7 185.95,84.6 185.44,84.6 185.35,84.51 185.35,84.37 185.44,84.28 186.02,84.28 186.6,84.86 v1(186.6,84.92)
  BOTTOM w0.14: v1(178.89,130.54) 178.56,130.82 U1.U1
M_A_DQ43: length 70.8
  TOP w0.102: JDIMM2.208 184.65,86.46 185.96,85.15 185.96,83.72 186.09,83.59 186.54,83.59 v1(186.6,83.65)
  IN03 w0.076: 183.17,123.9 178.21,128.86 178.21,130.5 v1(178.89,131.17)
  IN03 w0.13: v1(186.6,83.65) 186.25,83.65 186.04,83.86 186.04,90.56 186.17,90.69 186.56,90.69 186.68,90.81 186.68,91.08 186.56,91.2 186.22,91.2 186.04,91.38 186.04,92.93 190.55,97.44 190.55,106.2 190.67,106.33 190.74,106.33 190.87,106.46 190.87,106.72 190.74,106.85 190.67,106.85 190.55,106.98 190.55,107.24 190.67,107.37 190.74,107.37 190.87,107.49 190.87,107.75 190.74,107.88 190.67,107.88 190.55,108.01 190.55,108.27 190.67,108.4 190.74,108.4 190.87,108.53 190.87,108.79 190.74,108.92 190.67,108.92 190.55,109.05 190.55,109.31 190.67,109.44 190.74,109.44 190.87,109.57 190.87,109.83 190.74,109.96 190.67,109.96 190.55,110.09 190.55,110.34 190.67,110.47 190.74,110.47 190.87,110.6 190.87,110.86 190.74,110.99 190.67,110.99 190.55,111.12 190.55,111.38 190.67,111.51 190.74,111.51 190.87,111.64 190.87,111.9 190.74,112.03 190.67,112.03 190.55,112.16 190.55,112.42 190.67,112.55 190.74,112.55 190.87,112.68 190.87,112.94 190.74,113.07 190.67,113.07 190.55,113.19 190.55,115.6 190.01,116.13 190.01,119.41 185.52,123.9 183.17,123.9
  BOTTOM w0.102: JDIMM1.208 186.32,80.17 187.46,81.31 187.46,82.73 186.6,83.59 v1(186.6,83.65)
  BOTTOM w0.14: U1.U2 178.56,131.47 v1(178.89,131.17)
M_A_DQ44: length 72.4
  TOP w0.102: v1(184.94,81.99) 184.71,82.23 184.32,82.23 183.74,81.64 183.74,81.5 184.03,81.21 184.03,81.04 183.91,80.92 183.75,80.92 183.45,81.21 183.31,81.21 182.74,80.64 181.76,80.64 181.4,80.28 JDIMM2.195
  IN03 w0.076: v1(177.72,127.27) 177.72,126.75 179.53,124.94 179.63,124.94
  IN03 w0.13: 179.63,124.94 180.24,124.94 182.7,122.48 184.22,122.48 187.22,119.49 187.22,105.02 187.09,104.89 186.9,104.89 186.77,104.76 186.77,104.5 186.9,104.38 187.09,104.38 187.22,104.25 187.22,103.99 187.09,103.86 186.9,103.86 186.77,103.73 186.77,103.47 186.9,103.34 187.09,103.34 187.22,103.21 187.22,102.95 187.09,102.82 186.9,102.82 186.77,102.69 186.77,102.43 186.9,102.3 187.09,102.3 187.22,102.17 187.22,101.91 187.09,101.78 186.9,101.78 186.77,101.66 186.77,101.4 186.9,101.27 187.09,101.27 187.22,101.14 187.22,100.88 187.09,100.75 186.9,100.75 186.77,100.62 186.77,100.36 186.9,100.23 187.09,100.23 187.22,100.1 187.22,99.84 187.09,99.71 186.9,99.71 186.77,99.58 186.77,99.32 186.9,99.19 187.09,99.19 187.22,99.06 187.22,97.01 183.71,93.51 183.71,83.23 v1(184.94,81.99)
  BOTTOM w0.076: U1.V1 177.71,127.28 v1(177.72,127.27)
  BOTTOM w0.102: JDIMM1.195 183.07,85.8 183.84,85.02 183.84,83.69 184.14,83.39 184.14,82.8 v1(184.94,81.99)
M_A_DQ45: length 70.7
  TOP w0.102: v1(183.29,83.65) 182.86,84.08 182.86,84.44 181.15,86.15 JDIMM2.194
  IN03 w0.076: 179.65,124.53 179.43,124.53 176.37,127.59 v1(176.37,128.62)
  IN03 w0.13: v1(183.29,83.65) 182.94,83.29 182.67,83.29 182.54,83.42 182.54,83.87 182.67,84 182.75,84 182.87,84.13 182.87,84.43 182.75,84.56 182.6,84.56 182.54,84.62 182.54,93.35 186.05,96.85 186.05,113.24 186.18,113.37 186.34,113.37 186.47,113.5 186.47,113.76 186.34,113.89 186.17,113.89 186.04,114.02 186.04,114.28 186.17,114.41 186.34,114.41 186.47,114.54 186.47,114.8 186.34,114.93 186.17,114.93 186.04,115.06 186.04,115.32 186.17,115.45 186.34,115.45 186.47,115.57 186.47,115.83 186.34,115.96 186.17,115.96 186.04,116.09 186.04,116.35 186.17,116.48 186.34,116.48 186.47,116.61 186.47,116.87 186.34,117 186.18,117 186.05,117.13 186.05,117.36 186.18,117.49 186.28,117.49 186.41,117.62 186.41,117.88 186.28,118.01 186.18,118.01 186.05,118.14 186.05,118.4 186.18,118.53 186.28,118.53 186.41,118.66 186.41,118.91 186.28,119.04 186.18,119.04 186.05,119.17 186.05,119.64 183.71,121.97 182.52,121.97 179.97,124.53 179.65,124.53
  BOTTOM w0.076: U1.V4 177.27,132.33 177.27,130.9 177.27,130.9 177.27,129.84 177.08,129.65 177.08,128.8 176.9,128.62 v1(176.37,128.62)
  BOTTOM w0.102: v1(183.29,83.65) 183.7,83.24 183.7,81.68 183.18,81.16 183.18,80.53 182.82,80.17 JDIMM1.194
M_A_DQ46: length 72.6
  TOP w0.102: JDIMM2.203 183.4,80.21 183.68,80.49 184.05,80.49 185.35,81.8 185.35,84.76 v1(184.94,85.17)
  IN03 w0.076: 182.32,124.17 177.67,128.82 177.67,131.87 v1(178.89,133.09)
  IN03 w0.13: v1(184.94,85.17) 185.14,85.17 185.36,85.4 185.36,86.74 185.24,86.87 185.03,86.87 184.91,87 184.91,87.26 185.03,87.39 185.24,87.39 185.36,87.52 185.36,87.78 185.24,87.91 185.03,87.91 184.91,88.04 184.91,88.3 185.03,88.43 185.24,88.43 185.36,88.56 185.36,93.27 189.44,97.34 189.44,113.31 189.22,113.52 189.22,113.83 189.44,114.04 189.44,114.35 189.22,114.56 189.22,114.86 189.44,115.08 189.44,115.31 189.2,115.55 189.2,119.21 184.98,123.42 183.07,123.42 182.32,124.17
  BOTTOM w0.102: JDIMM1.203 185.07,86.52 184.97,86.42 183.54,86.42 183.43,86.3 183.43,86.13 183.54,86.01 184.66,86.01 184.76,85.91 184.76,85.76 184.66,85.66 184.27,85.66 184.16,85.56 184.16,84.8 184.29,84.68 184.44,84.68 v1(184.94,85.17)
  BOTTOM w0.14: v1(178.89,133.09) 178.56,133.42 U1.U5
M_A_DQ47: length 72.4
  TOP w0.102: v1(186.6,82.38) 185.66,83.32 185.66,85.03 185.11,85.58 184.86,85.58 183.65,86.78 JDIMM2.204
  IN03 w0.076: 183.13,123.65 177.95,128.83 177.95,131.5 v1(178.89,132.44)
  IN03 w0.13: v1(186.6,82.38) 186.6,82.39 185.71,83.28 185.71,93.1 189.8,97.19 189.8,115.59 189.63,115.75 189.63,119.28 185.26,123.65 183.13,123.65
  BOTTOM w0.102: JDIMM1.204 185.32,80.41 185.62,80.71 185.76,80.71 185.92,80.55 186.06,80.55 186.18,80.67 186.18,80.85 186.04,80.99 186.04,81.17 186.21,81.34 186.39,81.34 186.63,81.1 186.81,81.1 186.97,81.25 186.97,81.43 186.89,81.51 186.71,81.51 186.59,81.62 186.59,81.8 186.72,81.93 187.02,81.93 187.15,82.06 187.15,82.5 187.02,82.62 186.72,82.62 186.6,82.5 v1(186.6,82.38)
  BOTTOM w0.14: v1(178.89,132.44) 178.56,132.77 U1.U4
M_A_DQ48: length 78.5
  TOP w0.102: v1(188.5,84.92) 189.23,84.19 189.23,82.09 188.61,81.47 187.7,81.47 186.4,80.17 JDIMM2.215
  IN03 w0.076: 183.23,124.97 180.68,127.52 v1(180.68,128.06)
  IN03 w0.13: 183.23,124.97 183.3,124.9 186.56,124.9 188.64,122.81 189.3,122.81 191.66,120.45 191.66,117.86 193.39,116.13 193.39,109.73 193.06,109.39 192.88,109.39 192.76,109.27 192.76,109 192.88,108.88 193.06,108.88 193.19,108.75 193.19,108.52 193.06,108.39 192.89,108.39 192.76,108.26 192.76,108 192.89,107.87 193.06,107.87 193.19,107.74 193.19,107.48 193.06,107.35 192.89,107.35 192.76,107.22 192.76,106.96 192.89,106.83 193.06,106.83 193.19,106.7 193.19,106.44 193.06,106.31 192.88,106.31 192.76,106.19 192.76,105.92 192.88,105.8 193.06,105.8 193.19,105.67 193.19,105.4 193.06,105.27 192.89,105.27 192.76,105.14 192.76,104.88 192.89,104.75 193.06,104.75 193.19,104.62 193.19,104.36 193.06,104.23 192.89,104.23 192.76,104.1 192.76,103.84 192.89,103.71 193.06,103.71 193.19,103.58 193.19,103.33 193.06,103.2 192.91,103.2 192.78,103.07 192.78,102.81 192.91,102.68 193.06,102.68 193.19,102.55 193.19,102.29 193.06,102.16 192.96,102.16 192.83,102.03 192.83,101.78 192.96,101.65 193.06,101.65 193.19,101.52 193.19,101.19 193.06,101.06 192.94,101.06 192.81,100.93 192.81,100.67 192.94,100.55 193.06,100.55 193.19,100.42 193.19,97.46 189.73,94.01 189.73,92.84 188.08,91.19 188.08,88.6 188.25,88.43 188.34,88.43 188.46,88.3 188.46,88.04 188.34,87.91 188.21,87.91 188.08,87.78 188.08,87.52 188.21,87.39 188.34,87.39 188.46,87.27 188.46,87 188.34,86.88 188.21,86.88 188.08,86.75 188.08,86.48 188.21,86.36 188.34,86.36 188.46,86.23 188.46,85.97 188.34,85.84 188.24,85.84 188.11,85.71 188.11,85.04 188.24,84.92 v1(188.5,84.92)
  BOTTOM w0.076: v1(180.68,128.06) 180.78,128.06 180.93,128.2 180.93,128.55 180.03,129.44 180.03,130.56 179.93,130.66 179.93,131.18 U1.R2
  BOTTOM w0.102: JDIMM1.215 188.07,86.78 187.81,86.52 187.46,86.52 187.09,86.15 187.09,85.99 187.2,85.88 187.44,85.88 187.52,85.79 187.52,85.59 187.31,85.37 187.31,85.23 187.42,85.12 187.68,85.12 187.8,85 187.8,84.83 187.68,84.71 187.43,84.71 187.31,84.59 187.31,84.43 187.43,84.31 187.6,84.31 187.73,84.18 187.73,83.95 187.83,83.84 187.99,83.84 188.09,83.95 188.09,84.9 188.22,85.03 188.39,85.03 v1(188.5,84.92)
M_A_DQ49: length 78.8
  TOP w0.102: v1(190.15,81.99) 189.57,82.57 189.57,84.42 187.81,86.19 187.16,86.19 186.65,86.69 JDIMM2.216
  IN03 w0.076: v1(181.4,133.09) 180.46,132.15 180.46,129.99 184.34,126.11
  IN03 w0.13: 184.34,126.11 187.6,126.11 189.05,124.67 190.8,124.67 193.34,122.13 193.34,118.82 196.21,115.95 196.21,105.92 195.45,105.16 195.45,97.21 192.25,94.01 192.25,92.61 190.66,91.02 190.66,82.5 v1(190.15,81.99)
  BOTTOM w0.102: v1(190.15,81.99) 190.08,81.99 189.7,82.37 189.7,82.72 189.59,82.84 189.42,82.84 189.3,82.72 189.3,81.55 189.43,81.43 190.19,81.43 190.31,81.31 190.31,81.14 190.19,81.02 189.56,81.02 189.46,80.92 189.46,80.53 189.37,80.43 188.43,80.43 188.32,80.33 JDIMM1.216
  BOTTOM w0.14: U1.P5 v1(181.4,133.09)
M_A_DQ50: length 77.6
  TOP w0.102: v1(188.5,83.65) 188.93,83.22 188.93,82.23 188.51,81.81 187.61,81.81 186.23,80.43 185.66,80.43 185.4,80.17 JDIMM2.211
  IN03 w0.076: 183.3,124.64 179.78,128.16 v1(179.78,128.96)
  IN03 w0.13: 183.3,124.64 186.25,124.64 188.46,122.43 189.12,122.43 191.31,120.25 191.31,117.06 192.53,115.84 192.75,115.84 192.88,115.71 192.88,115.45 192.75,115.32 192.53,115.32 192.4,115.19 192.4,114.96 192.53,114.83 192.78,114.83 192.91,114.7 192.91,114.44 192.78,114.31 192.53,114.31 192.4,114.18 192.4,113.93 192.53,113.8 192.78,113.8 192.91,113.67 192.91,113.41 192.78,113.28 192.53,113.28 192.4,113.15 192.4,112.89 192.53,112.76 192.78,112.76 192.91,112.63 192.91,112.37 192.78,112.24 192.53,112.24 192.4,112.11 192.4,111.85 192.53,111.72 192.78,111.72 192.91,111.59 192.91,111.33 192.78,111.2 192.53,111.2 192.4,111.08 192.4,110.82 192.53,110.69 192.78,110.69 192.91,110.56 192.91,110.3 192.78,110.17 192.53,110.17 192.4,110.04 192.4,100.39 192.75,100.04 192.75,97.53 189.38,94.16 189.38,92.99 187.75,91.36 187.75,83.55 187.93,83.37 188.22,83.37 v1(188.5,83.65)
  BOTTOM w0.076: U1.R4 179.93,132.47 179.93,131.61 179.78,131.46 179.78,128.96 v1(179.78,128.96)
  BOTTOM w0.102: JDIMM1.211 187.07,86.62 186.97,86.52 186.54,86.52 186.43,86.41 186.43,86.25 186.54,86.13 186.66,86.13 186.79,86.01 186.79,85.82 186.66,85.69 186.54,85.69 186.43,85.58 186.43,85.43 186.54,85.32 186.9,85.32 187,85.22 187,84.24 187.85,83.4 188.37,83.4 188.5,83.52 v1(188.5,83.65)
M_A_DQ51: length 76.6
  TOP w0.102: v1(191.8,82.38) 191.8,82.5 191.68,82.62 191.45,82.62 191.32,82.5 191.32,82.21 191.56,81.97 191.56,81.82 190.58,80.83 190.11,80.83 189.7,80.43 189.03,80.43 188.9,80.3 JDIMM2.225
  IN03 w0.076: v1(181.4,132.44) 180.67,131.7 180.67,130.08 184.38,126.37
  IN03 w0.13: 184.38,126.37 187.85,126.37 189.15,125.07 190.93,125.07 193.69,122.3 193.69,119.03 196.57,116.16 196.57,105.64 195.83,104.91 195.83,97.08 192.58,93.83 192.58,92.47 191.05,90.94 191.05,81.82 191.18,81.69 191.92,81.69 192.04,81.82 192.04,82.13 v1(191.8,82.38)
  BOTTOM w0.102: v1(191.8,82.38) 191.07,83.11 191.07,86.19 190.57,86.69 JDIMM1.225
  BOTTOM w0.14: v1(181.4,132.44) 181.08,132.77 U1.P4
M_A_DQ52: length 77.5
  TOP w0.102: JDIMM2.212 185.65,86.78 185.91,86.52 186.39,86.52 188.09,84.82 188.09,82.78 v1(188.5,82.38)
  IN03 w0.076: 183.25,124.4 179.33,128.32 v1(179.33,129.41)
  IN03 w0.13: 183.25,124.4 186.04,124.4 188.44,122 188.89,122 190.95,119.94 190.95,116.64 192.02,115.57 192.02,99.81 192.15,99.68 192.26,99.68 192.39,99.55 192.39,99.29 192.26,99.16 192.15,99.16 192.02,99.03 192.02,97.31 189.02,94.31 189.02,93.65 188.64,93.27 188.28,93.27 188.06,93.04 188.06,92.18 187.41,91.54 187.41,83.12 187.57,82.96 187.93,82.96 188.06,82.83 188.06,82.58 187.93,82.45 187.45,82.45 187.32,82.32 187.32,81.94 187.45,81.82 188.13,81.82 188.5,82.19 v1(188.5,82.38)
  BOTTOM w0.076: U1.R5 179.62,132.82 179.62,131.48 179.63,131.48 179.63,130.16 179.33,129.87 v1(179.33,129.41)
  BOTTOM w0.102: v1(188.5,82.38) 188.5,82.5 188.63,82.62 188.87,82.62 189,82.5 189,81.97 188.87,81.84 188.34,81.84 188.22,81.72 188.22,81.56 188.34,81.44 188.99,81.44 189.11,81.31 189.11,80.92 188.99,80.8 188.34,80.8 187.98,80.44 187.45,80.44 187.32,80.31 JDIMM1.212
M_A_DQ53: length 76.7
  TOP w0.102: v1(191.8,83.65) 192.21,83.24 192.21,82.03 190.65,80.47 190.18,80.47 189.9,80.2 JDIMM2.229
  IN03 w0.076: v1(181.4,131.14) 180.92,130.66 180.92,130.12 184.39,126.65
  IN03 w0.13: 184.39,126.65 188.08,126.65 189.28,125.45 191.1,125.45 194.08,122.48 194.08,119.23 197.15,116.16 197.15,113.11 196.95,112.91 196.95,112.6 197.15,112.39 197.15,112.08 196.95,111.88 196.95,111.56 197.15,111.36 197.15,111.04 196.95,110.84 196.95,110.52 197.15,110.32 197.15,110.07 196.93,109.84 196.93,109.55 197.15,109.33 197.15,109.03 196.93,108.81 196.93,108.51 197.15,108.29 197.15,107.99 196.93,107.77 196.93,107.47 197.15,107.25 197.15,106.96 196.93,106.74 196.93,106.44 197.15,106.22 197.15,105.92 196.93,105.7 196.93,105.4 197.15,105.18 197.15,104.92 196.92,104.7 196.46,104.7 196.34,104.57 196.34,104.31 196.46,104.18 197.02,104.18 197.15,104.06 197.15,103.79 197.02,103.66 196.31,103.66 196.19,103.54 196.19,103.27 196.31,103.15 196.89,103.15 197.02,103.02 197.02,102.7 196.9,102.57 196.36,102.57 196.23,102.44 196.23,96.98 192.91,93.66 192.91,92.33 191.38,90.8 191.38,83.88 191.61,83.65 v1(191.8,83.65)
  BOTTOM w0.102: JDIMM1.229 191.57,86.66 191.38,86.47 191.38,86.28 191.52,86.14 191.98,86.14 192.09,86.02 192.09,85.85 191.98,85.73 191.51,85.73 191.38,85.6 191.38,83.65 191.5,83.52 191.68,83.52 v1(191.8,83.65)
  BOTTOM w0.14: U1.P2 181.08,131.47 v1(181.4,131.14)
M_A_DQ54: length 76.9
  TOP w0.102: JDIMM2.224 188.65,86.76 188.29,86.4 188.29,86.22 188.45,86.05 188.59,86.05 188.96,86.42 189.1,86.42 189.25,86.27 189.25,86.13 188.88,85.77 188.88,85.62 189.03,85.48 189.17,85.48 189.41,85.72 189.58,85.72 189.7,85.6 189.7,85.43 189.46,85.19 189.46,85.05 189.64,84.86 189.79,84.86 190.1,85.17 v1(190.15,85.17)
  IN03 w0.076: v1(181.16,127.64) 182.52,127.64 184.33,125.84
  IN03 w0.13: v1(190.15,85.17) 190.13,85.14 189.83,85.14 189.71,85.27 189.71,85.68 189.83,85.8 190.2,85.8 190.33,85.93 190.33,86.21 190.2,86.34 189.86,86.34 189.73,86.47 189.73,86.75 189.86,86.88 190.2,86.88 190.33,87 190.33,87.27 190.2,87.39 189.86,87.39 189.73,87.52 189.73,87.78 189.86,87.91 190.2,87.91 190.33,88.04 190.33,88.3 190.2,88.43 189.86,88.43 189.73,88.56 189.73,90.57 191.31,92.14 191.31,93.63 195.07,97.39 195.07,105.86 195.2,105.99 195.47,105.99 195.6,106.12 195.6,106.38 195.47,106.51 195.2,106.51 195.07,106.64 195.07,107.05 195.2,107.18 195.7,107.18 195.83,107.31 195.83,107.57 195.7,107.7 195.2,107.7 195.07,107.83 195.07,108.09 195.2,108.22 195.68,108.22 195.8,108.34 195.8,108.61 195.68,108.74 195.2,108.74 195.07,108.87 195.07,109.1 195.24,109.27 195.58,109.27 195.75,109.44 195.75,115.88 192.98,118.65 192.98,122 190.75,124.23 188.97,124.23 187.37,125.84 184.33,125.84
  BOTTOM w0.076: v1(181.16,127.64) 181.16,128.62 180.22,129.56 U1.R1
  BOTTOM w0.102: JDIMM1.224 190.32,80.64 190.61,80.93 190.61,84.71 v1(190.15,85.17)
M_A_DQ55: length 77.3
  TOP w0.102: JDIMM2.228 189.65,86.24 190.78,85.12 190.92,85.12 191.04,85 191.04,84.82 190.92,84.7 190.75,84.7 190.61,84.56 190.61,84.28 190.74,84.15 191.23,84.15 191.36,84.28 191.36,84.79 191.49,84.92 v1(191.8,84.92)
  IN03 w0.076: v1(181.4,130.5) 181.4,129.92 184.45,126.88
  IN03 w0.13: v1(191.8,84.92) 191.71,85 191.71,88.3 192.22,88.81 192.22,90.71 192.22,90.71 192.22,91.17 193.25,92.2 193.25,93.48 196.62,96.86 196.62,97.36 196.74,97.49 197.38,97.49 197.5,97.62 197.5,97.85 197.38,97.98 196.72,97.98 196.59,98.11 196.59,98.37 196.72,98.5 197.38,98.5 197.5,98.63 197.5,98.88 197.38,99.01 196.72,99.01 196.59,99.14 196.59,99.4 196.72,99.53 197.38,99.53 197.5,99.66 197.5,99.92 197.38,100.05 196.72,100.05 196.59,100.17 196.59,100.44 196.72,100.57 197.38,100.57 197.5,100.7 197.5,100.95 197.38,101.08 196.72,101.08 196.59,101.21 196.59,101.48 196.72,101.6 197.38,101.6 197.5,101.73 197.5,116.31 194.46,119.36 194.46,122.63 191.23,125.86 189.38,125.86 188.36,126.88 184.45,126.88
  BOTTOM w0.076: v1(181.4,130.5) 181.08,130.82 U1.P1
  BOTTOM w0.102: v1(191.8,84.92) 192.21,84.51 192.21,82.21 191.32,81.32 JDIMM1.228
M_A_DQ56: length 82.2
  TOP w0.102: v1(193.71,84.92) 194.13,84.49 194.13,82.2 193.23,81.3 192.52,81.3 191.67,80.45 191.18,80.45 190.9,80.17 JDIMM2.233
  IN03 w0.13: v1(182.75,129.14) 184.22,129.14 185.39,127.97 188.87,127.97 189.83,127 192.45,127 195.57,123.88 195.57,119.89 199.11,116.36 199.11,111.46 199.54,111.03 199.54,96.32 198,94.78 197.81,94.78 197.65,94.94 197.47,94.94 197.29,94.76 197.29,94.57 197.45,94.41 197.45,94.23 197.26,94.05 197.08,94.05 196.92,94.21 196.74,94.21 196.55,94.02 196.55,93.84 196.71,93.68 196.71,93.5 196.53,93.31 196.35,93.31 196.19,93.47 196,93.47 195.82,93.29 195.82,93.11 195.98,92.95 195.98,92.76 193.29,90.07 193.29,88.47 193.42,88.34 193.67,88.34 193.8,88.21 193.8,87.95 193.67,87.82 193.42,87.82 193.29,87.69 193.29,87.43 193.42,87.3 193.67,87.3 193.8,87.18 193.8,86.91 193.67,86.79 193.42,86.79 193.29,86.66 193.29,86.4 193.42,86.27 193.67,86.27 193.8,86.14 193.8,85.88 193.67,85.75 193.42,85.75 193.29,85.62 193.29,85.12 193.49,84.92 v1(193.71,84.92)
  BOTTOM w0.076: U1.M4 182.3,132.33 182.3,130.45 182.51,130.25 182.51,129.99 182.75,129.75 v1(182.75,129.14)
  BOTTOM w0.102: JDIMM1.233 192.57,86.63 192.77,86.42 193.36,86.42 193.46,86.32 193.46,86.17 193.36,86.06 192.97,86.06 192.86,85.95 192.86,85.79 192.97,85.68 193.48,85.68 193.59,85.57 193.59,85.41 193.48,85.3 193.07,85.3 192.95,85.17 192.95,83.97 193.05,83.87 193.19,83.87 193.29,83.97 193.29,84.89 193.42,85.02 193.61,85.02 v1(193.71,84.92)
M_A_DQ57: length 81.3
  TOP w0.102: v1(193.71,82.38) 193,83.09 193,84.43 190.65,86.78 JDIMM2.232
  IN03 w0.13: v1(184.09,127.79) 184.65,127.79 185.11,127.33 188.61,127.33 189.73,126.22 191.97,126.22 194.86,123.32 194.86,119.59 198.29,116.16 198.29,110.53 198.42,110.4 198.67,110.4 198.8,110.28 198.8,110.01 198.67,109.89 198.42,109.89 198.29,109.76 198.29,109.5 198.42,109.37 198.67,109.37 198.8,109.24 198.8,108.98 198.67,108.85 198.42,108.85 198.29,108.72 198.29,108.46 198.42,108.33 198.67,108.33 198.8,108.2 198.8,107.95 198.67,107.82 198.42,107.82 198.29,107.69 198.29,107.43 198.42,107.3 198.67,107.3 198.8,107.17 198.8,106.91 198.67,106.78 198.42,106.78 198.29,106.65 198.29,106.39 198.42,106.26 198.67,106.26 198.8,106.13 198.8,105.87 198.67,105.74 198.42,105.74 198.29,105.61 198.29,97.29 194.56,93.55 194.56,92.31 192.62,90.37 192.62,83.55 192.88,83.29 193.16,83.29 193.29,83.16 193.29,82.93 193.16,82.81 192.76,82.81 192.63,82.68 192.63,82.43 192.76,82.3 193.16,82.3 193.25,82.21 193.25,81.69 193.38,81.56 193.95,81.56 194.08,81.69 194.08,82.01 v1(193.71,82.38)
  BOTTOM w0.076: v1(184.09,127.79) 184.09,128.63 183.18,129.54 183.18,129.87 182.81,130.23 182.81,130.52 182.74,130.6 U1.M1
  BOTTOM w0.102: JDIMM1.232 192.32,80.44 192.22,80.53 192.22,80.97 192.32,81.07 192.32,81.3 192.95,81.93 192.95,83.47 193.05,83.57 193.2,83.57 193.3,83.47 193.3,82.38 193.43,82.25 193.58,82.25 v1(193.71,82.38)
M_A_DQ58: length 80.2
  TOP w0.102: JDIMM2.249 194.9,80.29 195.17,80.57 195.61,80.57 196.26,81.21 196.44,81.21 197.41,82.18 197.41,83.22 v1(196.98,83.65)
  IN03 w0.13: v1(196.98,83.65) 196.56,84.07 196.56,85.24 198.14,86.82 198.14,90.76 199.8,92.42 199.99,92.42 200.19,92.22 200.37,92.22 200.55,92.41 200.55,92.59 200.35,92.79 200.35,92.97 200.54,93.16 200.72,93.16 200.92,92.96 201.1,92.96 201.28,93.14 201.28,93.32 201.09,93.52 201.09,93.7 201.27,93.89 201.45,93.89 201.6,93.74 201.78,93.74 201.97,93.93 201.97,94.11 201.82,94.25 201.82,94.44 203.19,95.81 203.19,99.27 203,99.46 203,107.68 203.19,107.87 203.19,122.48 199.97,125.71 198.11,125.71 193.26,130.56 189.76,130.56 189.3,131.02 185.08,131.02 184.63,131.47 184.63,132.21 184.4,132.44 v1(183.92,132.44)
  BOTTOM w0.102: JDIMM1.249 196.57,86.52 196.67,86.42 197.37,86.42 197.49,86.3 197.49,86.13 197.37,86.01 196.67,86.01 196.57,85.91 196.57,83.77 196.7,83.65 v1(196.98,83.65)
  BOTTOM w0.14: v1(183.92,132.44) 183.59,132.77 U1.L4
M_A_DQ59: length 81.4
  TOP w0.102: v1(196.98,82.38) 196.54,82.82 196.54,85.29 195.82,86.02 194.77,86.02 194.15,86.63 JDIMM2.246
  IN03 w0.13: v1(196.98,82.38) 196.26,82.38 196.13,82.5 196.13,82.71 196.26,82.83 196.39,82.83 196.51,82.96 196.51,83.19 196.21,83.49 196.21,85.53 197.78,87.1 197.78,90.94 202.79,95.94 202.79,98.05 202.51,98.33 202.51,98.55 202.79,98.83 202.79,99.09 202.51,99.37 202.51,107.88 202.79,108.16 202.79,122.38 199.84,125.33 197.81,125.33 193.49,129.65 190.16,129.65 189.12,130.69 184.83,130.69 184.4,131.12 183.94,131.12 v1(183.92,131.14)
  BOTTOM w0.102: JDIMM1.246 195.82,80.48 195.72,80.57 195.42,80.57 195.3,80.7 195.3,80.87 195.42,81 195.95,81 196.21,81.25 196.21,83.05 196.3,83.15 196.42,83.15 196.51,83.05 196.51,82.08 196.63,81.97 196.87,81.97 197,82.1 197,82.36 v1(196.98,82.38)
  BOTTOM w0.14: v1(183.92,131.14) 183.59,131.47 U1.L2
M_A_DQ60: length 80.6
  TOP w0.102: JDIMM2.245 193.9,80.28 194.79,81.18 195.78,81.18 196.5,81.9 196.5,82.24 196.38,82.37 196.04,82.37 195.91,82.24 195.91,81.95 195.71,81.74 v1(195.36,81.74)
  IN03 w0.13: v1(182.3,129.59) 184.22,129.59 185.52,128.3 189.05,128.3 189.88,127.46 192.7,127.46 196.03,124.13 196.03,119.99 199.23,116.79 199.64,116.79 199.77,116.67 199.77,116.45 199.64,116.32 199.62,116.32 199.49,116.19 199.49,115.93 199.62,115.8 199.77,115.8 199.89,115.67 199.89,115.41 199.77,115.28 199.62,115.28 199.49,115.15 199.49,113.24 199.62,113.11 199.79,113.11 199.92,112.98 199.92,96.17 194.69,90.94 194.69,88.12 194.13,87.56 194.13,82.65 195.04,81.74 v1(195.36,81.74)
  BOTTOM w0.076: v1(182.3,129.59) 182.3,130.15 182.15,130.3 182.15,132.83 U1.M5
  BOTTOM w0.102: v1(195.36,81.74) 195.87,82.25 195.87,85.8 195.57,86.1 JDIMM1.245
M_A_DQ61: length 80.4
  TOP w0.102: JDIMM2.236 191.65,86.67 191.57,86.59 191.57,86.49 191.7,86.36 192.31,86.36 192.33,86.39 192.5,86.39 192.61,86.27 192.61,86.1 192.54,86.03 192.54,85.86 192.66,85.74 192.83,85.74 192.88,85.79 193.05,85.79 193.17,85.67 193.17,85.5 193.11,85.44 193.11,85.3 193.3,85.1 193.3,84.03 193.71,83.62 v1(193.71,83.65)
  IN03 w0.13: v1(183.64,128.24) 184.66,128.24 185.26,127.64 188.74,127.64 189.83,126.55 192.17,126.55 195.22,123.5 195.22,119.74 198.65,116.31 198.65,111.28 199.16,110.77 199.16,105.37 199.03,105.24 198.78,105.24 198.65,105.11 198.65,104.85 198.78,104.72 199.03,104.72 199.16,104.59 199.16,104.33 199.07,104.25 199.03,104.2 198.78,104.2 198.65,104.07 198.65,103.81 198.78,103.69 199.03,103.69 199.16,103.56 199.16,103.3 199.03,103.17 198.78,103.17 198.65,103.04 198.65,102.78 198.78,102.65 199.03,102.65 199.16,102.52 199.16,102.26 199.03,102.13 198.78,102.13 198.65,102 198.65,101.74 198.78,101.61 199.03,101.61 199.16,101.49 199.16,101.23 199.03,101.1 198.78,101.1 198.65,100.97 198.65,100.71 198.78,100.58 199.03,100.58 199.16,100.45 199.16,100.19 199.03,100.06 198.78,100.06 198.65,99.93 198.65,99.67 198.78,99.54 199.03,99.54 199.16,99.41 199.16,99.15 199.03,99.02 198.78,99.02 198.65,98.89 198.65,98.64 198.78,98.51 199.03,98.51 199.16,98.38 199.16,98.12 199.03,97.99 198.78,97.99 198.65,97.86 198.65,97.6 198.78,97.47 199.03,97.47 199.16,97.34 199.16,97.18 198.82,96.85 198.82,96.67 198.96,96.53 198.96,96.35 198.77,96.17 198.59,96.17 198.46,96.3 198.27,96.3 198.09,96.12 198.09,95.93 198.22,95.8 198.22,95.62 198.04,95.43 197.86,95.43 197.72,95.57 197.54,95.57 194.91,92.94 194.91,92.18 192.95,90.22 192.95,84.08 193.42,83.62 193.68,83.62 v1(193.71,83.65)
  BOTTOM w0.076: v1(183.64,128.24) 183.64,128.8 182.98,129.47 182.98,129.82 182.66,130.13 182.66,130.37 182.46,130.58 182.46,131.19 U1.M2
  BOTTOM w0.102: v1(193.71,83.65) 193.71,83.59 194.11,83.18 194.11,82.19 193.87,81.94 193.39,81.94 192.68,81.23 192.68,80.56 192.81,80.43 193.19,80.43 193.32,80.3 JDIMM1.236
M_A_DQ62: length 80.3
  TOP w0.102: JDIMM2.250 195.15,86.69 195.11,86.65 195.11,86.45 195.22,86.34 196.36,86.34 197.87,84.83 197.87,84.65 197.65,84.43 197.47,84.43 v1(196.98,84.92)
  IN03 w0.13: v1(196.98,84.92) 196.98,85.18 198.5,86.69 198.5,88.81 198.62,88.94 199,88.94 199.13,89.07 199.13,89.33 199,89.46 198.62,89.46 198.5,89.59 198.5,89.84 199.01,90.36 199.01,90.54 198.83,90.73 198.83,90.91 199.01,91.09 199.19,91.09 199.38,90.91 199.56,90.91 199.74,91.09 199.74,91.28 199.56,91.46 199.56,91.64 199.74,91.83 199.93,91.83 200.11,91.64 200.29,91.64 203.58,94.92 203.58,100.74 203.45,100.87 203.45,101.26 203.58,101.39 203.58,101.78 203.45,101.91 203.45,102.3 203.58,102.43 203.58,102.82 203.45,102.95 203.45,103.33 203.58,103.46 203.58,122.61 200.09,126.09 198.5,126.09 193.64,130.94 189.94,130.94 189.53,131.35 185.39,131.35 185.14,131.6 185.14,132.64 184.65,133.12 183.95,133.12 v1(183.92,133.09)
  BOTTOM w0.102: JDIMM1.250 196.82,81.42 197.41,82.01 197.41,84.49 v1(196.98,84.92)
  BOTTOM w0.14: v1(183.92,133.09) 183.59,133.42 U1.L5
M_A_DQ63: length 82
  TOP w0.102: v1(195.36,84.92) 194.91,84.46 194.91,82.49 193.27,80.85 192.56,80.85 191.9,80.2 JDIMM2.237
  IN03 w0.13: v1(195.36,84.92) 195.65,84.92 195.85,85.12 195.85,86.06 195.54,86.37 195.54,86.55 195.72,86.74 195.9,86.74 196.33,86.31 196.51,86.31 196.7,86.5 196.7,86.68 196.23,87.15 196.23,87.32 196.42,87.51 196.6,87.51 197.06,87.05 197.25,87.05 197.43,87.23 197.43,87.51 197.02,87.91 197.02,88.19 197.43,88.6 197.43,91.09 202.41,96.07 202.41,97.51 202.15,97.76 202.15,109.13 202.41,109.39 202.41,109.65 202.15,109.91 202.15,110.17 202.41,110.42 202.41,110.69 202.15,110.94 202.15,111.21 202.41,111.46 202.41,111.72 201.83,112.29 201.83,114.19 202.41,114.76 202.41,122.23 199.69,124.95 197.48,124.95 193.24,129.19 190.11,129.19 188.89,130.41 184.7,130.41 184.63,130.48 183.92,130.48 v1(183.92,130.49)
  BOTTOM w0.102: v1(195.36,84.92) 195.36,84.89 195.23,84.76 194.84,84.76 194.71,84.89 194.71,85.12 194.84,85.25 195.04,85.25 195.19,85.4 195.19,85.55 195.09,85.65 194.12,85.65 194,85.77 194,85.94 194.12,86.06 195.09,86.06 195.19,86.16 195.19,86.39 195.07,86.52 193.7,86.52 193.57,86.64 JDIMM1.237
  BOTTOM w0.14: U1.L1 183.59,130.82 v1(183.92,130.49)
M_A_DQS_DN0: length 84.5
  TOP w0.102: JDIMM2.11 133.4,84.11 133.64,84.35 134.09,84.35 v1(134.27,84.53)
  IN03 w0.076: v1(147.62,132.04) 147.62,132.16 147.52,132.26 147.34,132.26 146.68,131.6 146.68,131.5 146.83,131.35 146.83,131.24 146.76,131.17 146.65,131.17 146.51,131.32 146.4,131.32 146.32,131.24 146.32,131.13 146.45,131 146.45,130.89 146.38,130.82 146.27,130.82 146.12,130.97 146.04,130.97 145.87,130.79 145.22,130.79 145.21,130.78 145.21,130.73 145.2,130.72 145.19,130.72
  IN03 w0.145: v1(134.27,84.53) 134.27,84.44 134.14,84.31 133.83,84.31 133.7,84.44 133.7,86.49 132.53,87.66 130.78,87.66 130.01,88.43 130.01,89.27 130.47,89.72 130.47,90.47 130.02,90.92 129.59,90.92 128.99,90.31 128.81,90.31 128.37,90.75 128.37,90.93 128.99,91.54 128.99,91.97 128.38,92.58 127.95,92.58 127.43,92.05 127.12,92.05 126.91,92.26 126.91,93.11 127.06,93.25 127.89,93.25 128.21,93.57 128.21,94.45 127.95,94.72 127.06,94.72 126.91,94.86 126.91,111.04 128.66,112.8 128.66,113.8 135.19,120.33 135.19,121.13 144.78,130.72 145.19,130.72
  BOTTOM w0.076: v1(147.62,132.04) 147.62,132.04 147.73,132.15 147.73,132.78 148.02,133.08 148.18,133.08 148.43,133.32 149.74,133.32 149.84,133.42 150.01,133.42 150.12,133.3 150.12,133.14 U1.BR5
  BOTTOM w0.102: v1(134.27,84.53) 134.27,84.41 134.4,84.29 135.3,84.29 135.43,84.41 135.43,84.76 135.3,84.89 134.92,84.89 134.68,85.14 134.68,85.66 134.92,85.91 135.24,85.91 135.37,86.03 135.37,86.48 135.3,86.54 135.12,86.54 135.07,86.59 135.07,87.57 JDIMM1.11
M_A_DQS_DN1: length 78.4
  TOP w0.102: v1(140.37,83.9) 140.18,84.08 139.18,84.08 138.93,84.33 138.93,84.92 139.18,85.17 139.34,85.17 139.47,85.3 139.47,85.7 139.34,85.83 138.96,85.83 138.65,86.14 JDIMM2.32
  IN03 w0.076: 146.91,127.05 146.92,127.07 147.02,127.07 147.1,127.14 148.22,128.26 148.57,128.26 148.76,128.07 149.06,128.07 v1(149.15,127.99)
  IN03 w0.145: 146.91,127.05 146.4,126.55 145.87,126.55 139.57,120.25 139.57,119.11 133.24,112.78 133.24,106.72 133.07,106.55 132.7,106.55 132.3,106.15 132.3,105.61 132.62,105.29 132.88,105.29 133.02,105.14 133.02,104.56 132.88,104.42 132.62,104.42 132.3,104.1 132.3,103.29 132.66,102.93 133.09,102.93 133.24,102.78 133.24,96.35 136.6,92.98 136.6,92.36 136.46,92.22 136.22,92.22 135.92,91.92 135.92,91.31 136.22,91.01 136.46,91.01 136.6,90.86 136.6,88.39 138.32,86.68 138.54,86.68 139.27,85.95 139.27,84.09 139.67,83.7 140.16,83.7 v1(140.37,83.9)
  BOTTOM w0.076: 150.84,128.43 150.86,128.44 150.97,128.44 151.24,128.71 151.45,128.71 153.23,130.48 153.23,130.92 152.9,131.25 152.9,131.78 152.57,132.12 U1.BL3
  BOTTOM w0.102: JDIMM1.32 140.32,80.33 140.38,80.39 140.56,80.39 140.62,80.45 140.62,80.94 140.89,81.21 140.89,84 140.74,84.15 140.49,84.15 140.37,84.02 v1(140.37,83.9)
  BOTTOM w0.147: v1(149.15,127.99) 149.12,127.96 149.12,127.74 149.36,127.5 149.92,127.5 150.02,127.6 150.02,127.79 149.91,127.89 149.91,128.08 150.04,128.21 150.22,128.21 150.33,128.1 150.51,128.1 150.84,128.43
M_A_DQS_DN2: length 74.6
  TOP w0.102: v1(146.21,83.65) 146.03,83.46 145.8,83.46 145.33,82.99 145.33,81.67 144.66,81 144.11,81 143.9,80.79 JDIMM2.53
  IN03 w0.076: v1(151.23,126.94) 151.12,126.83 151.12,126.65 151.3,126.47 151.3,126.12 151.3,126.12 151.17,125.99 151.17,125.89 151.16,125.88 151.16,125.87
  IN03 w0.145: v1(146.21,83.65) 146.21,83.61 145.99,83.39 145.69,83.39 145.55,83.53 145.55,85.92 144.23,87.24 143.87,87.24 142.59,88.52 142.08,88.52 141.84,88.76 141.84,90.45 141.97,90.58 142.26,90.58 142.56,90.88 142.56,91.77 142.28,92.04 141.97,92.04 141.84,92.17 141.84,94.02 139.62,96.24 139.62,106.13 139.34,106.41 139.34,107.22 139.62,107.5 139.62,108.47 139.34,108.74 139.34,109.55 139.62,109.83 139.62,110.8 139.34,111.07 139.34,111.88 139.62,112.16 139.62,112.69 144.39,117.46 144.39,119.1 151.16,125.87
  BOTTOM w0.076: 153.88,128.05 153.89,128.06 154.01,128.06 154.17,128.22 154.32,128.22 155.63,129.52 155.63,130.37 155.37,130.63 155.37,131.67 155.47,131.77 155.47,132.25 155.35,132.36 155.19,132.36 155.07,132.25 U1.BG3
  BOTTOM w0.102: v1(146.21,83.65) 146.21,83.52 146.34,83.4 146.56,83.4 146.86,83.7 146.86,85.58 146.44,86 146.08,86 145.87,86.21 145.87,86.5 145.8,86.56 145.62,86.56 145.57,86.61 JDIMM1.53
  BOTTOM w0.147: 153.88,128.05 152.37,126.54 151.41,126.54 151.23,126.72 v1(151.23,126.94)
M_A_DQS_DN3: length 74.2
  TOP w0.102: v1(150.27,83.65) 150.11,83.81 149.95,83.81 149.84,83.7 149.4,83.7 149.08,84.01 149.08,84.7 149.33,84.94 149.54,84.94 149.66,85.07 149.66,85.45 149.54,85.58 149.4,85.58 149.15,85.82 JDIMM2.74
  IN03 w0.076: v1(156.5,127.77) 156.39,127.66 156.39,127.46 156.63,127.23 156.63,126.35 156.04,125.76 155.84,125.56 155.84,125.46 155.83,125.45
  IN03 w0.145: v1(150.27,83.65) 150.44,83.81 150.63,83.81 151,84.18 151,85.92 148.45,88.46 148.28,88.46 147.77,88.97 147.77,90.54 147.89,90.66 148.61,90.66 148.91,90.96 148.91,91.83 148.61,92.13 147.92,92.13 147.77,92.27 147.77,94.25 145.87,96.16 145.87,102.87 145.53,103.21 145.53,103.91 145.87,104.25 145.87,104.79 145.55,105.11 145.22,105.11 145.05,105.28 145.05,105.81 145.22,105.98 145.55,105.98 145.87,106.3 145.87,107.12 145.55,107.44 145.22,107.44 145.05,107.61 145.05,108.14 145.22,108.31 145.55,108.31 145.87,108.63 145.87,113.01 148.89,116.03 148.89,118.51 154.22,123.83 155.83,125.45
  BOTTOM w0.076: U1.BD3 157.59,132.32 157.71,132.44 157.89,132.44 158.01,132.32 158.01,132.02 157.88,131.89 157.88,130.45 158.06,130.27 158.06,130.09 157.97,130.01 157.97,130
  BOTTOM w0.102: JDIMM1.74 150.82,80.42 150.87,80.47 151.06,80.47 151.12,80.52 151.12,83.7 150.93,83.88 150.37,83.88 150.27,83.79 v1(150.27,83.65)
  BOTTOM w0.147: v1(156.5,127.77) 156.5,127.55 156.68,127.38 157.47,127.38 157.97,127.88 157.97,130
M_A_DQS_DN4: length 72.1
  TOP w0.102: JDIMM2.177 176.9,80.17 177.18,80.45 177.39,80.45 178.58,81.64 179.95,81.64 180.28,81.97 180.28,83.54 180.18,83.64 179.86,83.64 179.74,83.51 v1(179.74,83.39)
  IN03 w0.076: 176.75,124.74 176.73,124.75 176.73,124.85 176.49,125.1 176.49,125.46 175.8,126.14 175.69,126.14 175.53,125.99 175.53,125.86 v1(175.65,125.75)
  IN03 w0.145: v1(179.74,83.39) 179.58,83.55 179.28,83.55 178.98,83.85 178.98,94.02 181.96,96.99 181.96,110.74 182.28,111.06 182.48,111.06 182.65,111.23 182.65,111.76 182.48,111.93 182.28,111.93 181.96,112.24 181.96,113.07 182.28,113.39 182.48,113.39 182.62,113.53 182.62,114.11 182.48,114.26 182.28,114.26 181.96,114.58 181.96,115.4 182.28,115.72 182.48,115.72 182.62,115.86 182.62,116.44 182.48,116.59 182.28,116.59 181.96,116.91 181.96,117.73 182.28,118.05 182.48,118.05 182.62,118.2 182.62,118.78 182.48,118.92 182.28,118.92 181.96,119.24 181.96,119.52 176.75,124.74
  BOTTOM w0.076: U1.AA3 175.92,132.12 175.64,131.83 175.64,130.66 175.86,130.43 175.86,130.25 175.95,130.16 175.95,130.15
  BOTTOM w0.102: v1(179.74,83.39) 179.45,83.39 179.39,83.33 179.39,83.23 179.14,82.99 178.69,82.99 178.44,83.23 178.44,83.93 178.71,84.21 179.03,84.21 179.13,84.31 179.13,85.35 179,85.47 178.56,85.47 178.3,85.74 178.3,86.1 178.48,86.28 178.57,86.28 178.64,86.35 178.64,86.71 178.57,86.78 JDIMM1.177
  BOTTOM w0.147: v1(175.65,125.75) 175.65,125.97 175.95,126.26 175.95,130.15
M_A_DQS_DN5: length 71.8
  TOP w0.102: v1(184.94,83.26) 184.76,83.45 184.6,83.45 184.25,83.8 184.25,84.54 183.03,85.75 182.66,85.75 182.15,86.26 JDIMM2.198
  IN03 w0.076: v1(179.07,125.92) 179.07,126.26 179.18,126.37 179.37,126.37 179.67,126.07 179.67,125.96 179.68,125.95
  IN03 w0.145: 179.68,125.95 182.79,122.84 184.5,122.84 187.99,119.35 187.99,112.57 188.32,112.23 188.57,112.23 188.7,112.1 188.7,111.49 188.57,111.36 188.24,111.36 187.94,111.06 187.94,110.2 188.24,109.9 188.5,109.9 188.62,109.77 188.62,109.16 188.5,109.03 188.26,109.03 187.95,108.73 187.95,108.15 188.26,107.85 188.5,107.85 188.62,107.72 188.62,107.11 188.5,106.98 188.32,106.98 188.01,106.66 188.01,97.06 184.14,93.2 184.14,91.91 184.55,91.5 184.55,90.82 184.14,90.41 184.14,83.78 184.48,83.43 184.78,83.43 v1(184.94,83.26)
  BOTTOM w0.076: U1.U3 178.15,131.82 178.15,130.67 178.43,130.39 178.43,129.63 178.52,129.54
  BOTTOM w0.102: JDIMM1.198 183.82,80.42 183.87,80.47 184.07,80.47 184.12,80.52 184.12,80.88 184.67,81.44 184.96,81.44 185.5,81.98 185.5,83.39 185.38,83.51 185.07,83.51 184.94,83.39 v1(184.94,83.26)
  BOTTOM w0.147: 178.52,129.54 178.52,129.31 179.29,128.53 179.29,126.31 179.07,126.09 v1(179.07,125.92)
M_A_DQS_DN6: length 78.8
  TOP w0.102: v1(190.15,83.26) 190.15,83.39 190.28,83.51 190.52,83.51 190.65,83.39 190.65,81.91 190.24,81.51 189.78,81.51 189.3,81.03 188.01,81.03 187.7,80.72 187.7,80.45 187.64,80.39 187.45,80.39 187.4,80.35 JDIMM2.219
  IN03 w0.076: v1(182.48,126.26) 182.36,126.38 182.36,126.55 182.48,126.66 182.65,126.66 182.92,126.39
  IN03 w0.145: 182.92,126.39 184.09,125.23 186.91,125.23 188.71,123.43 189.62,123.43 192.17,120.88 192.17,118.22 194.66,115.73 194.66,114.55 194.54,114.42 194.28,114.42 193.93,114.07 193.93,113.44 194.23,113.14 194.75,113.14 194.87,113.01 194.87,112.47 194.75,112.34 194.26,112.34 193.96,112.04 193.96,111.38 194.26,111.08 194.66,111.08 194.79,110.95 194.79,110.34 194.66,110.21 194.3,110.21 194.02,109.94 193.98,109.89 193.98,97.5 190.66,94.17 190.66,92.69 190.02,92.05 189.68,92.05 188.93,91.3 188.93,83.79 189.28,83.43 189.98,83.43 v1(190.15,83.26)
  BOTTOM w0.076: U1.P3 180.77,131.93 180.77,131.75 180.67,131.65 180.67,130.42 180.79,130.29 180.92,130.29
  BOTTOM w0.102: JDIMM1.219 189.07,86.42 188.99,86.34 188.58,86.34 188.34,86.09 188.34,85.59 188.58,85.35 189.41,85.35 189.54,85.22 189.54,84.81 189.41,84.69 189.15,84.69 188.91,84.44 188.91,83.72 189.18,83.45 189.97,83.45 v1(190.15,83.26)
  BOTTOM w0.147: 180.92,130.29 180.99,130.21 182.69,128.52 182.69,126.69 182.48,126.48 v1(182.48,126.26)
M_A_DQS_DN7: length 81.9
  TOP w0.102: v1(195.36,83.65) 195.61,83.39 195.82,83.39 195.96,83.53 195.96,84.93 195.57,85.32 194.03,85.32 193.75,85.6 193.75,85.9 193.12,86.52 192.82,86.52 192.65,86.68 JDIMM2.240
  IN03 w0.076: v1(184.82,129.59) 185.16,129.59 185.34,129.77 185.7,129.77 185.77,129.84
  IN03 w0.145: v1(195.36,83.65) 195.19,83.48 195,83.48 194.91,83.57 194.91,86.95 196.18,88.22 196.18,90.86 196.82,91.5 196.82,91.52 201.3,96.01 201.3,111.33 201.3,111.33 201.05,111.58 201.05,114.51 201.82,115.28 201.82,122.06 199.5,124.38 197.08,124.38 193.14,128.32 190.17,128.32 188.65,129.84 185.77,129.84
  BOTTOM w0.076: 183.89,129.8 183.88,129.82 183.83,129.82 183.43,130.22 183.43,130.45 183.18,130.7 183.18,131.64 183.09,131.73 183.09,132.28 183.2,132.39 183.36,132.39 183.47,132.28 U1.L3
  BOTTOM w0.102: JDIMM1.240 194.32,80.31 194.2,80.42 194.2,80.59 194.12,80.67 193.48,80.67 193.24,80.92 193.24,81.29 193.48,81.54 194.26,81.54 194.44,81.36 194.61,81.36 194.75,81.5 194.75,81.92 194.48,82.19 194.48,82.72 194.72,82.96 194.72,83.28 194.91,83.46 195.18,83.46 v1(195.36,83.65)
  BOTTOM w0.147: 183.89,129.8 184.47,129.23 184.68,129.23 184.82,129.37 v1(184.82,129.59)
M_A_DQS_DP0: length 84.6
  TOP w0.102: JDIMM2.13 133.9,79.38 133.9,80.34 133.85,80.4 133.66,80.4 133.61,80.45 133.61,84.03 133.73,84.15 134.14,84.15 134.27,84.02 v1(134.27,83.9)
  IN03 w0.076: v1(148.11,132.45) 148.07,132.41 147.27,132.41 145.8,130.94 145.28,130.94 145.2,131.02 145.19,131.02
  IN03 w0.145: v1(134.27,83.9) 134.27,83.92 134.18,84.01 133.7,84.01 133.4,84.31 133.4,86.37 132.41,87.36 130.66,87.36 129.71,88.3 129.71,89.39 130.17,89.85 130.17,90.35 129.9,90.62 129.72,90.62 129.11,90.02 128.69,90.02 128.08,90.63 128.08,91.05 128.69,91.66 128.69,91.84 128.25,92.28 128.07,92.28 127.55,91.76 127,91.76 126.61,92.14 126.61,93.23 126.93,93.55 127.77,93.55 127.92,93.7 127.92,94.28 127.77,94.42 126.93,94.42 126.61,94.74 126.61,111.17 128.37,112.92 128.37,113.92 134.89,120.45 134.89,121.25 144.66,131.02 145.19,131.02
  BOTTOM w0.076: U1.BP5 150.6,133.18 150.08,132.67 149.83,132.67 149.68,132.82 149.68,133.07 149.59,133.16 148.49,133.16 148.25,132.92 148.08,132.92 147.88,132.72 147.88,132.59 148.02,132.45 v1(148.11,132.45)
  BOTTOM w0.102: v1(134.27,83.9) 134.45,84.08 135.38,84.08 135.63,84.33 135.63,84.85 135.38,85.09 135.01,85.09 134.88,85.22 134.88,85.58 135.01,85.7 135.32,85.7 135.57,85.95 JDIMM1.13
M_A_DQS_DP1: length 78.4
  TOP w0.102: v1(140.37,84.53) 140.37,84.41 140.24,84.29 139.26,84.29 139.14,84.41 139.14,84.84 139.26,84.97 139.42,84.97 139.67,85.21 139.67,85.79 139.42,86.03 139.04,86.03 138.86,86.22 138.86,86.48 138.92,86.55 139.09,86.55 139.15,86.61 JDIMM2.34
  IN03 w0.076: 147.12,126.84 147.13,126.86 147.13,126.96 147.21,127.04 147.3,127.13 147.57,127.13 147.64,127.21 147.64,127.31 147.64,127.31 147.64,127.47 147.76,127.59 147.95,127.59 148.08,127.46 148.2,127.46 148.28,127.54 148.28,127.61 148.1,127.8 148.1,127.92 148.28,128.11 148.51,128.11 148.78,127.84 148.78,127.61 v1(148.7,127.54)
  IN03 w0.145: 147.12,126.84 146.52,126.25 145.99,126.25 139.86,120.12 139.86,118.98 133.54,112.66 133.54,106.6 133.19,106.25 132.82,106.25 132.6,106.03 132.6,105.73 132.74,105.59 133,105.59 133.32,105.27 133.32,104.44 133,104.12 132.74,104.12 132.6,103.98 132.6,103.41 132.79,103.23 133.22,103.23 133.54,102.91 133.54,96.47 136.9,93.11 136.9,92.24 136.58,91.92 136.34,91.92 136.21,91.79 136.21,91.43 136.34,91.31 136.58,91.31 136.9,90.99 136.9,88.51 138.44,86.97 138.66,86.97 139.57,86.07 139.57,84.22 139.74,84.05 139.91,84.05 140.37,84.51 v1(140.37,84.53)
  BOTTOM w0.076: 151.07,128.2 151.1,128.22 151.1,128.35 151.3,128.55 151.52,128.55 153.39,130.42 153.39,130.99 153.06,131.32 153.06,131.82 U1.BK3
  BOTTOM w0.102: JDIMM1.34 140.82,80.85 141.09,81.12 141.09,84.08 140.82,84.35 140.55,84.35 v1(140.37,84.53)
  BOTTOM w0.147: 151.07,128.2 150.05,127.18 149.22,127.18 148.86,127.54 v1(148.7,127.54)
M_A_DQS_DP2: length 74.7
  TOP w0.102: JDIMM2.55 144.4,80.37 144.35,80.42 144.16,80.42 144.11,80.48 144.11,80.71 144.2,80.8 144.75,80.8 145.54,81.59 145.54,82.91 145.89,83.26 146.08,83.26 146.21,83.13 v1(146.21,83.01)
  IN03 w0.076: 150.95,126.08 151.1,126.23 151.1,126.38 150.99,126.49 v1(150.78,126.49)
  IN03 w0.145: v1(146.21,83.01) 146.13,83.09 145.57,83.09 145.26,83.4 145.26,85.8 144.11,86.95 143.74,86.95 142.47,88.23 141.96,88.23 141.55,88.64 141.55,90.57 141.85,90.87 142.13,90.87 142.26,91 142.26,91.62 142.13,91.74 141.85,91.74 141.55,92.05 141.55,93.89 139.32,96.12 139.32,106.01 139.04,106.29 139.04,107.34 139.32,107.62 139.32,108.34 139.04,108.62 139.04,109.67 139.32,109.95 139.32,110.67 139.04,110.95 139.04,112.01 139.32,112.28 139.32,112.81 144.09,117.58 144.09,119.22 144.75,119.88 150.95,126.08
  BOTTOM w0.076: U1.BF3 155.62,131.93 155.62,131.71 155.52,131.61 155.52,130.69 155.78,130.44 155.78,129.46 154.39,128.07 154.24,128.07 154.12,127.96 154.12,127.83 154.11,127.82
  BOTTOM w0.102: JDIMM1.55 146.07,86.3 146.17,86.2 146.52,86.2 147.06,85.66 147.06,83.61 146.64,83.19 146.39,83.19 v1(146.21,83.01)
  BOTTOM w0.147: v1(150.78,126.49) 151,126.49 151.28,126.22 152.5,126.22 154.11,127.82
M_A_DQS_DP3: length 74.1
  TOP w0.102: v1(150.27,84.28) 150.27,84.18 150.1,84.02 149.87,84.02 149.75,83.9 149.48,83.9 149.28,84.1 149.28,84.61 149.41,84.74 149.62,84.74 149.87,84.98 149.87,85.53 149.62,85.78 149.48,85.78 149.36,85.91 149.36,86.5 149.41,86.56 149.59,86.56 149.65,86.62 149.65,87.57 JDIMM2.76
  IN03 w0.076: v1(156.05,127.32) 156.32,127.32 156.48,127.17 156.48,127.08 156.35,126.95 156.27,126.95 156.18,126.86 156.18,126.74 156.27,126.65 156.41,126.65 156.48,126.58 156.48,126.41 156.41,126.34 156,126.34 155.9,126.24 155.9,126.09 155.98,126.01 155.98,125.91 155.74,125.67 155.63,125.67 155.62,125.66
  IN03 w0.145: v1(150.27,84.28) 150.38,84.18 150.58,84.18 150.7,84.3 150.7,85.8 148.33,88.17 148.16,88.17 147.47,88.85 147.47,90.67 147.77,90.96 148.48,90.96 148.61,91.09 148.61,91.7 148.48,91.83 147.79,91.83 147.47,92.15 147.47,94.13 145.57,96.03 145.57,102.75 145.23,103.08 145.23,104.03 145.57,104.37 145.57,104.67 145.42,104.81 145.09,104.81 144.75,105.16 144.75,105.93 145.09,106.28 145.42,106.28 145.57,106.42 145.57,107 145.42,107.15 145.09,107.15 144.75,107.49 144.75,108.26 145.09,108.61 145.42,108.61 145.57,108.75 145.57,113.13 148.59,116.15 148.59,118.63 154.01,124.04 155.62,125.66
  BOTTOM w0.076: 158.3,130 158.21,130.09 158.21,130.33 158.03,130.51 158.03,131.83 158.32,132.12 U1.BC3
  BOTTOM w0.102: v1(150.27,84.28) 150.47,84.08 151.02,84.08 151.32,83.78 JDIMM1.76
  BOTTOM w0.147: v1(156.05,127.32) 156.27,127.32 156.54,127.05 157.6,127.05 158.17,127.62 158.3,127.75 158.3,130
M_A_DQS_DP4: length 72
  TOP w0.102: JDIMM2.179 177.4,80.17 178.67,81.44 180.04,81.44 180.49,81.89 180.49,83.62 180.26,83.84 179.92,83.84 v1(179.74,84.03)
  IN03 w0.076: v1(175.2,126.2) 175.31,126.09 175.42,126.09 175.62,126.29 175.87,126.29 176.64,125.52 176.64,125.16 176.84,124.96 176.94,124.96 176.96,124.95
  IN03 w0.145: v1(179.74,84.03) 179.56,83.85 179.41,83.85 179.28,83.98 179.28,93.89 182.26,96.87 182.26,110.61 182.4,110.76 182.6,110.76 182.95,111.1 182.95,111.88 182.6,112.22 182.4,112.22 182.26,112.37 182.26,112.95 182.4,113.09 182.6,113.09 182.92,113.41 182.92,114.24 182.6,114.55 182.4,114.55 182.26,114.7 182.26,115.28 182.4,115.42 182.6,115.42 182.92,115.74 182.92,116.57 182.6,116.89 182.4,116.89 182.26,117.03 182.26,117.61 182.4,117.75 182.6,117.75 182.92,118.07 182.92,118.9 182.6,119.22 182.4,119.22 182.26,119.36 182.26,119.65 176.96,124.95
  BOTTOM w0.076: U1.AB3 175.29,132.21 175.38,132.21 175.48,132.11 175.48,130.6 175.71,130.37 175.71,130.19 175.69,130.17 175.63,130.17 175.63,130.16 175.63,130.15
  BOTTOM w0.102: v1(179.74,84.03) 179.74,83.86 179.67,83.79 179.56,83.79 179.18,83.41 179.18,83.32 179.06,83.19 178.77,83.19 178.65,83.32 178.65,83.85 178.8,84 179.11,84 179.33,84.22 179.33,85.43 179.09,85.68 178.65,85.68 178.5,85.82 178.5,86.01 178.57,86.08 178.65,86.08 178.84,86.27 178.84,86.55 179.07,86.78 JDIMM1.179
  BOTTOM w0.147: v1(175.2,126.2) 175.42,126.2 175.63,126.4 175.63,130.15
