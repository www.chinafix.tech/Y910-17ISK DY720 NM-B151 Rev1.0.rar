# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CMDA6: length 28.8
  BOTTOM w0.102: G2.AC50 256.5,147.78 256.5,148.28 256.77,148.55 256.77,154.01
  BOTTOM w0.122: U48.J5 258.16,171.15 257.58,170.57 257.58,164.44 258.38,163.64 258.38,163.24 258.68,162.95 260.67,162.95 260.99,162.62 260.99,158.24 259.74,156.98 259.74,156.98 256.77,154.01
CMDA7: length 29.1
  BOTTOM w0.102: 256.49,154.11 256.49,148.7 256.19,148.4 G2.AC51
  BOTTOM w0.122: 256.49,154.11 259.23,156.86 259.23,157.19 260.49,158.45 260.49,161.68 259.73,162.45 258.39,162.45 257.86,162.98 257.86,163.74 257.31,164.29 257.31,171 257.86,171.55 258.91,171.55 U48.J4
CMDA8: length 27.7
  BOTTOM w0.122: U48.H5 257.81,171.95 257.01,171.15 257.01,163.91 257.34,163.58 257.34,162.75 258.15,161.94 259.41,161.94 259.99,161.37 259.99,158.66 258.73,157.41 258.73,156.73 256.19,154.19 G2.AC52
CMDA9: length 31.2
  BOTTOM w0.122: G2.AC49 255.84,147.12 255.84,154.22 258.23,156.61 258.23,157.64 259.49,158.9 259.49,161.05 259.1,161.44 257.94,161.44 256.71,162.67 256.71,171.35 257.71,172.35 258.91,172.35 U48.H4
CMDA10: length 30
  BOTTOM w0.122: G2.AD52 255.49,154.25 257.73,156.49 257.73,157.87 258.98,159.13 258.98,160.68 258.83,160.84 257.68,160.84 256.21,162.31 256.21,163.49 256.41,163.69 256.41,171.55 255.61,172.35 253.31,172.35 U48.G12
CMDA11: length 27.6
  BOTTOM w0.102: G2.AD51 255.49,148.4 255.17,148.72 255.17,150.13
  BOTTOM w0.122: 255.17,150.13 255.17,150.14 255.17,154.32 257.22,156.37 257.22,158.09 258.05,158.91 258.05,160.14 257.87,160.32 257.49,160.32 255.71,162.1 255.71,163.77 256.11,164.17 256.11,171.2 255.36,171.95 U48.H10
CMDA12: length 28
  BOTTOM w0.102: G2.AD50 255.49,147.71 255.14,148.06 255.14,148.37 254.91,148.6 254.91,154.43
  BOTTOM w0.122: 254.91,154.43 256.72,156.25 256.72,158.33 256.85,158.46 256.85,160.02 255.16,161.7 255.16,163.72 255.81,164.37 255.81,171 255.26,171.55 254.11,171.55 U48.H11
CMDA13: length 26.9
  BOTTOM w0.102: 254.66,154.57 254.66,148.54 254.44,148.32 254.44,147.82 G2.AF50
  BOTTOM w0.122: U48.K11 254.11,170.75 254.76,170.75 254.86,170.65 255.26,170.65 255.51,170.4 255.51,164.5 254.66,163.65 254.66,160.84 256.22,159.28 256.22,156.12 254.66,154.57
CMDA14: length 24.6
  BOTTOM w0.102: 254.4,154.69 254.4,148.72 254.09,148.41 G2.AF51
  BOTTOM w0.122: U48.K10 254.91,170.35 255.21,170.05 255.21,164.62 254.01,163.42 254.01,160.78 255.71,159.07 255.71,156 254.4,154.69
CMDA15: length 25.2
  BOTTOM w0.122: U48.L12 253.31,169.95 254.66,169.95 254.91,169.7 254.91,164.65 254.58,164.32 253.99,164.32 253.5,163.83 253.5,160.56 255.21,158.86 255.21,155.88 254.08,154.75 254.08,149.57 254.09,149.57 G2.AF52
CMDA16: length 40.9
  BOTTOM w0.102: 248.56,150.95 248.63,150.89 248.63,148.57 248.84,148.37 248.84,147.97 249.19,147.62 G2.AN50
  BOTTOM w0.122: U2022.L3 234.48,172.35 233.07,172.35 232.98,172.45 231.8,172.45 230.79,171.44 230.79,160.84 236.37,155.26 239.55,155.26 243.47,151.34 248.18,151.34 248.56,150.95
CMDA17: length 39.2
  TOP w0.122: R2197.1 234.44,171.58 v3(234.48,171.55)
  BOTTOM w0.102: G2.AN51 249.19,148.4 248.87,148.72 248.87,151.16 248.8,151.23
  BOTTOM w0.122: 248.8,151.23 248.44,151.59 243.93,151.59 239.61,155.92 236.74,155.92 231.33,161.33 231.33,170.76 232.12,171.55 v3(234.48,171.55) U2022.J3
CMDA18: length 36.1
  TOP w0.122: R2193.1 233.48,170.56 v3(233.68,170.75)
  BOTTOM w0.102: 249.09,151.42 249.19,151.32 G2.AN52
  BOTTOM w0.122: 249.09,151.42 248.66,151.84 244.4,151.84 239.69,156.55 236.95,156.55 231.85,161.64 231.85,170.11 232.46,170.72 233.65,170.72 v3(233.68,170.75) U2022.J2
CMDA19: length 36.6
  BOTTOM w0.122: U2022.G3 234.51,169.91 233.01,169.91 232.38,169.28 232.38,161.98 237.18,157.18 239.78,157.18 244.86,152.1 248.91,152.1 249.54,151.48 249.54,147.12 G2.AM49
CMDA20: length 32.7
  BOTTOM w0.122: U2022.H5 236.88,169.94 236.88,164.64 236.55,164.3 235.87,164.3 235.13,163.56 235.13,159.95 237.37,157.71 239.96,157.71 245.29,152.38 249.25,152.38 249.89,151.75 G2.AM52
CMDA21: length 36.5
  BOTTOM w0.102: G2.AM51 249.89,148.42 250.19,148.73 250.19,151.96 249.86,152.29
  BOTTOM w0.122: 249.86,152.29 249.55,152.59 249.55,156.14 247.36,158.33 237.92,158.33 236.41,159.84 236.41,160.64 235.64,161.42 235.64,163.54 236.01,163.91 236.52,163.91 237.14,164.53 237.14,170.24 236.63,170.75 236.07,170.75 U2022.H4
CMDA22: length 36.2
  BOTTOM w0.102: 250.14,152.53 250.44,152.23 250.44,148.52 250.24,148.32 250.24,148.04 249.89,147.69 G2.AM50
  BOTTOM w0.122: 250.14,152.53 250.05,152.62 250.05,156.39 247.62,158.83 239.06,158.83 236.14,161.75 236.14,163.45 236.34,163.66 236.68,163.66 237.43,164.41 237.43,170.6 236.88,171.15 U2022.J5
CMDA23: length 37.4
  BOTTOM w0.102: 250.56,152.84 250.56,152.61 250.7,152.47 250.7,148.6 250.94,148.37 250.94,147.97 251.29,147.62 G2.AK50
  BOTTOM w0.122: U2022.J4 236.07,171.55 237.18,171.55 237.72,171 237.72,164.37 236.64,163.29 236.64,162.2 239.5,159.34 247.87,159.34 250.56,156.65 250.56,152.84
CMDA24: length 36
  BOTTOM w0.102: 250.88,152.72 250.97,152.63 250.97,148.75 251.29,148.43 G2.AK51
  BOTTOM w0.122: 250.88,152.72 250.87,152.73 250.87,157.11 248.13,159.85 239.8,159.85 237.14,162.5 237.14,163.32 238,164.17 238,171.23 237.27,171.95 U2022.K5
CMDA25: length 36.6
  BOTTOM w0.122: U2022.K4 236.07,172.35 237.43,172.35 238.3,171.47 238.3,164.05 237.65,163.39 237.65,162.77 240.07,160.35 248.34,160.35 251.38,157.31 251.38,155.68 251.28,155.58 251.28,150.91 251.29,150.91 G2.AK52
CMDA26: length 39.6
  BOTTOM w0.122: G2.AJ49 251.65,147.1 251.65,150.86 251.65,150.86 251.65,155.13 251.88,155.36 251.88,157.52 248.54,160.86 240.3,160.86 238.15,163.02 238.15,163.55 238.56,163.97 238.56,171.33 239.58,172.35 241.67,172.35 U2022.L12
CMDA27: length 35
  BOTTOM w0.122: G2.AJ52 251.99,155.01 252.38,155.41 252.38,157.74 248.75,161.37 240.51,161.37 238.65,163.23 238.65,163.51 238.84,163.69 238.84,171.11 239.4,171.67 239.68,171.95 U2022.K10
CMDA28: length 36.2
  BOTTOM w0.102: 252.29,150.34 252.29,148.71 251.99,148.4 G2.AJ51
  BOTTOM w0.122: U2022.K11 240.88,171.55 239.73,171.55 239.16,170.98 239.16,163.44 240.52,162.07 248.76,162.07 252.89,157.95 252.89,155.48 252.29,154.89 252.29,150.34
CMDA29: length 36.2
  BOTTOM w0.102: G2.AJ50 251.99,147.69 252.34,148.04 252.34,148.32 252.56,148.54 252.56,150.29 252.61,150.34
  BOTTOM w0.122: 252.61,150.34 252.61,154.77 253.39,155.56 253.39,158.16 248.97,162.58 240.74,162.58 239.45,163.86 239.45,170.33 239.78,170.65 240.18,170.65 240.28,170.75 240.88,170.75 U2022.H11
CMDA30: length 34.7
  BOTTOM w0.102: 252.86,150.12 252.82,150.08 252.82,148.59 253.04,148.37 253.04,148.05 253.39,147.7 G2.AG50
  BOTTOM w0.122: U2022.H10 240.14,170.35 239.76,169.97 239.76,164.27 240.95,163.08 249.18,163.08 253.89,158.37 253.89,155.63 252.88,154.63 252.88,150.15 252.86,150.12
CMDA31: length 35.2
  BOTTOM w0.102: 253.14,149.88 253.08,149.83 253.08,148.7 253.39,148.39 G2.AG51
  BOTTOM w0.122: 253.14,149.88 253.16,149.9 253.16,154.49 254.4,155.72 254.4,158.58 249.39,163.58 241.16,163.58 240.08,164.67 240.08,169.7 240.33,169.95 241.68,169.95 U2022.G12
CMDB0: length 31.4
  BOTTOM w0.102: G2.B35 271.07,136.97 271.39,136.65 274.95,136.65 275.06,136.54
  BOTTOM w0.122: U2023.G3 295.3,147.34 295.3,145.89 295.45,145.74 295.45,144.94 294.16,143.65 287.48,143.65 281.31,137.47 278.53,137.47 277.38,136.33 275.27,136.33 275.06,136.54
CMDB1: length 32.3
  TOP w0.122: v3(294.5,147.34) 294.54,147.29 v1(294.54,146.51) 294.54,144.82 R2198.1
  BOTTOM w0.122: U2023.J3 v3(294.5,147.34) 294.5,145.06 293.59,144.15 287.27,144.15 281.09,137.98 278.31,137.98 277.17,136.83 275.38,136.83 275.19,137.02 271.64,137.02 G2.A35
CMDB2: length 30.3
  TOP w0.122: R2194.1 293.47,146.31 v3(293.7,146.54)
  BOTTOM w0.122: G2.D35 269.85,137.34 276.96,137.34 278.1,138.48 280.88,138.48 287.06,144.65 293.05,144.65 293.66,145.27 293.66,145.7 293.7,145.74 293.7,146.53 v3(293.7,146.54) U2023.J2
CMDB3: length 26.7
  BOTTOM w0.122: G2.A36 276.58,137.67 277.89,138.98 280.67,138.98 286.98,145.29 292.25,145.29 292.9,145.94 292.9,147.34 U2023.L3
CMDB4: length 29.4
  BOTTOM w0.102: 276.56,138.19 276.35,137.98 271.4,137.98 271.09,137.67 G2.B36
  BOTTOM w0.122: U2023.K5 292.92,149.72 287.51,149.72 287.34,149.55 287.34,149.37 286.23,148.26 286.23,145.26 280.5,139.53 277.9,139.53 276.56,138.19
CMDB5: length 31.8
  BOTTOM w0.102: G2.C36 270.43,137.67 270.78,138.02 271.09,138.02 271.31,138.24 276.05,138.24 276.34,138.52
  BOTTOM w0.122: 276.34,138.52 277.84,140.03 280.29,140.03 285.73,145.47 285.73,148.46 286.24,148.97 286.45,148.97 287.47,149.99 293.36,149.99 293.7,149.64 293.7,148.94 U2023.K4
CMDB6: length 31.4
  BOTTOM w0.102: G2.C38 270.54,138.72 271.04,138.72 271.26,138.49 275.55,138.49 275.67,138.61
  BOTTOM w0.122: 275.67,138.61 277.59,140.53 280.08,140.53 285.23,145.68 285.23,148.67 286.03,149.47 286.46,149.47 287.27,150.29 293.6,150.29 294.1,149.78 U2023.J5
CMDB7: length 32.4
  BOTTOM w0.102: G2.B38 271.04,139.07 271.36,138.75 275.21,138.75 275.3,138.83
  BOTTOM w0.122: 275.3,138.83 277.5,141.03 279.86,141.03 284.72,145.89 284.72,148.88 285.82,149.98 286.47,149.98 287.08,150.59 294.1,150.59 294.5,150.19 294.5,148.94 U2023.J4
CMDB8: length 31.3
  BOTTOM w0.122: U2023.H5 294.9,150.52 294.54,150.89 286.93,150.89 286.52,150.48 285.61,150.48 284.22,149.09 284.22,146.11 279.65,141.54 277.42,141.54 274.95,139.07 G2.A38
CMDB9: length 35.1
  BOTTOM w0.122: G2.D38 269.84,139.42 274.82,139.42 277.44,142.04 279.44,142.04 283.72,146.32 283.72,149.3 285.4,150.98 286.52,150.98 286.72,151.19 294.71,151.19 295.3,150.6 295.3,148.94 U2023.H4
CMDB10: length 33.4
  BOTTOM w0.122: U2023.G12 295.3,154.54 295.3,152.32 294.47,151.49 285.19,151.49 283.21,149.52 283.21,146.53 279.23,142.54 277.31,142.54 274.53,139.77 G2.A39
CMDB11: length 32.1
  BOTTOM w0.102: 274.6,140.29 274.41,140.1 271.42,140.1 271.09,139.77 G2.B39
  BOTTOM w0.122: 274.6,140.29 277.35,143.05 279.02,143.05 282.71,146.74 282.71,149.74 284.96,151.99 286.51,151.99 286.71,151.79 294.27,151.79 294.9,152.42 U2023.H10
CMDB12: length 33.5
  BOTTOM w0.102: 274.43,140.55 274.24,140.36 271.33,140.36 271.09,140.12 270.69,140.12 270.34,139.77 G2.C39
  BOTTOM w0.122: U2023.H11 294.5,153.74 294.5,152.45 294.14,152.09 286.98,152.09 286.57,152.49 284.75,152.49 282.21,149.95 282.21,146.96 278.8,143.55 277.42,143.55 274.43,140.55
CMDB13: length 32.6
  BOTTOM w0.102: G2.C41 270.54,140.82 271.04,140.82 271.26,140.59 273.99,140.59 274.18,140.78
  BOTTOM w0.122: U2023.K11 293.7,153.74 293.7,153.14 293.6,153.04 293.6,152.67 293.31,152.39 287.33,152.39 286.72,153 284.54,153 281.71,150.16 281.71,147.17 278.59,144.05 277.45,144.05 274.18,140.78
CMDB14: length 30.3
  BOTTOM w0.102: 273.85,140.99 273.68,140.82 271.41,140.82 271.06,141.17 G2.B41
  BOTTOM w0.122: 273.85,140.99 277.42,144.55 278.38,144.55 281.2,147.38 281.2,150.37 284.33,153.5 286.63,153.5 287.47,152.67 292.86,152.67 293.3,153.11 U2023.K10
CMDB15: length 31
  BOTTOM w0.122: U2023.L12 292.88,154.56 292.88,153.17 292.65,152.94 287.6,152.94 286.97,153.57 286.97,153.84 286.81,154 284.12,154 280.7,150.58 280.7,147.59 278.17,145.06 277.41,145.06 273.51,141.17 G2.A41
CMDB16: length 33.3
  BOTTOM w0.102: 272.43,147.22 272.18,146.97 271.94,146.97 271.79,147.12 271.24,147.12 G2.B49
  BOTTOM w0.122: U55.L3 269.53,172.35 268.13,172.35 268.03,172.45 267.23,172.45 265.78,170.99 265.78,157.07 269.98,152.87 269.98,151.03 272.43,148.59 272.43,147.22
CMDB17: length 35.1
  TOP w0.122: R2199.1 267.15,170.32 267.5,170.67 267.93,170.67 v2(268.81,171.55) v3(269.53,171.55)
  BOTTOM w0.122: U55.J3 v3(269.53,171.55) 267.47,171.55 266.29,170.37 266.29,157.28 270.75,152.82 270.75,151 272.8,148.95 272.8,147.09 272.22,146.52 271.84,146.52 271.59,146.77 G2.A49
CMDB18: length 31.3
  TOP w0.122: v3(268.73,170.75) 268.54,170.56 R2196.1
  BOTTOM w0.122: U55.J2 v3(268.73,170.75) 267.93,170.75 267.88,170.7 267.43,170.7 266.8,170.07 266.8,157.49 271.51,152.77 271.51,151.05 273.16,149.41 273.16,147.04 272.33,146.22 271.74,146.22 G2.A48
CMDB19: length 32.5
  BOTTOM w0.122: G2.D47 269.84,145.72 272.34,145.72 273.5,146.87 273.5,149.54 273.1,149.94 273.1,151.9 267.35,157.65 267.35,169.17 268.13,169.95 269.53,169.95 U55.G3
CMDB20: length 29
  BOTTOM w0.122: U55.H5 271.91,169.97 271.91,164.56 271.74,164.39 271.56,164.39 270.06,162.89 270.06,155.66 273.6,152.11 273.6,149.96 273.88,149.68 273.88,146.83 272.42,145.37 G2.A47
CMDB21: length 31.8
  BOTTOM w0.102: G2.B47 271.04,145.37 271.36,145.05 272.56,145.05 272.74,145.22
  BOTTOM w0.122: U55.H4 271.13,170.75 271.83,170.75 272.18,170.41 272.18,164.51 271.16,163.5 271.16,163.28 270.61,162.73 270.61,155.82 274.1,152.33 274.1,150 274.27,149.83 274.27,146.75 272.74,145.22
CMDB22: length 32.6
  BOTTOM w0.102: G2.C47 270.43,145.37 270.78,145.02 271.04,145.02 271.28,144.77 272.74,144.77 272.92,144.96
  BOTTOM w0.122: U55.J5 271.98,171.15 272.48,170.65 272.48,164.32 271.67,163.51 271.67,163.07 271.13,162.54 271.13,156.01 274.61,152.54 274.61,146.64 272.92,144.96
CMDB23: length 34.8
  BOTTOM w0.102: 273.13,144.7 272.96,144.52 271.21,144.52 271.01,144.32 270.77,144.32 270.42,143.97 G2.C45
  BOTTOM w0.122: 273.13,144.7 275,146.56 275,149.1 275.11,149.21 275.11,152.75 271.65,156.21 271.65,162.34 272.17,162.86 272.17,163.52 272.78,164.12 272.78,171.15 272.38,171.55 271.13,171.55 U55.J4
CMDB24: length 34.2
  BOTTOM w0.102: 273.36,144.49 273.15,144.27 271.39,144.27 271.09,143.97 G2.B45
  BOTTOM w0.122: U55.K5 272.71,171.95 273.08,171.59 273.08,163.97 272.67,163.57 272.67,162.64 272.16,162.13 272.16,156.42 275.61,152.96 275.61,149.12 275.39,148.9 275.39,146.51 273.36,144.49
CMDB25: length 35.5
  BOTTOM w0.122: G2.A45 273.25,143.97 276.24,146.96 276.24,149.05 276.12,149.17 276.12,153.17 272.66,156.63 272.66,161.92 273.17,162.43 273.17,163.57 273.38,163.77 273.38,171.76 272.79,172.35 271.13,172.35 U55.K4
CMDB26: length 38.4
  BOTTOM w0.122: U55.L12 276.73,172.35 274.51,172.35 273.68,171.51 273.68,161.38 276.62,158.44 276.62,146.88 273.36,143.63 269.85,143.63 G2.D44
CMDB27: length 34.5
  BOTTOM w0.122: U55.K10 274.61,171.95 273.98,171.32 273.98,163.76 274.18,163.55 274.18,161.59 277.13,158.64 277.13,147.93 276.97,147.77 276.97,146.84 273.4,143.27 G2.A44
CMDB28: length 36.5
  BOTTOM w0.102: 273.68,143.11 273.54,142.96 271.41,142.96 271.11,143.27 G2.B44
  BOTTOM w0.122: 273.68,143.11 277.35,146.78 277.35,147.42 277.64,147.7 277.64,158.85 274.68,161.8 274.68,163.62 274.28,164.03 274.28,171.19 274.64,171.55 275.93,171.55 U55.K11
CMDB29: length 36.9
  BOTTOM w0.102: 273.89,142.89 273.7,142.7 271.26,142.7 271.04,142.92 270.54,142.92 G2.C44
  BOTTOM w0.122: U55.H11 275.93,170.75 275.33,170.75 275.23,170.65 274.86,170.65 274.58,170.36 274.58,164.38 275.19,163.77 275.19,162.01 278.21,158.99 278.21,147.44 277.63,146.87 277.63,146.63 273.89,142.89
CMDB30: length 35.9
  BOTTOM w0.102: 274.06,142.58 273.93,142.44 271.26,142.44 271.04,142.22 270.79,142.22 270.44,141.87 G2.C42
  BOTTOM w0.122: 274.06,142.58 278.71,147.23 278.71,159.2 275.69,162.23 275.69,163.68 274.86,164.51 274.86,169.91 275.3,170.35 U55.H10
CMDB31: length 37.2
  BOTTOM w0.102: G2.B42 271.09,141.87 271.39,142.17 274.06,142.17 274.24,142.35
  BOTTOM w0.122: 274.24,142.35 277.48,145.58 277.78,145.58 279.21,147.01 279.21,159.41 276.19,162.44 276.19,163.86 276.03,164.02 275.76,164.02 275.13,164.65 275.13,169.7 275.36,169.93 276.75,169.93 U55.G12
CMDC0: length 38.7
  BOTTOM w0.102: 271.52,119.53 271.35,119.53 271.07,119.82 270.54,119.82 G2.C11
  BOTTOM w0.122: 271.52,119.53 273.32,119.53 273.85,119 273.85,117.88 274.6,117.12 274.6,111.58 278.89,107.3 282.87,107.3 284.17,108.6 294.29,108.6 295.58,109.89 295.58,110.68 295.43,110.83 295.43,112.28 U2025.G3
CMDC1: length 39.4
  TOP w0.122: v3(294.62,112.29) 294.62,111.57 v2(294.74,111.46) 294.74,110.85 294.71,110.82 294.71,109.73 R2202.1
  BOTTOM w0.102: G2.B11 271.16,120.17 271.47,119.85 271.74,119.85
  BOTTOM w0.122: U2025.J3 v3(294.62,112.29) 294.63,112.29 294.63,110.01 293.72,109.1 283.95,109.1 282.66,107.81 279.1,107.81 275.12,111.79 275.12,117.16 274.16,118.12 274.16,119.14 273.45,119.85 271.74,119.85
CMDC2: length 30
  TOP w0.122: R2206.1 293.59,111.26 v3(293.82,111.49)
  BOTTOM w0.122: G2.A11 273.58,120.17 274.46,119.28 274.46,118.43 275.56,117.33 278.01,117.33 285.03,110.32 286.23,110.32 286.94,109.6 293.17,109.6 293.79,110.22 293.79,110.65 293.83,110.69 293.83,111.48 v3(293.82,111.49) 294.22,111.88 U2025.J2
CMDC3: length 30.6
  BOTTOM w0.122: G2.D11 269.84,120.52 273.72,120.52 274.81,119.43 274.81,118.68 275.57,117.92 278.15,117.92 285.24,110.82 286.48,110.82 287.07,110.23 292.38,110.23 293.03,110.88 293.03,112.29 U2025.L3
CMDC4: length 25.8
  BOTTOM w0.122: G2.A12 273.86,120.87 276.21,118.52 278.26,118.52 283.36,113.42 286.82,113.42 287.47,114.07 287.47,114.43 287.7,114.66 293.05,114.66 U2025.K5
CMDC5: length 27.9
  BOTTOM w0.102: G2.B12 271.09,120.87 271.41,121.19 273.96,121.19 274.11,121.04
  BOTTOM w0.122: U2025.K4 293.83,113.88 293.83,114.59 293.49,114.93 287.62,114.93 286.61,113.92 283.6,113.92 278.49,119.02 276.13,119.02 274.11,121.04
CMDC6: length 28.2
  BOTTOM w0.102: 274.24,121.35 274.15,121.44 271.31,121.44 271.09,121.22 270.71,121.22 270.36,120.87 G2.C12
  BOTTOM w0.122: 274.24,121.35 276.07,119.53 278.78,119.53 283.88,114.42 286.77,114.42 287.58,115.23 293.73,115.23 294.23,114.73 U2025.J5
CMDC7: length 29.7
  BOTTOM w0.102: 274.38,121.6 274.29,121.69 271.26,121.69 271.04,121.92 270.54,121.92 G2.C14
  BOTTOM w0.122: U2025.J4 294.63,113.88 294.63,115.13 294.23,115.53 287.5,115.53 286.9,114.93 284.25,114.93 279.15,120.03 275.96,120.03 274.38,121.6
CMDC8: length 28.5
  BOTTOM w0.102: G2.B14 271.11,122.27 271.42,121.95 274.44,121.95 274.59,121.8
  BOTTOM w0.122: 274.59,121.8 275.86,120.53 279.36,120.53 284.47,115.43 286.98,115.43 287.38,115.83 294.67,115.83 295.03,115.47 U2025.H5
CMDC9: length 29
  BOTTOM w0.122: U2025.H4 295.43,113.88 295.43,115.55 294.84,116.13 286.85,116.13 286.65,115.93 284.68,115.93 279.57,121.03 275.76,121.03 274.53,122.27 G2.A14
CMDC10: length 31.8
  BOTTOM w0.122: U2025.G12 295.43,119.48 295.43,117.27 294.59,116.43 285.75,116.43 285.31,116.88 284.87,116.88 280.21,121.54 275.67,121.54 274.59,122.62 269.84,122.62 G2.D14
CMDC11: length 27.2
  BOTTOM w0.122: U2025.H10 295.03,117.37 294.4,116.73 287.11,116.73 286.91,116.94 286.13,116.94 281.03,122.04 275.6,122.04 274.67,122.97 G2.A15
CMDC12: length 28.5
  BOTTOM w0.102: 274.94,123.13 274.79,123.28 271.4,123.28 271.09,122.97 G2.B15
  BOTTOM w0.122: 274.94,123.13 275.53,122.54 281.27,122.54 286.37,117.44 286.83,117.44 287.23,117.03 294.27,117.03 294.63,117.4 294.63,118.68 U2025.H11
CMDC13: length 28.1
  BOTTOM w0.102: 275.2,123.35 275,123.55 271.24,123.55 271.01,123.32 270.74,123.32 270.39,122.97 G2.C15
  BOTTOM w0.122: 275.2,123.35 275.5,123.05 281.48,123.05 286.59,117.94 286.85,117.94 287.46,117.33 293.44,117.33 293.73,117.62 293.73,117.98 293.83,118.08 293.83,118.68 U2025.K11
CMDC14: length 26.5
  BOTTOM w0.102: 275.32,123.78 275.28,123.81 271.22,123.81 271.01,124.02 270.76,124.02 270.41,124.37 G2.C17
  BOTTOM w0.122: 275.32,123.78 275.54,123.55 281.71,123.55 287.64,117.61 292.99,117.61 293.43,118.06 U2025.K10
CMDC15: length 27.2
  BOTTOM w0.122: G2.B17 271.13,124.37 271.44,124.05 282.21,124.05 287.47,118.79 287.47,118.14 287.73,117.88 292.78,117.88 293.01,118.11 293.01,119.51 U2025.L12
CMDC16: length 33.8
  BOTTOM w0.102: 274.56,129.58 271.4,129.58 271.09,129.27 G2.B24
  BOTTOM w0.122: 274.56,129.58 275.53,130.56 275.53,131.7 280.69,136.86 281.6,136.86 286.56,141.82 293.96,141.82 295.14,140.64 295.34,140.64 295.53,140.45 295.53,139.82 295.43,139.72 295.43,138.32 U2024.L3
CMDC17: length 34.8
  TOP w0.122: R2203.1 293.67,140.01 294.63,139.05 v3(294.63,138.31)
  BOTTOM w0.122: U2024.J3 294.23,137.92 v3(294.63,138.31) 294.63,138.32 294.63,140.41 293.72,141.32 286.77,141.32 281.81,136.35 280.9,136.35 275.96,131.41 275.96,130.57 274.65,129.27 G2.A24
CMDC18: length 32.7
  TOP w0.122: R2207.1 293.64,139.31 v3(293.83,139.11)
  BOTTOM w0.122: U2024.J2 294.22,138.72 v3(293.83,139.11) 293.83,139.93 293.73,140.03 293.73,140.34 293.26,140.81 286.99,140.81 282.02,135.85 281.11,135.85 276.52,131.26 276.52,130.58 274.85,128.92 269.84,128.92 G2.D23
CMDC19: length 28.8
  BOTTOM w0.122: U2024.G3 293.03,138.32 293.03,139.74 292.46,140.31 287.2,140.31 282.24,135.35 281.32,135.35 277.03,131.06 277.03,130.65 274.95,128.57 G2.A23
CMDC20: length 27.2
  BOTTOM w0.102: G2.B23 271.04,128.57 271.34,128.26 275.1,128.26 275.24,128.4
  BOTTOM w0.122: U2024.H5 293.03,135.92 287.72,135.92 287.45,136.19 287.45,136.4 286.7,137.14 284.75,137.14 282.45,134.84 281.54,134.84 277.54,130.85 277.54,130.7 275.24,128.4
CMDC21: length 29.3
  BOTTOM w0.102: 275.53,128.12 275.41,128.01 271.25,128.01 271.04,128.22 270.54,128.22 G2.C23
  BOTTOM w0.122: 275.53,128.12 281.75,134.34 282.66,134.34 284.96,136.64 286.68,136.64 287.65,135.67 293.49,135.67 293.83,136.01 293.83,136.72 U2024.H4
CMDC22: length 28.7
  BOTTOM w0.102: 275.97,127.85 275.86,127.74 271.31,127.74 271.09,127.52 270.74,127.52 270.39,127.17 G2.C21
  BOTTOM w0.122: U2024.J5 294.23,135.87 293.73,135.37 287.63,135.37 286.88,136.12 285.16,136.12 282.87,133.84 281.96,133.84 275.97,127.85
CMDC23: length 29.5
  BOTTOM w0.102: G2.B21 271.1,127.17 271.42,127.48 276.31,127.48 276.44,127.6
  BOTTOM w0.122: 276.44,127.6 282.17,133.34 283.08,133.34 285.37,135.62 287.06,135.62 287.62,135.07 294.23,135.07 294.63,135.47 294.63,136.72 U2024.J4
CMDC24: length 28.2
  BOTTOM w0.122: G2.A21 276.53,127.17 277.54,128.17 277.72,128.17 282.38,132.83 283.29,132.83 283.96,133.5 284.7,133.5 286.32,135.12 287.25,135.12 287.6,134.77 294.67,134.77 295.03,135.13 U2024.K5
CMDC25: length 32.1
  BOTTOM w0.122: G2.D20 269.84,126.82 276.69,126.82 277.68,127.81 278.07,127.81 282.48,132.21 284.64,132.21 284.9,132.47 284.9,132.98 286.53,134.62 287.43,134.62 287.58,134.47 294.84,134.47 295.43,135.06 295.43,136.72 U2024.K4
CMDC26: length 30.5
  BOTTOM w0.122: U2024.L12 295.43,131.12 295.43,133.33 294.59,134.17 286.82,134.17 285.42,132.76 285.42,132.25 284.86,131.69 282.69,131.69 278.31,127.31 277.74,127.31 276.9,126.47 G2.A20
CMDC27: length 28.9
  BOTTOM w0.102: 272.58,126.15 271.35,126.15 271.04,126.47 G2.B20
  BOTTOM w0.122: 272.58,126.15 277.11,126.15 277.77,126.8 278.52,126.8 282.9,131.19 285.07,131.19 285.92,132.04 285.92,132.5 287.29,133.87 294.4,133.87 295.03,133.24 U2024.K10
CMDC28: length 30.2
  BOTTOM w0.102: G2.C20 270.19,126.47 270.54,126.12 271.04,126.12 271.25,125.9 272.19,125.9 272.28,125.82 272.43,125.82
  BOTTOM w0.122: U2024.K11 294.63,131.92 294.63,133.21 294.27,133.57 287.64,133.57 286.51,132.44 286.51,131.9 285.18,130.57 283.01,130.57 278.73,126.3 277.79,126.3 277.31,125.82 272.43,125.82
CMDC29: length 29.6
  BOTTOM w0.102: G2.C18 270.39,125.07 270.74,125.42 271.09,125.42 271.32,125.65 271.99,125.65 272.22,125.42 272.49,125.42
  BOTTOM w0.122: 272.49,125.42 277.32,125.42 277.7,125.8 279.06,125.8 283.29,130.03 285.55,130.03 286.56,131.03 286.56,131.57 287.04,132.05 287.04,132.66 287.65,133.27 293.44,133.27 293.73,132.98 293.73,132.62 293.83,132.52 293.83,131.92 U2024.H11
CMDC30: length 27.6
  BOTTOM w0.102: 272.25,125.05 272.13,125.05 271.76,125.42 271.44,125.42 271.09,125.07 270.89,125.07 G2.B18
  BOTTOM w0.122: U2024.H10 293.43,132.55 292.99,132.99 287.69,132.99 287.26,132.56 287.26,131.88 286.81,131.43 286.81,130.55 286.31,130.06 286.31,129.76 285.98,129.43 283.41,129.43 279.27,125.29 277.71,125.29 277.46,125.05 272.25,125.05
CMDC31: length 28.3
  BOTTOM w0.122: U2024.G12 293.01,131.1 293.01,132.49 292.78,132.72 287.74,132.72 287.49,132.47 287.49,131.74 287.03,131.28 287.03,130.3 286.85,130.12 286.85,129.41 285.55,128.12 282.81,128.12 279.42,124.73 271.92,124.73 G2.A18
CMDD0: length 36.6
  BOTTOM w0.102: G2.AD2 255.49,113.62 255.17,113.3 255.17,113.04 255.22,112.99 255.22,108.61 255.11,108.5
  BOTTOM w0.122: 255.11,108.5 254.19,107.59 248.98,107.59 241.27,99.87 241.27,91.59 242.82,90.04 243.6,90.04 243.87,90.32 245.27,90.32 U2026.G3
CMDD1: length 36.9
  TOP w0.122: R2204.1 242.78,90.71 243.15,91.07 244.27,91.07 v2(244.32,91.12) v3(245.27,91.12)
  BOTTOM w0.122: G2.AD1 255.49,108.45 254.11,107.08 249.2,107.08 241.78,99.66 241.78,92.26 242.92,91.12 v3(245.27,91.12) U2026.J3
CMDD2: length 34.9
  TOP w0.122: R2201.1 244.24,92.15 v3(244.47,91.92)
  BOTTOM w0.122: G2.AD4 255.85,114.9 255.85,108.39 254.04,106.58 249.42,106.58 242.29,99.44 242.29,92.75 243.12,91.92 v3(244.47,91.92) U2026.J2
CMDD3: length 31
  BOTTOM w0.122: U2026.L3 245.27,92.72 243.6,92.72 243.46,92.85 243.39,92.85 242.92,93.32 242.92,99.3 249.7,106.08 253.97,106.08 256.18,108.29 256.18,112.85 256.19,112.85 G2.AC1
CMDD4: length 29.1
  BOTTOM w0.122: U2026.K5 247.65,92.7 247.65,98.11 247.48,98.28 246.77,98.28 246.27,98.78 246.27,101.06 250.36,105.15 253.8,105.15 254.6,105.95 254.6,106.25 256.5,108.15 256.5,113.35 256.19,113.67 G2.AC2
CMDD5: length 31.2
  BOTTOM w0.102: 256.76,107.95 256.76,113.51 256.54,113.74 256.54,113.96 256.19,114.31 G2.AC3
  BOTTOM w0.122: 256.76,107.95 255.12,106.31 255.12,105.76 253.97,104.61 250.53,104.61 247.83,101.91 247.83,101.91 246.77,100.85 246.77,98.76 247,98.53 247.55,98.53 247.92,98.16 247.92,92.26 247.58,91.92 246.87,91.92 U2026.K4
CMDD6: length 30.4
  BOTTOM w0.102: G2.AA3 257.24,114.22 257.24,113.72 257.01,113.49 257.01,107.77
  BOTTOM w0.122: 257.01,107.77 255.63,106.38 255.63,105.5 254.2,104.07 250.71,104.07 247.28,100.64 247.28,99.14 248.22,98.2 248.22,92.02 247.72,91.52 U2026.J5
CMDD7: length 31.1
  BOTTOM w0.122: U2026.J4 246.87,91.12 248.12,91.12 248.52,91.52 248.52,98.25 247.91,98.86 247.91,100.56 250.89,103.54 254.5,103.54 256.13,105.17 256.13,106.43 257.26,107.56 257.26,113.32 257.59,113.64 G2.AA2
CMDD8: length 29.9
  BOTTOM w0.122: U2026.H5 248.46,90.72 248.82,91.08 248.82,98.47 248.41,98.88 248.41,100.35 250.32,102.25 253.99,102.25 256.63,104.89 256.63,106.5 257.59,107.46 G2.AA1
CMDD9: length 33.7
  BOTTOM w0.122: G2.AA4 257.94,114.92 257.94,107.37 257.13,106.57 257.13,104.38 254.5,101.75 250.53,101.75 248.92,100.14 248.92,98.91 249.12,98.71 249.12,90.91 248.53,90.32 246.87,90.32 U2026.H4
CMDD10: length 32.1
  BOTTOM w0.122: U2026.G12 252.47,90.32 250.25,90.32 249.42,91.15 249.42,99.92 250.74,101.25 254.88,101.25 257.64,104 257.64,106.64 258.29,107.29 G2.Y1
CMDD11: length 30.6
  BOTTOM w0.122: U2026.H10 250.35,90.72 249.72,91.35 249.72,98.48 249.92,98.68 249.92,99.71 250.95,100.74 255.09,100.74 258.14,103.79 258.14,106.66 258.6,107.13 258.6,113.35 258.29,113.67 G2.Y2
CMDD12: length 31.8
  BOTTOM w0.122: G2.Y3 258.29,114.42 258.64,114.07 258.64,113.67 258.86,113.45 258.86,106.85 258.64,106.63 258.64,103.58 255.31,100.24 251.16,100.24 250.43,99.5 250.43,98.75 250.02,98.34 250.02,91.48 250.38,91.12 251.67,91.12 U2026.H11
CMDD13: length 30.6
  BOTTOM w0.122: U2026.K11 251.67,91.92 251.07,91.92 250.97,92.02 250.61,92.02 250.32,92.31 250.32,98.29 250.93,98.9 250.93,99.29 251.37,99.74 255.52,99.74 259.15,103.36 259.15,113.51 259.34,113.7 259.34,114.22 G2.V3
CMDD14: length 28.7
  BOTTOM w0.122: U2026.K10 251.04,92.32 250.6,92.76 250.6,98.16 251.68,99.23 255.73,99.23 260.06,103.56 260.06,106.11 259.46,106.71 259.46,112.48 259.37,112.56 259.37,113.32 259.69,113.63 G2.V2
CMDD15: length 29.4
  BOTTOM w0.122: G2.V1 259.69,112.67 259.76,112.59 259.76,107.06 260.56,106.26 260.56,103.35 255.94,98.73 251.58,98.73 250.87,98.02 250.87,92.97 251.1,92.74 252.49,92.74 U2026.L12
CMDD16: length 33.7
  BOTTOM w0.102: 265.26,110.43 265.13,110.56 265.13,113.47 264.94,113.67 264.94,113.99 264.59,114.34 G2.L3
  BOTTOM w0.122: U60.L3 271.43,90.32 273.05,90.32 273.15,90.22 273.48,90.22 275.13,91.87 275.13,100.13 270.18,105.07 270.18,108.36 268.7,109.84 265.85,109.84 265.26,110.43
CMDD17: length 34.4
  TOP w0.122: R2205.1 272.18,91.09 v2(272.13,91.14) 272.11,91.12 v3(271.43,91.12)
  BOTTOM w0.102: 264.99,110.24 264.88,110.36 264.88,112.92 264.92,112.97 264.92,113.28 264.59,113.62 G2.L2
  BOTTOM w0.122: 264.99,110.24 265.68,109.55 268.23,109.55 269.29,108.49 269.29,105.17 274.57,99.89 274.57,92.21 273.48,91.12 v3(271.43,91.12) U60.J3
CMDD18: length 29.2
  TOP w0.122: v3(272.23,91.92) 272.33,92.02 R857.1
  BOTTOM w0.122: G2.L1 264.59,110.21 265.53,109.27 267.78,109.27 268.74,108.32 268.74,104.97 274.04,99.67 274.04,92.6 273.45,92.02 273.13,92.02 273.03,91.92 v3(272.23,91.92) U60.J2
CMDD19: length 29.9
  BOTTOM w0.122: U60.G3 271.43,92.72 272.83,92.72 273.5,93.39 273.5,99.45 268.13,104.83 268.13,108.19 267.32,108.99 265.35,108.99 264.24,110.11 264.24,114.92 G2.M4
CMDD20: length 25.7
  BOTTOM w0.122: G2.M1 263.96,113.1 263.96,109.94 265.18,108.72 266.89,108.72 267.44,108.16 267.44,104.41 270.45,101.4 270.45,98.76 269.97,98.28 269.31,98.28 269.05,98.02 269.05,92.7 U60.H5
CMDD21: length 27.6
  BOTTOM w0.102: 263.64,112.9 263.57,112.97 263.57,113.37 263.89,113.68 G2.M2
  BOTTOM w0.122: 263.64,112.9 263.64,109.81 265.02,108.44 266.46,108.44 266.89,108 266.89,104.18 269.9,101.17 269.9,98.88 269.54,98.53 269.15,98.53 268.78,98.16 268.78,92.26 269.12,91.92 269.83,91.92 U60.H4
CMDD22: length 27.5
  BOTTOM w0.102: 263.47,109.53 263.32,109.69 263.32,113.56 263.54,113.77 263.54,114.22 G2.M3
  BOTTOM w0.122: 263.47,109.53 264.85,108.16 266.02,108.16 266.38,107.79 266.38,103.97 269.39,100.96 269.39,99.09 268.48,98.18 268.48,92.02 268.98,91.52 U60.J5
CMDD23: length 28.3
  BOTTOM w0.102: G2.P3 262.49,114.35 262.81,114.03 262.81,113.72 263.07,113.46 263.07,109.49
  BOTTOM w0.122: U60.J4 269.83,91.12 268.58,91.12 268.18,91.52 268.18,98.24 268.79,98.85 268.79,100.71 265.78,103.72 265.78,106.79 263.07,109.49
CMDD24: length 27.1
  BOTTOM w0.122: G2.P2 262.49,113.64 262.8,113.33 262.8,109.34 265.22,106.91 265.22,103.53 268.29,100.47 268.29,98.79 267.88,98.39 267.88,91.08 268.24,90.72 U60.K5
CMDD25: length 27.6
  BOTTOM w0.122: U60.K4 269.83,90.32 268.17,90.32 267.58,90.91 267.58,98.69 267.78,98.89 267.78,100.26 264.68,103.36 264.68,107 262.49,109.19 G2.P1
CMDD26: length 30.4
  BOTTOM w0.122: G2.R4 262.14,114.92 262.14,109.11 263.75,107.49 263.75,103.58 267.28,100.05 267.28,91.15 266.45,90.32 264.23,90.32 U60.L12
CMDD27: length 25.8
  BOTTOM w0.122: U60.K10 266.35,90.72 266.98,91.35 266.98,98.91 266.78,99.11 266.78,99.8 263.21,103.36 263.21,107.6 261.79,109.03 G2.R1
CMDD28: length 27.1
  BOTTOM w0.122: U60.K11 265.03,91.12 266.32,91.12 266.68,91.48 266.68,98.64 266.28,99.05 266.28,99.59 262.71,103.15 262.71,107.67 261.37,109.01 261.37,113.22 261.79,113.64 G2.R2
CMDD29: length 26.8
  BOTTOM w0.122: G2.R3 261.44,114.22 261.44,113.72 261.05,113.33 261.05,108.9 262.21,107.74 262.21,102.94 265.77,99.38 265.77,98.9 266.38,98.29 266.38,92.31 266.09,92.02 265.73,92.02 265.63,91.92 265.03,91.92 U60.H11
CMDD30: length 25
  BOTTOM w0.122: G2.U3 260.39,114.31 260.74,113.96 260.74,112.49 260.73,112.48 260.73,111.53 260.74,111.53 260.74,108.77 261.71,107.8 261.71,102.55 266.1,98.16 266.1,92.76 265.66,92.32 U60.H10
CMDD31: length 25.9
  BOTTOM w0.122: G2.U2 260,113.48 260,112.99 260.41,112.59 260.41,108.67 261.2,107.88 261.2,102.26 265,98.46 265.39,98.46 265.83,98.02 265.83,92.97 265.6,92.74 264.21,92.74 U60.G12
CODEC_PD_N: length 304.6
  TOP w0.097: v1(280.26,27.26) 279.97,26.97 D19.1 ; D8.1 287.24,40.21 286.74,40.72 v1(286.48,40.72)
  IN03 w0.091: v1(280.26,27.26) 282.04,29.04 282.04,36.91 285.85,40.72 v1(286.48,40.72)
  IN05 w0.091: v1(255.21,42.02) 255.87,42.68 257.78,42.68 258.87,43.77 263.62,43.77 263.88,43.51 264.76,43.51 265.27,44.02 266.42,44.02 267.18,43.26 268.07,43.26 269.84,41.48 273.78,41.48 274.67,42.37 277.08,42.37 277.97,41.48 285.72,41.48 v1(286.48,40.72) ; v1(115.92,33.73) 115.73,33.93 111.37,33.93 111.03,33.59 86.82,33.59 86.08,32.85 79.6,32.85 79.09,33.35 76.3,33.35 75.79,32.85 72.95,32.85 70.16,30.05 68.93,30.05 66.55,32.43 58.24,32.43 53.72,36.96 53.72,41.3 47.44,47.58 44.29,47.58 43.53,48.34 42.51,48.34 41.54,49.31 36.28,49.31 v2(34.72,50.88)
  IN08 w0.091: v1(255.21,42.02) 254.96,42.02 254.53,42.45 252.84,42.45 252.6,42.21 235.65,42.21 235.3,41.86 215.5,41.86 212.5,44.86 202.74,44.86 200.12,42.24 192.48,42.24 189.83,44.89 170.53,44.89 168.47,46.95 119.56,46.95 115.54,42.93 115.54,39.45 115.03,38.94 115.03,34.62 v1(115.92,33.73)
  BOTTOM w0.076: 35.02,51.64 35.02,51.18 v2(34.72,50.88)
  BOTTOM w0.089: 35.02,51.64 34.77,51.89 U5.E6
CODEC_PD_N_R: length 19.1
  TOP w0.097: R292.1 286.74,39.12 286.84,39.23 D8.2 ; R292.1 286.23,38.54 287.13,37.63 U7.52 ; R292.1 285.77,39.12 v1(285.47,38.81) ; R338.2 v2(282.19,27.21) 282.62,27.21 v1(282.93,27.51)
  IN10 w0.091: v1(285.47,38.81) 285.21,38.56 285.21,29.67 284.96,29.42 284.96,28.65 283.81,27.51 v1(282.93,27.51)
COMP31: length 0.9
  BOTTOM w0.254: PC3439.1 PR3419.2
COMP31_NVS: length 0.9
  BOTTOM w0.254: PC3571.1 PR3444.2
COMP32: length 1
  BOTTOM w0.254: PR3417.2 308.15,92.56 PC3438.1
COMP32_NVS: length 1
  BOTTOM w0.254: PC3514.1 211.63,103.97 211.6,103.99 PR3441.2
COMP_1PH_A: length 3.7
  TOP w0.203: v1(125.24,186.92) 125.53,187.21 PU1101.18
  BOTTOM w0.254: v1(125.24,186.92) 125.24,186.77 124.58,186.11 PC1150.2 PC1149.2
COMP_3PH_A: length 6.4
  TOP w0.203: PU1101.48 125.53,196.1 125.3,196.33 125.28,196.33 v1(124.94,196.68)
  BOTTOM w0.254: PC1120.2 122.19,197.79 PC1133.2 122.17,197.74 122.58,197.34 v2(124.07,197.34) 124.28,197.34 v1(124.94,196.68)
CPU_2_PCH_TRIGGER: length 230.9
  TOP w0.097: v3(183.28,146.81) 183.02,147.06 R31.2 ; v1(175.99,53.42) 175.99,41.1 175.8,40.91 v1(175.99,40.72)
  IN08 w0.091: v1(175.99,53.42) 175.61,53.42 175.1,52.91 174.59,52.91 174.14,53.36 174.14,53.74 173.96,53.93 173.2,53.93 172.82,53.55 172.82,53.29 172.44,52.91 170.78,52.91 170.15,53.55 170.15,72.98 169.39,73.74 169.39,102.82 195.17,128.6 195.17,131.52 195.68,132.03 195.68,142.45 191.18,146.94 185.47,146.94 185.14,147.27 183.74,147.27 v3(183.28,146.81)
  IN10 w0.091: v3(250.54,57.86) 251.3,57.1 251.3,50.86 249.78,49.34 249.78,47.96 250.03,47.7 250.03,47.14 248.6,45.71 248.56,45.71 247.94,45.08 247.94,43.58 245.91,41.55 215.58,41.55 212.22,44.91 206.87,44.91 203.82,41.86 177.13,41.86 v1(175.99,40.72)
  BOTTOM w0.097: U2.AK1 249.02,57.86 v3(250.54,57.86)
CPU_2_PCH_TRIGGER_R: length 1.4
  TOP w0.097: v1(184.05,146.77) 183.94,146.88 R31.1
  BOTTOM w0.102: U1.J23 184.23,146.94 v1(184.05,146.77)
CPU_B+: length 52.9
  TOP w0.381: PR1196.1 119.55,190.2 117.32,190.2 v1(116.3,191.21)
  IN03 w0.254: v1(116.3,191.21) 116.94,191.85 116.94,195.15 119.86,198.07 126.46,198.07 128.49,200.1 131.41,200.1 132.68,198.83 132.68,196.42 136.24,192.87 141.07,192.87 141.7,192.23 153.97,192.23 v1(154.66,191.54)
  IN08 w0.254: v1(154.66,191.54) 154.6,191.6
  vias: v1(154.66,189.94) v1(154.66,188.65) v1(155.67,191.54) v1(155.67,189.94) v1(155.67,188.65) v1(156.69,191.54) v1(156.69,189.94) v1(156.69,188.65) v1(158.34,191.54) v1(158.34,189.94) v1(159.23,191.54) v1(159.23,189.94) v1(160.12,191.54) v1(160.12,189.94) v1(161.13,191.54) v1(161.13,189.94) v1(162.15,191.54) v1(162.15,189.94) v1(166.47,194.9) v1(166.47,194.26) v1(167.74,194.9) v1(167.74,194.26) v1(169.01,194.9) v1(169.01,194.26) v1(169.26,189.94) v1(170.02,191.54) v1(170.02,189.94) v1(170.91,191.54) v1(170.91,189.94) v1(171.93,191.54) v1(171.93,189.94) v1(172.94,191.54) v1(172.94,189.94) v1(179.93,189.94) v1(180.82,191.54) v1(180.82,189.94) v1(181.71,191.54) v1(181.71,189.94) v1(182.72,191.54) v1(182.72,189.94) v1(183.74,191.54) v1(183.74,189.94) v1(190.72,189.94) v1(191.61,191.54) v1(191.61,189.94) v1(192.5,191.54) v1(192.5,189.94) v1(193.52,191.54) v1(193.52,189.94) v1(194.53,191.54) v1(194.53,189.94) v1(201.65,189.94) v1(202.41,189.94) v1(203.17,189.94) v1(203.93,189.94) v1(204.69,189.94) v1(205.46,189.94) v1(212.06,171.4) v1(212.19,172.04) v1(212.31,172.67) v2(155.8,192.74) v2(174.34,192.99) v2(179.67,192.36)
CPU_CORE: length 73.8
  TOP w0.203: C1008.1 173.84,148.99 v1(173.38,148.52) 172.95,148.94 C1007.1
  TOP w0.254: v1(172.61,143.15) 172.6,143.16 172.6,143.75 C983.1
  TOP w0.305: C1015.1 176.43,143.62 v1(175.95,143.14) 175.49,143.6 C1014.1 ; C1016.1 179.17,143.74 v1(179.76,143.15) 180.29,143.68 C1017.1 ; C1010.1 182.26,141 v1(182.27,141.01) ; C1056.2 173.16,146.67 v1(173.58,147.09)
  BOTTOM w0.127: 174.43,151.88 U1.AB30 ; U1.AB30 175.06,151.88 ; U1.AB30 174.43,152.5 ; U1.P13 181.05,138.46 181.27,138.46 ; U1.P13 181.2,138.94 ; U1.P13 180.57,138.94 ; U1.P13 180.72,138.46 180.46,138.46 ; 180.57,139.59 U1.P14 ; U1.P14 181.2,138.97 ; U1.P14 180.57,138.97 ; U1.P14 181.2,139.59 ; U1.N14 182.11,139.59 ; U1.N14 181.49,139.59 ; U1.N14 181.49,138.97 ; U1.N14 182.11,138.97 ; 183.32,139.59 U1.L14 ; U1.L14 183.94,138.97 ; U1.L14 183.32,138.97 ; U1.L14 183.94,139.59 ; U1.AF36 171.88,156.43 ; U1.AF36 171.31,155.86 ; U1.AF36 171.88,155.86 ; 171.88,157.08 U1.AF37 171.88,156.51 ; 176.92,139.59 U1.W14 ; U1.W14 176.92,138.97 ; U1.W14 177.54,138.97 ; U1.W14 177.54,139.59 ; 179.16,151.88 U1.T30 ; U1.T30 179.16,152.5 ; U1.T30 179.78,152.5 ; U1.T30 179.78,151.88 ; 174.17,138.97 U1.AC14 ; U1.AC14 174.8,138.97 ; U1.AC14 174.17,139.59 ; U1.AC14 174.8,139.59 ; 183.32,138.94 U1.L13 ; U1.L13 183.32,138.32 ; U1.L13 183.94,138.94 ; U1.V14 178.45,139.59 ; U1.V14 177.83,138.97 ; U1.V14 177.83,139.59 ; 172.1,152.61 U1.AE31 ; U1.AE31 172.1,153.18 ; U1.AE31 172.67,153.18 ; 181.52,151.88 U1.N30 ; U1.N30 182.14,152.5 ; U1.N30 182.14,151.88 ; U1.N30 181.52,152.5 ; 183.98,138.97 U1.K14 ; U1.K14 184.55,139.02 184.63,139.02 184.77,138.87 U1.K13 ; U1.K14 183.98,139.59 ; U1.W30 177.42,152.5 ; U1.W30 176.79,151.88 ; U1.W30 176.79,152.5 ; U1.W30 177.42,151.88 ; U1.AD14 173.88,139.59 ; U1.AD14 173.26,139.59 ; U1.AD14 173.26,138.97 ; U1.AD14 173.88,138.97 ; 176.01,151.85 U1.Y29 ; U1.Y29 176.63,151.23 ; U1.Y29 176.63,151.85 ; 173.65,151.85 U1.AC29 ; U1.AC29 174.27,151.23 ; U1.AC29 174.27,151.85 ; 179.16,151.23 U1.T29 ; U1.T29 179.16,151.85 ; U1.T29 179.78,151.85 ; 172.1,156.51 U1.AE37 ; U1.AE37 172.67,157.08 ; U1.AE37 172.1,157.08 ; U1.AE37 172.67,156.51 ; U1.K13 184.23,138.69 184.2,138.72 v1(184.18,138.72) ; U1.K13 184.77,138.43 184.68,138.33 ; U1.N13 182.11,138.94 ; U1.N13 182.11,138.32 ; U1.N13 181.49,138.94 ; U1.N13 181.63,138.46 181.43,138.46 ; 176.79,151.85 U1.W29 ; U1.W29 177.42,151.85 ; U1.W29 176.79,151.23 ; U1.AE14 172.97,138.97 ; U1.AE14 172.34,138.97 ; U1.AE14 172.34,139.59 ; U1.AE14 172.97,139.59 ; U1.AB29 175.06,151.23 ; U1.AB29 175.06,151.85 ; U1.AB29 174.43,151.85 ; U1.AB29 174.43,151.23 ; U1.AD37 173.45,156.51 ; U1.AD37 172.88,157.08 ; U1.AD37 173.45,157.08 ; U1.AD37 172.88,156.51 ; U1.P30 181.36,152.5 ; U1.P30 180.73,151.88 ; U1.P30 181.36,151.88 ; U1.AE36 172.67,155.86 ; U1.AE36 172.1,155.86 ; U1.AE36 172.67,156.43 ; U1.AE36 172.1,156.43 ; U1.AA13 175.07,138.95 v1(174.94,138.95) ; 172.1,157.16 U1.AE38 ; U1.AE38 172.67,157.16 ; U1.AE38 172.1,157.73 ; U1.AE38 172.67,157.73 ; 172.34,138.32 U1.AE13 ; U1.AE13 172.34,138.94 ; U1.AE13 172.97,138.94 ; U1.AD38 173.45,157.16 ; U1.AD38 172.88,157.16 ; U1.AD38 173.45,157.73 ; U1.AD38 172.88,157.73 ; U1.R13 180.28,138.94 ; U1.R13 179.66,138.32 ; U1.R13 179.66,138.94 ; U1.R13 180.14,138.46 180.36,138.46 ; U1.P29 181.36,151.23 ; U1.P29 181.36,151.85 ; U1.P29 180.73,151.85 ; U1.P29 180.73,151.23 ; 176.01,152.5 U1.Y30 ; U1.Y30 176.63,151.88 ; U1.Y30 176.01,151.88 ; U1.Y30 176.63,152.5 ; U1.AD13 173.88,138.94 ; U1.AD13 173.88,138.32 ; U1.AD13 173.26,138.94 ; 172.07,151.88 U1.AE30 ; U1.AE30 172.07,152.5 ; U1.AE30 172.69,151.88 ; U1.AC30 174.27,152.5 ; U1.AC30 173.65,151.88 ; U1.AC30 174.27,151.88 ; U1.AC30 173.65,152.5 ; 178.37,151.88 U1.U30 ; U1.U30 178.99,152.5 ; U1.U30 178.37,152.5 ; U1.U30 178.99,151.88 ; 171.88,157.16 U1.AF38 171.88,157.73 ; 174.17,138.94 U1.AC13 ; U1.AC13 174.17,138.32 ; U1.AC13 174.8,138.94 ; U1.U29 178.99,151.85 ; U1.U29 178.99,151.23 ; U1.U29 178.37,151.85 ; v1(177.68,138.95) 177.82,138.95 U1.V13 178.05,138.54 177.32,138.54 U1.W13 177.55,138.95 v1(177.68,138.95)
  vias: v1(155.04,175.85) v1(155.04,175.09) v1(155.04,174.2) v1(155.04,173.31) v1(155.04,171.66) v1(155.8,171.66) v1(156.56,171.66) v1(157.32,171.66) v1(158.13,171.68) v1(158.8,171.68) v1(159.23,169.75) v1(159.48,175.85) v1(159.48,175.09) v1(159.48,174.2) v1(159.48,173.31) v1(159.48,171.66) v1(160.12,169.75) v1(160.12,167.97) v1(161.01,167.97) v1(161.01,166.45) v1(161.51,167.19) v1(161.75,157.77) v1(161.75,156.47) v1(161.75,155.82) v1(161.75,155.17) v1(161.75,154.52) v1(161.75,153.87) v1(161.75,153.22) v1(161.77,147.02) v1(161.9,151.04) v1(162.02,167.97) v1(162.02,166.45) v1(162.54,154.52) v1(162.54,153.21) v1(162.55,167.19) v1(162.63,140.99) v1(163.05,138.95) v1(163.16,167.97) v1(163.16,166.45) v1(163.32,157.79) v1(163.33,156.47) v1(163.33,152.57) v1(163.42,148.8) v1(163.62,167.21) v1(164.11,155.82) v1(164.11,154.52) v1(164.11,153.22) v1(164.21,167.97) v1(164.42,147.11) v1(164.56,166.45) v1(164.69,167.21) v1(164.67,142.35) v1(164.9,155.17) v1(164.9,153.87) v1(164.9,153.22) v1(164.9,151.04) v1(165.17,167.92) v1(165.53,166.45) v1(165.69,157.12) v1(165.69,155.82) v1(165.7,148.8) v1(165.83,167.29) v1(165.78,139.65) v1(165.8,138.95) v1(166.41,140.96) v1(166.52,166.45) v1(166.46,157.79) v1(166.48,156.47) v1(166.48,155.82) v1(166.48,155.17) v1(166.48,153.87) v1(166.48,153.22) v1(166.68,151.01) v1(166.71,138.95) v1(167.1,175.85) v1(167.1,174.96) v1(167.1,174.2) v1(167.1,173.31) v1(167.1,171.53) v1(167.1,169.88) v1(167.27,155.17) v1(167.33,150.96) v1(167.48,167.08) v1(167.86,171.53) v1(167.86,169.88) v1(167.91,147.1) v1(167.9,142.3) v1(168.01,157.82) v1(167.99,148.8) v1(168.12,167.08) v1(168.05,157.12) v1(168.05,156.47) v1(168.05,155.16) v1(168.05,153.87) v1(168.05,153.22) v1(168.5,169.88) v1(168.54,139.63) v1(168.62,141.09) v1(168.75,171.53) v1(168.75,167.08) v1(168.84,155.82) v1(168.84,155.17) v1(168.84,154.52) v1(168.84,153.22) v1(169.02,143.19) v1(169.13,169.88) v1(169.39,167.08) v1(169.64,171.53) v1(169.63,153.87) v1(169.63,152.57) v1(169.77,169.88) v1(170.02,167.08) v1(170.53,171.53) v1(170.53,169.88) v1(171.29,171.53) v1(171.29,169.88) v1(172.03,169.88) v1(171.99,157.12) v1(171.99,155.82) v1(171.99,153.21) v1(172.05,171.53) v1(172.18,175.85) v1(172.18,174.96) v1(172.18,174.2) v1(172.18,173.31) v1(172.44,142.32) v1(172.79,157.81) v1(172.78,156.47) v1(172.78,155.16) v1(173.11,138.95) v1(173.56,157.12) v1(173.56,155.82) v1(173.56,154.52) v1(173.56,153.22) v1(174.03,138.95) v1(174.09,141.18) v1(174.35,155.17) v1(174.35,153.87) v1(174.35,153.22) v1(174.35,152.57) v1(174.35,151.01) v1(175.14,157.12) v1(175.14,155.82) v1(175.93,157.8) v1(175.93,156.47) v1(175.93,155.82) v1(175.92,155.17) v1(175.93,154.52) v1(175.93,153.22) v1(175.99,142.32) v1(176.71,153.87) v1(176.71,153.22) v1(176.71,151.01) v1(176.92,140.24) v1(176.99,148.53) v1(177.09,147.09) v1(177.5,157.82) v1(177.5,156.47) v1(177.5,155.16) v1(177.5,152.57) v1(177.77,141.18) v1(177.85,140.22) v1(178.3,157.82) v1(178.29,157.12) v1(178.29,156.47) v1(178.29,155.82) v1(178.29,155.17) v1(178.29,154.52) v1(178.29,153.87) v1(178.29,153.22) v1(178.51,144.94) v1(179.04,171.78) v1(179.04,170.01) v1(179.08,155.17) v1(179.08,152.57) v1(179.08,151.01) v1(179.17,175.85) v1(179.17,174.96) v1(179.17,174.07) v1(179.17,173.18) v1(179.8,172.67) v1(179.8,171.78) v1(179.8,170.01) v1(179.85,157.85) v1(179.86,157.12) v1(179.86,156.47) v1(179.86,155.82) v1(179.86,154.52) v1(179.86,153.22) v1(180.31,167.08) v1(180.44,170.01) v1(180.43,138.95) v1(180.56,172.67) v1(180.56,171.78) v1(180.65,155.17) v1(180.65,154.52) v1(180.65,153.87) v1(180.65,153.22) v1(180.6,148.51) v1(181.02,150.96) v1(181.07,170.01) v1(181.07,167.08) v1(181.2,172.67) v1(181.2,171.78) v1(181.33,141.43) v1(181.33,140.29) v1(181.34,138.95) v1(181.44,157.78) v1(181.44,157.12) v1(181.44,156.47) v1(181.44,155.82) v1(181.44,152.57) v1(181.71,170.01) v1(181.71,167.08) v1(181.83,172.67) v1(181.83,171.78) v1(181.92,148.49) v1(181.98,147.1) v1(182.24,142.46) v1(182.34,170.01) v1(182.34,167.08) v1(182.6,172.67) v1(182.6,171.78) v1(182.98,170.01) v1(182.98,167.08) v1(183.18,138.3) v1(183.61,175.85) v1(183.61,174.96) v1(183.61,174.07) v1(183.61,173.18) v1(183.61,171.78) v1(183.61,170.01) v1(183.61,167.08) v1(184.25,167.08) v1(184.88,167.08) v1(190.22,175.85) v1(190.22,174.96) v1(190.22,174.07) v1(190.22,173.43) v1(190.22,172.67) v1(190.22,171.91) v1(190.22,171.15) v1(190.22,170.26) v1(190.22,169.5) v1(191.1,172.67) v1(191.1,171.91) v1(191.1,171.15) v1(191.1,170.26) v1(191.1,169.5) v1(191.99,172.67) v1(191.99,171.91) v1(191.99,171.15) v1(191.99,170.26) v1(191.99,169.5) v1(192.88,172.67) v1(192.88,171.91) v1(192.88,171.15) v1(192.88,170.26) v1(192.88,169.5) v1(193.77,172.67) v1(193.77,171.91) v1(193.77,171.15) v1(193.77,170.26) v1(193.77,169.5) v1(194.41,172.67) v1(194.41,171.91) v1(195.04,172.67) v1(195.04,171.91) v1(195.68,175.85) v1(195.68,174.96) v1(195.68,174.07) v1(195.68,173.43) v1(195.8,172.67) v1(195.8,171.91) v2(183.61,168.35) v3(182.22,138.95) v3(182.28,139.62)
CPU_CSREF: length 34.4
  TOP w0.254: PR907.1 284.78,180.47 v1(284.96,180.29) 285.34,180.29 285.59,180.55 PR3565.2 PC1425.2 ; v1(284.78,184.28) PR3532.1 285.16,183.21 PR3564.2 PC1424.2 ; PR914.1 284.78,177.93 v1(284.96,177.75) 285.08,177.88 PR3566.2 PC1426.2 ; v1(284.78,186.92) PR1013.1 285.16,185.88 PR3563.2 PC1423.2 ; PU1605.21 289.34,181.75 v1(288.39,180.8) 288.13,180.55 PC1427.1 ; PC1422.2 PR3562.2 285.03,188.55 PR1006.1 284.65,189.56 v1(284.78,189.69)
  BOTTOM w0.508: v1(288.39,180.8) 287.75,180.8 286.61,179.66 286.61,178.01 286.35,177.75 v1(284.96,177.75) v1(284.96,180.29) 284.96,181.69 285.34,182.07 285.34,183.72 v1(284.78,184.28) v1(284.78,186.92) v2(284.78,188.29) v1(284.78,189.69)
CPU_EDP_HPD: length 2.1
  TOP w0.097: v3(245.46,52.53) 246.17,51.82 R934.2
  BOTTOM w0.097: U2.BD7 245.46,52.19 v3(245.46,52.53)
CPU_PLTRST_N: length 406.9
  TOP w0.097: R176.2 252.32,57.23 v1(252.83,57.74)
  IN03 w0.091: v1(83.28,34.62) 85.5,36.85 89.57,36.85 91.58,38.86 96.36,38.86 96.62,38.6 97.85,38.6 98.68,37.76 107.73,37.76 119.39,49.42 148.87,49.42 157.58,40.72 157.58,39.45 v1(158.21,38.81)
  IN05 w0.091: v1(113.13,128.35) 113.13,162.26 118.71,167.85 136.37,167.85 147.16,157.05 147.16,155.78 v1(146.65,155.27)
  IN08 w0.091: v1(83.28,34.62) 81.63,36.27 81.63,46.56 79.98,48.21 79.98,52.53 77.97,54.54 77.97,59.26 78.67,59.96 78.67,65.29 78.21,65.75 77.67,65.75 76.01,67.41 76.01,75.81 76.39,76.19 76.39,78.24 77.15,79 77.15,81.71 77.69,82.25 77.69,89.47 76.52,90.65 76.52,90.98 76.93,91.39 77.39,91.39 79.93,93.93 79.93,98.69 81.3,100.05 86.99,100.05 97.25,110.32 101.32,110.32 102.97,111.97 102.97,114.13 109.32,120.48 109.32,125.56 112.11,128.35 v1(113.13,128.35)
  IN10 w0.091: v1(252.83,57.74) 253.08,57.74 253.66,57.15 254.17,57.15 255.54,55.78 255.54,46.99 254.42,45.87 254.42,43.94 249.42,38.94 213.88,38.94 210.56,42.26 208.27,42.26 205.73,39.73 186.96,39.73 185.69,38.46 158.57,38.46 v1(158.21,38.81)
  BOTTOM w0.076: 148.48,154.84 149.78,154.84 149.93,154.99 150.24,154.99 U1.BP35
  BOTTOM w0.097: 148.48,154.84 148.05,155.27 v1(146.65,155.27)
CPU_PLTRST_N_R: length 4.4
  TOP w0.097: R176.1 v1(250.54,57.23)
  BOTTOM w0.097: U2.AK2 248.87,57.5 250.27,57.5 v1(250.54,57.23)
CPU_SVID_ALERT_N: length 13.1
  IN03 w0.091: v1(146.65,158.83) 147.52,157.97 148.15,157.97 150.08,156.04 150.08,155.91 151.38,154.61 152.02,154.61 152.5,154.13 152.5,153.88 153.15,153.23 v1(154.66,153.23)
  BOTTOM w0.097: v1(154.66,153.23) 154.61,153.23 U1.BH31 ; v1(146.65,158.83) 146.15,159.34 R9.2
CPU_SVID_CLK: length 12.4
  IN03 w0.091: v1(154.67,153.87) 154.29,153.49 153.64,153.49 153.5,153.63 153.5,154.64 152.87,155.27 152.06,155.27 148.51,158.83 v3(147.8,158.83)
  BOTTOM w0.097: v3(147.8,158.83) 147.8,158.86 147.29,159.36 R46.2 ; U1.BH32 154.28,153.54 154.61,153.87 v1(154.67,153.87)
CPU_SVID_DATA: length 18.2
  IN03 w0.091: v3(147.92,156.54) 148.69,156.54 150.24,154.99 150.24,154.21 150.66,153.78 151.95,153.78 152.75,152.99 153.51,152.99 155.04,151.46 155.04,150.45 155.26,150.22 v1(155.4,150.22)
  BOTTOM w0.097: R48.2 145.13,159.34 v3(147.92,156.54)
  BOTTOM w0.102: U1.BH29 154.73,151.21 154.73,150.85 155.36,150.22 v1(155.4,150.22)
CPU_SVIDALERT_N: length 52.6
  TOP w0.097: v1(118.84,193.25) 119.22,193.63 PR1239.2
  IN03 w0.091: v1(141.07,167.21) 140.33,167.95 140.33,169.95 130.67,179.61 129.93,179.61 129.84,179.52 129.84,179.37 129.75,179.28 129.56,179.28 129.47,179.37 129.47,179.52 129.38,179.61 129.2,179.61 129.11,179.52 129.11,179.37 129.01,179.28 128.83,179.28 128.74,179.37 128.74,179.52 128.65,179.61 128.47,179.61 128.37,179.52 128.37,179.37 128.28,179.28 128.1,179.28 128.01,179.37 128.01,179.52 127.92,179.61 127.73,179.61 127.64,179.52 127.64,179.37 127.55,179.28 127.37,179.28 127.28,179.37 127.28,179.52 127.19,179.61 127,179.61 126.91,179.52 126.91,179.37 126.82,179.28 126.64,179.28 126.55,179.37 126.55,179.52 126.45,179.61 122.57,179.61 119.93,182.25 119.93,190.81 118.43,192.3 118.43,192.84 v1(118.84,193.25)
  BOTTOM w0.097: v1(141.07,167.21) 142.54,167.21 v2(142.82,166.93) R8.1 146.65,163.1 146.65,162.08 R9.1
CPU_SVIDCLK: length 52.6
  TOP w0.097: PR1234.1 118.71,192.74 v3(118.84,192.61) 118.97,192.74 PR1238.1
  IN03 w0.091: v3(118.84,192.61) 118.92,192.61 120.49,191.04 120.49,186.92 120.58,186.83 120.91,186.83 121,186.74 121,186.56 120.91,186.47 120.58,186.47 120.49,186.37 120.49,186.03 120.58,185.94 120.91,185.94 121,185.85 121,185.67 120.91,185.57 120.58,185.57 120.49,185.48 120.49,185.3 120.58,185.21 120.91,185.21 121,185.12 121,184.93 120.91,184.84 120.58,184.84 120.49,184.75 120.49,184.57 120.58,184.48 120.91,184.48 121,184.39 121,184.2 120.91,184.11 120.58,184.11 120.49,184.02 120.49,182.48 122.8,180.17 130.91,180.17 141.07,170.01 v3(141.07,169.5)
  BOTTOM w0.097: v3(141.07,169.5) v4(141.45,169.12) 147.29,163.27 R46.1
CPU_SVIDDATA: length 52.5
  TOP w0.097: PR1235.2 118.21,193.63 v3(118.84,194.26) 119.1,194.52 PR1237.2
  IN03 w0.091: v3(141.07,166.45) 139.77,167.75 139.77,169.72 130.77,178.72 125.88,178.72 125.55,179.05 122.34,179.05 119.37,182.01 119.37,190.57 117.88,192.07 117.88,193.3 v3(118.84,194.26)
  BOTTOM w0.097: v3(141.07,166.45) 142.59,166.45 v4(144.24,164.8) 145.13,163.91 R7.2 144.52,163 144.52,162.18 R48.1
CPU_VCCIO_VCC_SENSE: length 90
  IN08 w0.203: v1(184.88,139.35) 184.75,139.47 184.75,139.81 184.93,139.98 185.26,139.98 185.49,139.75 185.49,137.48 184.73,136.72 184.73,135.47 186.15,134.05 186.15,132.85 185.82,132.52 184.91,132.52 184.7,132.72 184.7,133.99 184.12,134.57 175.57,134.57 174.8,133.8 174.8,132.02 174,131.22 166.07,131.22 165.4,131.89 165.4,134.07 164.93,134.55 163,134.55 161.97,135.57 161.97,137.79 162.34,138.15 163.71,138.15 164.03,138.47 164.03,141.03 163.88,141.19 163.88,143.67 160.37,147.17 152.87,147.17 152.21,146.51 148.98,146.51 145.79,149.69 145.79,156.7 145.06,157.44 137.79,157.44 v1(137.18,158.04)
  BOTTOM w0.203: v2(137.18,158.63) v1(137.18,158.04) 136.62,158.04 PR1227.1 ; U1.H14 185.34,139.81 v1(184.88,139.35)
