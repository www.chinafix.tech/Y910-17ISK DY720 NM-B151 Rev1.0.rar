# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
H_VCCST_PWRGD_R: length 2.2
  TOP w0.097: R17.2 v1(186.38,139.47)
  BOTTOM w0.097: U1.H13 185.34,139.08 185.74,139.47 v1(186.38,139.47)
HDA_BCLK: length 54
  TOP w0.097: U7.13 284.66,31.41 283.54,31.41 v1(283.43,31.3) ; R131.2 v1(252.83,50.75)
  IN05 w0.091: v1(283.43,31.3) 282.9,31.83 282.42,31.83 282.16,32.08 282.16,40.21 281.78,40.59 281.02,40.59 280.77,40.34 266.66,40.34 263.48,43.51 258.93,43.51 257.45,42.04 v1(256.2,42.04)
  IN10 w0.091: v1(256.2,42.04) 256.76,42.6 256.76,43.46 257.68,44.38 257.68,45.14 257.02,45.8 v1(257.02,47.83)
  BOTTOM w0.097: v1(283.43,31.3) 283.43,30.81 283.56,30.69 C339.1 ; v1(252.83,50.75) 252.95,50.75 253.38,51.18 254.6,51.18 257.02,48.77 v1(257.02,47.83)
HDA_BCLK_R: length 8.5
  TOP w0.097: R131.1 v2(250.24,50.75) 249.78,50.75 249.27,51.26 249.27,52.02 248.76,52.53 247.37,52.53 246.98,52.91 245.16,52.91 v3(244.75,53.32)
  BOTTOM w0.097: v3(244.75,53.32) 244.58,53.15 U2.BA9
HDA_I2S_SEL: length 2.9
  TOP w0.097: R289.1 TP94.1 282.8,34.67 283.16,34.32 283.74,34.32 283.85,34.21 284.07,34.21 284.07,34.21 U7.6
HDA_JD1: length 1.6
  TOP w0.097: v2(283.1,33.35) 283.16,33.41 U7.8
HDA_JD2: length 42.1
  TOP w0.097: R312.1 R311.2 v1(304.52,29.42) ; v1(282.8,33.86) R310.1 C332.2 283.28,32.97 283.41,33.1 283.69,33.1 283.78,33.01 U7.9
  IN03 w0.091: v1(304.52,29.42) 304.13,29.42 304.01,29.54 300.96,29.54 300.2,30.31 300.2,35.51 298.17,37.54 294.86,37.54 294.36,38.05 294.36,40.59 293.97,40.97 288.51,40.97 287.24,39.7 285.59,39.7 284.96,39.07 284.96,37.29 282.8,35.13 v1(282.8,33.86)
HDA_RST_N: length 58.1
  TOP w0.097: v1(255.24,40.9) 254.71,41.43 252.75,41.43 250.79,43.39 v2(247.37,43.39) 246.86,43.39 245.97,44.28 245.97,47.45 v1(245.84,47.58) ; v1(284.45,28.91) 285.1,29.56 285.31,29.56 285.53,29.79 U7.15
  IN05 w0.091: v1(255.24,40.9) 255.7,40.44 257,40.44 259.19,42.63 263.11,42.63 266.29,39.45 275.43,39.45 276.19,38.69 279.5,38.69 279.88,39.07 280.64,39.07 281.02,38.69 281.02,30.18 282.29,28.91 v1(284.45,28.91)
  BOTTOM w0.097: v1(245.84,47.58) 246.48,48.21 R135.2
HDA_RST_N_R: length 5.7
  BOTTOM w0.097: U2.BD8 244.6,50.02 245.36,49.25 v2(247.24,49.25) 247.39,49.1 R135.1
HDA_SDIN: length 65.1
  TOP w0.097: v1(283.31,26.37) 283.69,26.75 R307.2
  IN05 w0.091: v1(254.2,40.9) 254.91,40.19 257.37,40.19 259.6,42.41 262.85,42.41 266.16,39.11 275.17,39.11 275.81,38.47 278.61,38.47 280.04,37.03 280.04,32.04 280.63,31.46 280.63,29.04 v1(283.31,26.37)
  IN08 w0.091: v1(256.38,50.75) 255.92,51.21 252.28,51.21 251.82,50.75 v3(245.21,50.75)
  IN10 w0.091: v1(256.38,50.75) 255.87,50.24 255.87,46.82 254.63,45.58 254.63,41.84 254.2,41.41 v1(254.2,40.9)
  BOTTOM w0.097: v3(245.21,50.75) 245.1,50.86 U2.BE7
HDA_SDIN_R: length 4.6
  TOP w0.097: v2(283.69,28.91) R307.1 284.12,28.4 284.7,28.4 284.96,28.65 284.96,29.01 285.29,29.34 285.64,29.34 285.93,29.63 U7.16
HDA_SDOUT: length 58.3
  TOP w0.097: v1(285.47,28.91) 285.64,28.91 286.33,29.6 U7.17 ; v1(254.2,42.02) 253.8,42.42 253.8,46.35 252.37,47.78 R167.1 252.11,48.85 251.3,48.85 251.18,48.97 v2(250.79,48.97) 250.16,48.97 249.27,48.09 248.2,48.09 247.95,48.34 R134.2
  IN05 w0.091: v1(254.2,42.02) 254.65,41.56 257.28,41.56 258.98,43.26 263.31,43.26 266.53,40.04 275.68,40.04 276.44,39.28 279.07,39.28 279.62,39.83 280.89,39.83 281.78,38.94 281.78,31.07 282.16,30.69 284.45,30.69 285.47,29.67 v1(285.47,28.91)
HDA_SDOUT_R: length 6.5
  TOP w0.097: R2286.2 245.84,50.45 v3(245.84,49.86) 245.84,49.36 246.22,48.97 R134.1
  BOTTOM w0.097: v3(245.84,49.86) 245.46,50.24 245.16,50.24 244.83,50.57 244.83,52.15 245.02,52.35 U2.BB7
HDA_SPKR: length 88.7
  TOP w0.097: R164.1 231.87,47.96 232.38,48.47 233.27,48.47 v3(233.78,48.97) ; v1(283.31,25.48) 283.43,25.61 R313.2
  IN08 w0.091: v1(278.35,46.05) 274.42,46.05 272.89,47.58 267.91,47.58 267.56,47.93 263.78,47.93 263.37,48.34 256.51,48.34 256.1,47.93 248,47.93 247.59,48.34 244.21,48.34 243.7,47.83 239.87,47.83 239.49,48.21 234.16,48.21 233.78,48.59 v3(233.78,48.97)
  IN10 w0.091: v1(278.35,46.05) 277.72,46.05 273.78,42.12 273.78,39.96 275.05,38.69 279.12,38.69 279.62,39.2 282.93,39.2 283.31,38.81 283.31,37.93 284.7,36.53 284.7,30.05 282.42,27.77 282.42,26.37 v1(283.31,25.48)
  BOTTOM w0.097: v3(233.78,48.97) 234.03,48.97 235.43,50.37 235.43,51.67 U2.BD26
HDA_SYNC: length 60.2
  TOP w0.097: U7.14 284.32,31.01 284.32,31.01 283.88,31.01 283.43,30.56 v1(283.43,30.18) ; v1(254.22,47.45) 254.22,43.01 254.71,42.52 254.71,41.86 255.06,41.51 255.65,41.51 v1(256.26,40.9)
  IN05 w0.091: v1(283.43,30.18) 283.43,29.8 283.05,29.42 282.29,29.42 281.38,30.33 281.38,38.84 280.79,39.43 279.73,39.43 279.28,38.98 276.32,38.98 275.55,39.74 266.41,39.74 263.23,42.92 259.06,42.92 257.04,40.9 v1(256.26,40.9)
  IN08 w0.091: v1(254.22,47.45) 254.1,47.45 253.46,46.82 248.76,46.82 247.49,48.09 245.33,48.09 v1(244.83,47.58)
  BOTTOM w0.097: v1(244.83,47.58) 244.7,47.7 R132.2
HDA_SYNC_R: length 4.3
  BOTTOM w0.097: U2.BD9 244.12,51.71 244.32,51.51 244.32,49.58 v2(244.67,49.23) R132.1
HDMI_CEC: length 4.2
  TOP w0.097: JDP1.14 11.82,159.3 v1(11.65,159.46)
  BOTTOM w0.097: v2(13.89,159.13) R807.1 11.98,159.13 v1(11.65,159.46)
HDMI_CLK_DN: length 101.3
  TOP w0.081: v3(19.95,133) 19.71,132.76 19.46,132.76 19.19,133.03 CM6.3
  IN10 w0.081: v3(19.95,133) 19.8,132.85 17.17,132.85 14.84,130.52 14.84,121.57 16.81,119.59 20.79,119.59 40.73,99.66 46.86,99.66 50.27,96.24 50.27,94.21 51.69,92.79 54.96,92.79 55.34,92.41 58.14,92.41 59.25,91.29 62.5,91.29 63.6,90.19 63.6,86.49 66.19,83.9 68.53,83.9 69.63,82.81 76.37,82.81 v1(76.55,82.63)
  BOTTOM w0.081: U2019.25 79.69,82.8 79.6,82.89 78.58,82.89 78.48,82.79 76.71,82.79 v1(76.55,82.63)
HDMI_CLK_DP: length 101.3
  TOP w0.081: CM6.2 19.19,132.18 19.46,132.45 19.71,132.45 v3(19.95,132.21)
  IN10 w0.081: v1(76.56,83.26) 76.35,83.05 69.73,83.05 68.63,84.15 66.3,84.15 63.85,86.59 63.85,90.29 62.61,91.54 59.35,91.54 58.24,92.66 55.44,92.66 55.06,93.04 51.79,93.04 50.52,94.31 50.52,96.35 46.96,99.9 40.83,99.9 20.89,119.84 16.91,119.84 15.08,121.67 15.08,130.41 17.27,132.6 20.15,132.6 20.25,132.5 20.25,132.3 20.15,132.21 v3(19.95,132.21)
  BOTTOM w0.081: v1(76.56,83.26) 76.72,83.1 78.36,83.1 78.46,83.2 79.6,83.2 79.69,83.3 U2019.26
HDMI_CLK_R_DN: length 4
  TOP w0.081: CM6.4 17.03,133.03 16.72,132.72 15.97,132.72 15.91,132.78 D26.10 D26.1 14.82,132.78 14.78,132.75 13.91,132.75 R2279.1
HDMI_CLK_R_DP: length 4
  TOP w0.081: CM6.1 17.03,132.18 16.79,132.41 16.1,132.41 15.96,132.28 D26.9 D26.2 14.81,132.28 14.65,132.44 13.78,132.44 R2278.1
HDMI_CLK_RS_DN: length 3.6
  TOP w0.081: JHDMI1.12 10.71,132.75 11.06,132.4 11.4,132.4 11.79,132.79 12.34,132.79 R2279.2
HDMI_CLK_RS_DP: length 3.6
  TOP w0.081: R2278.2 12.37,132.48 11.92,132.48 11.53,132.09 11.06,132.09 10.71,131.75 JHDMI1.10
HDMI_DATA0_DN: length 99.6
  TOP w0.081: v3(19.95,131.23) 19.71,130.98 19.46,130.98 19.19,131.25 CM3.3
  IN10 w0.081: v3(19.95,131.23) 19.8,131.07 18.09,131.07 15.72,128.71 15.72,122.02 17.14,120.61 21.04,120.61 40.74,100.92 47.09,100.92 48.35,99.66 49.37,99.66 49.76,99.26 49.76,98.53 52.45,95.84 54.74,95.84 55.22,95.35 55.22,94.08 55.63,93.68 58.51,93.68 59.34,92.85 60.48,92.85 61.06,93.42 63.22,93.42 63.55,93.09 64.87,93.09 65.33,93.56 70.61,93.56 70.97,93.2 70.97,85.97 72.34,84.6 76.36,84.6 v1(76.55,84.41)
  BOTTOM w0.081: U2019.28 79.69,84.3 79.6,84.39 78.51,84.39 78.33,84.57 76.71,84.57 v1(76.55,84.41)
HDMI_DATA0_DP: length 99.6
  TOP w0.081: v3(19.95,130.43) 19.71,130.67 19.46,130.67 19.19,130.4 CM3.2
  IN10 w0.081: v3(19.95,130.43) 20.15,130.43 20.24,130.52 20.24,130.72 20.14,130.82 18.19,130.82 15.97,128.6 15.97,122.13 17.24,120.86 21.15,120.86 40.84,101.16 47.19,101.16 48.45,99.9 49.47,99.9 50.01,99.37 50.01,98.63 52.55,96.08 54.84,96.08 55.47,95.46 55.47,94.19 55.73,93.93 58.61,93.93 59.44,93.09 60.37,93.09 60.95,93.67 63.32,93.67 63.65,93.34 64.76,93.34 65.23,93.81 70.71,93.81 71.22,93.3 71.22,86.08 72.44,84.85 76.36,84.85 76.55,85.04 v1(76.56,85.04)
  BOTTOM w0.081: U2019.29 79.69,84.8 79.6,84.7 78.63,84.7 78.46,84.88 76.72,84.88 v1(76.56,85.04)
HDMI_DATA0_R_DN: length 4.2
  TOP w0.081: R2273.1 13.86,131.02 14.08,131.02 14.26,131.2 14.61,131.2 14.69,131.28 D26.4 D26.7 16.09,131.28 16.15,131.22 16.46,131.22 16.73,130.95 16.97,130.95 CM3.4
HDMI_DATA0_R_DP: length 4.2
  TOP w0.081: R2272.1 13.83,130.71 14.21,130.71 14.39,130.89 14.57,130.89 14.69,130.78 D26.5 D26.6 15.93,130.78 16.06,130.91 16.33,130.91 16.61,130.64 16.79,130.64 17.03,130.4 CM3.1
HDMI_DATA0_RS_DN: length 3.5
  TOP w0.081: JHDMI1.9 10.71,131.25 11.09,130.88 11.58,130.88 11.78,131.07 12.39,131.07 R2273.2
HDMI_DATA0_RS_DP: length 3.5
  TOP w0.081: JHDMI1.7 10.71,130.25 11.03,130.57 11.71,130.57 11.91,130.76 12.31,130.76 R2272.2
HDMI_DATA1_DN: length 94.6
  TOP w0.081: v3(19.95,129.32) 19.71,129.07 19.46,129.07 19.19,129.35 CM4.3
  IN10 w0.081: 76.41,86.33 76.36,86.38 74.37,86.38 73.79,85.8 72.54,85.8 71.86,86.49 71.86,93.59 70.5,94.95 63.97,94.95 63.72,94.7 60.79,94.7 60.55,94.95 56.87,94.95 55.09,96.73 52.96,96.73 51.03,98.66 51.03,99.93 50.23,100.73 48.58,100.73 47.5,101.81 41.09,101.81 21.14,121.75 17.29,121.75 16.61,122.43 16.61,127.18 18.6,129.17 19.8,129.17 v3(19.95,129.32)
  IN10 w0.091: v1(76.55,86.19) 76.41,86.33
  BOTTOM w0.081: U2019.31 79.69,85.8 79.6,85.89 78.49,85.89 78.04,86.35 76.71,86.35 v1(76.55,86.19)
HDMI_DATA1_DP: length 94.6
  TOP w0.081: CM4.2 19.19,128.5 19.46,128.76 19.71,128.76 v3(19.95,128.52)
  IN10 w0.081: v1(76.56,86.82) 76.55,86.82 76.36,86.63 74.27,86.63 73.69,86.05 72.65,86.05 72.11,86.59 72.11,93.7 70.61,95.2 63.87,95.2 63.62,94.95 60.9,94.95 60.65,95.2 56.97,95.2 55.19,96.97 53.06,96.97 51.28,98.76 51.28,100.03 50.33,100.97 48.68,100.97 47.6,102.05 41.19,102.05 21.24,122 17.39,122 16.86,122.53 16.86,127.08 18.7,128.92 20.14,128.92 20.26,128.8 20.26,128.63 20.15,128.52 v3(19.95,128.52)
  BOTTOM w0.081: v1(76.56,86.82) 76.72,86.66 78.17,86.66 78.62,86.2 79.6,86.2 79.69,86.3 U2019.32
HDMI_DATA1_R_DN: length 4.1
  TOP w0.081: CM4.4 17.03,129.35 16.79,129.11 16.39,129.11 16.27,129.22 D30.10 D30.1 14.7,129.22 14.61,129.13 14.42,129.13 14.27,129.27 13.83,129.27 R2275.1
HDMI_DATA1_R_DP: length 4.1
  TOP w0.081: R2274.1 13.87,128.96 14.14,128.96 14.29,128.82 14.61,128.82 14.7,128.72 D30.2 D30.9 16.27,128.72 16.35,128.8 16.72,128.8 17.03,128.5 CM4.1
HDMI_DATA1_RS_DN: length 3.4
  TOP w0.081: JHDMI1.6 11.3,129.75 11.75,129.29 12.39,129.29 R2275.2
HDMI_DATA1_RS_DP: length 3.4
  TOP w0.081: R2274.2 12.31,128.98 11.53,128.98 11.3,128.75 JHDMI1.4
HDMI_DATA2_DN: length 85.5
  TOP w0.081: CM5.3 19.19,127.57 19.47,127.29 19.7,127.29 v3(19.95,127.54)
  IN10 w0.081: v3(19.95,127.54) 19.8,127.39 19.23,127.39 18.24,126.39 18.24,123.97 19.06,123.15 20.92,123.15 41.12,102.95 47.63,102.95 48.89,101.68 50.89,101.68 51.4,101.18 52.67,101.18 57.5,96.35 70.87,96.35 73.92,93.3 73.92,91.23 74.2,90.95 74.2,88.78 74.82,88.16 76.36,88.16 v1(76.55,87.96)
  BOTTOM w0.081: U2019.34 79.69,87.3 79.6,87.39 78.65,87.39 77.91,88.13 76.71,88.13 v1(76.55,87.96)
HDMI_DATA2_DP: length 85.5
  TOP w0.081: v3(19.95,126.74) 19.71,126.98 19.46,126.98 19.19,126.72 CM5.2
  IN10 w0.081: v3(19.95,126.74) 20.15,126.74 20.26,126.85 20.26,127.04 20.15,127.14 19.33,127.14 18.49,126.29 18.49,124.08 19.16,123.4 21.03,123.4 41.23,103.2 47.73,103.2 49,101.93 51,101.93 51.5,101.43 52.77,101.43 57.6,96.59 70.97,96.59 74.16,93.4 74.16,91.33 74.44,91.06 74.44,88.88 74.92,88.4 76.36,88.4 v1(76.55,88.6)
  BOTTOM w0.081: U2019.35 79.69,87.8 79.6,87.7 78.77,87.7 78.04,88.44 76.71,88.44 v1(76.55,88.6)
HDMI_DATA2_R_DN: length 4.2
  TOP w0.081: R2277.1 13.77,127.55 14.66,127.55 14.83,127.72 D30.4 D30.7 15.99,127.72 16.06,127.65 16.35,127.65 16.73,127.26 16.85,127.26 17.15,127.57 CM5.4
HDMI_DATA2_R_DP: length 4.2
  TOP w0.081: CM5.1 17.15,126.72 16.92,126.95 16.61,126.95 16.22,127.34 16.1,127.34 15.99,127.22 D30.6 D30.5 14.83,127.22 14.81,127.24 13.92,127.24 R2276.1
HDMI_DATA2_RS_DN: length 3.6
  TOP w0.081: JHDMI1.3 10.76,128.25 11.1,127.9 11.47,127.9 11.91,127.46 12.34,127.46 R2277.2
HDMI_DATA2_RS_DP: length 3.6
  TOP w0.081: JHDMI1.1 10.76,127.25 11.1,127.59 11.34,127.59 11.79,127.15 12.37,127.15 R2276.2
HDMI_DDC_CLK: length 33
  TOP w0.081: R443.2 15.92,134.82 16.53,134.82 17.67,135.96 17.67,136.15 v1(17.88,136.35) 17.8,136.42 17.8,136.84 R862.1
  IN10 w0.081: v1(6.45,121.62) 6.62,121.8 6.62,121.91 6.33,122.2 6.33,125.4 9.63,128.71 9.63,136.33 12.95,139.65 15.44,139.65 17.77,137.31 17.77,136.45 v1(17.88,136.35)
  BOTTOM w0.081: v1(6.45,121.62) 6.45,121.13 Q41.3
HDMI_DDC_CLK_R: length 6.1
  TOP w0.081: 12.15,134.43 12.58,134.86 14.46,134.86 R443.1 ; 12.15,134.43 D27.2 ; 12.15,134.43 12.15,134.46 11.74,134.86 11.51,134.86 10.89,134.25 JHDMI1.15
HDMI_DDC_DATA: length 33.1
  TOP w0.081: R565.1 17.24,136.78 v1(17.24,136.35) 17.34,136.25 17.34,136.07 v1(16.91,135.64) 16.4,135.13 15.54,135.13 15.46,135.21 15.46,135.39 R444.2
  IN10 w0.081: v1(17.24,136.35) 17.37,136.48 17.38,136.48 17.53,136.63 17.53,137.21 15.34,139.4 13.05,139.4 9.88,136.22 9.88,128.6 6.57,125.3 6.57,122.3 6.95,121.92 7.31,121.92 7.72,122.33 v1(7.72,122.51)
  BOTTOM w0.081: v1(7.72,122.51) 8.2,122.51 8.32,122.39 8.32,121.96 Q41.6
HDMI_DDC_DATA_R: length 6.2
  TOP w0.081: R444.1 14.75,135.36 14.56,135.17 12.58,135.17 12.15,135.6 ; 12.15,135.6 12.15,135.58 11.74,135.17 11.38,135.17 10.96,134.75 JHDMI1.16 ; 12.15,135.6 D28.2
HDMI_DONGLE_DETECT: length 114.5
  TOP w0.097: JDP1.13 11.75,158.8 v1(11.65,158.7)
  IN08 w0.091: v1(74.14,96.73) 74.14,97.33 73.34,98.12 70.71,98.12 68.8,96.22 62.07,96.22 61.77,96.52 57.96,96.52 53.56,100.92 43.02,100.92 18.77,125.17 18.77,144.35 17.62,145.49 17.62,157.69 16.86,158.45 11.91,158.45 v1(11.65,158.7)
  BOTTOM w0.097: R408.1 11.07,158.7 v1(11.65,158.7) ; v1(74.14,96.73) 74.33,96.54 75.63,96.54 75.92,96.25 75.92,95.96 76.17,95.71 Q6.5
HDMI_REP_A1_VTH1: length 1.4
  BOTTOM w0.097: U2019.16 84.29,81.8 R2236.2
HDMI_REP_A4_VTH0: length 1.5
  BOTTOM w0.097: R2237.2 83.9,81.3 U2019.17
HDMI_REP_ENI2C: length 2.9
  BOTTOM w0.097: U2019.21 81.01,80.18 80.23,79.4 R2122.2 79.8,79.4 79.67,79.28 R2143.1
HDMI_REP_EQ0: length 1.1
  BOTTOM w0.097: R2141.2 81.01,90.03 U2019.39
HDMI_REP_EQ1: length 1
  BOTTOM w0.097: U2019.40 81.51,90.42 R2142.2
HDMI_REP_EQ2: length 1
  BOTTOM w0.097: U2019.41 82.01,90.3 R2125.2
HDMI_REP_EQ3: length 1.2
  BOTTOM w0.097: R2126.2 82.51,89.91 U2019.42
HDMI_REP_FG0: length 2.4
  BOTTOM w0.097: R2140.2 78.79,88.98 79.6,88.98 79.78,88.8 U2019.37
HDMI_REP_FG1: length 1.5
  BOTTOM w0.097: U2019.38 79.79,89.67 79.79,90.36 R2139.2
HDMI_REP_I2C_DONE_A0: length 3.1
  BOTTOM w0.097: R2239.2 78.28,80.22 v2(78.96,80.22) 79.22,80.22 79.6,80.6 79.6,80.98 79.92,81.3 U2019.22
HDMI_REP_PEN: length 1.8
  BOTTOM w0.254: U2019.20 81.51,79.96 81.57,79.89 Q106.2
HDMI_REP_SCL: length 3.5
  TOP w0.097: R2131.1 80.49,79.33 80.54,79.28 R2240.2 81.43,79.71 81.88,79.71 v1(82.27,80.09)
  BOTTOM w0.097: U2019.19 82.01,80.35 v1(82.27,80.09)
HDMI_REP_SDA: length 4.9
  TOP w0.097: R2130.1 81.55,80.27 81.81,80.52 82.64,80.52 v1(83.07,80.09) 82.26,79.28 R2241.2
  BOTTOM w0.097: U2019.18 82.51,80.66 v1(83.07,80.09)
HDMI_REP_SW0: length 1.5
  BOTTOM w0.097: U2019.2 84.55,88.8 R2123.2
HDMI_REP_SW1: length 1.6
  BOTTOM w0.097: R2138.2 84.16,89.3 U2019.1
HDMI_REP_VOD1: length 2.4
  BOTTOM w0.097: R2238.2 v2(78.96,81.49) 79.47,81.49 79.78,81.8 U2019.23
HP_JD: length 2.3
  TOP w0.097: v1(301.34,29.06) 301.75,29.06 302.1,29.42 R311.1
  BOTTOM w0.097: JIO1.61 301.2,28.92 v1(301.34,29.06)
HP_OUTL: length 16.7
  TOP w0.254: 295.18,30.25 293.4,30.25 293.01,30.64 293.01,31.45 292.33,32.13 292.3,32.13 292.22,32.21 U7.32
  TOP w0.356: 295.18,30.25 295.88,29.54 v2(295.88,26.88) 295.88,24.34 v1(295.63,24.08)
  BOTTOM w0.254: JIO1.71 299.56,24.92 299.43,25.06 299.19,25.06
  BOTTOM w0.356: 299.19,25.06 296.6,25.06 v1(295.63,24.08)
HP_OUTR: length 16.9
  TOP w0.254: 293.72,30.81 293.39,31.14 293.39,31.65 292.53,32.51 292.45,32.51 292.36,32.61 U7.33
  TOP w0.356: 293.72,30.81 295.63,30.81 v2(296.13,30.31) 296.39,30.05 296.39,23.96 v1(296.26,23.83)
  BOTTOM w0.254: JIO1.72 299.46,24.52 299.41,24.57 299.18,24.57
  BOTTOM w0.356: v1(296.26,23.83) 297.01,24.57 299.18,24.57
I2CB_SCL: length 2.1
  TOP w0.097: R2298.1 240.25,117.2 v3(239.69,117.77)
  BOTTOM w0.1: G2.BG8 v3(239.69,117.77)
I2CB_SDA: length 3.3
  TOP w0.097: R2299.1 242.41,117.68 241.9,118.19 241.02,118.19 240.59,117.77 v3(240.39,117.77)
  BOTTOM w0.1: G2.BF8 v3(240.39,117.77)
I2CC_SCL: length 323.7
  TOP w0.097: PR1469.1 301.34,183.72 v3(302.1,184.48) ; R2169.2 225.22,120.07 v3(225.14,120.15)
  IN05 w0.091: v3(308.07,72.22) 306.67,73.61 306.67,76.91 305.66,77.93 304.64,77.93 304.39,78.18 304.39,79.84 306.8,82.25 306.8,91.01 308.58,92.79 308.58,102.93 307.94,103.56 307.94,111.46 306.8,112.6 306.8,120.98 307.69,121.87 307.69,171.44 302.74,176.4 302.74,183.59 302.1,184.22 v3(302.1,184.48) 302.36,184.48 303.63,185.75 303.63,195.88 v3(303.62,195.88)
  IN08 w0.091: v3(289.02,74.88) 288.01,73.87 283.96,73.87 282.44,72.34 280.03,72.34 278.86,71.18 278.86,69.02 278.63,68.79 277.08,68.79 276.77,69.1 276.77,70.65 277.59,71.47 277.59,75.24 276.68,76.15 274.31,76.15 273.17,75.01 270.84,75.01 269.44,76.41 253.1,76.41 252.21,75.52 242.67,75.52 238.99,79.2 223.12,79.2 222.86,79.45 220.19,79.45 215.23,84.41 215.23,86.7 213.84,88.09 213.84,94.62 212.67,95.79 212.67,99.57 213.46,100.35 213.46,101.81 213.87,102.22 217.23,102.22 219.01,104 219.01,107.99 218.82,108.18 218.82,111.59 217.27,113.14 217.27,114.89 217.5,115.12 217.5,117.01 218.2,117.7 223.13,117.7 225.14,119.71 v3(225.14,120.15)
  IN10 w0.091: v3(308.07,72.22) 307.64,71.78 307.64,57.74 304.64,54.74 302.86,54.74 301.09,56.52 299.44,56.52 295.63,60.33 295.63,70.24 293.59,72.27 292.32,72.27 291.43,73.16 291.43,73.99 290.55,74.88 v3(289.02,74.88)
  BOTTOM w0.097: v3(225.14,120.15) 225.01,120.02 R2296.1 ; v3(303.62,195.88) 303.44,196.06 PU5.6
I2CC_SCL_R: length 13.8
  TOP w0.097: R2169.1 228.98,120.07 230.5,118.54 v2(232.76,118.54) 232.81,118.49 238.31,118.49 v3(238.99,119.17)
  BOTTOM w0.1: G2.BG9 v3(238.99,119.17)
I2CC_SDA: length 326.5
  TOP w0.097: PR1470.1 300.96,182.83 301.72,183.59 v3(302.1,183.59) ; v3(225.14,120.73) 225.57,120.73 R2170.2
  IN05 w0.091: v3(308.07,71.45) 306.42,73.1 306.42,76.81 305.55,77.68 304.54,77.68 304.13,78.08 304.13,79.94 306.55,82.35 306.55,91.36 308.33,93.14 308.33,102.82 307.69,103.46 307.69,111.2 306.55,112.35 306.55,121.11 307.44,122.01 307.44,171.34 302.49,176.29 302.49,183.21 v3(302.1,183.59) 301.7,184 301.7,189.97 303.25,191.51 303.25,195.42 v3(302.79,195.88)
  IN08 w0.091: v3(290.29,74.27) 289.63,73.61 284.07,73.61 282.54,72.09 280.13,72.09 279.12,71.07 279.12,68.91 278.73,68.53 277.03,68.53 276.55,69.01 276.55,70.74 277.34,71.53 277.34,75.14 276.58,75.9 274.42,75.9 273.27,74.76 270.73,74.76 269.34,76.15 253.21,76.15 252.32,75.26 242.41,75.26 238.78,78.89 222.99,78.89 222.68,79.2 220.06,79.2 214.92,84.34 214.92,86.57 213.53,87.97 213.53,94.62 212.46,95.7 212.46,99.66 213.24,100.45 213.24,101.9 213.78,102.44 217.14,102.44 218.79,104.09 218.79,107.9 218.6,108.09 218.6,111.48 217.01,113.07 217.01,115.01 217.28,115.29 217.28,117.1 218.11,117.92 222.71,117.92 224.69,119.9 224.69,120.53 224.89,120.73 v3(225.14,120.73)
  IN10 w0.091: v3(290.29,74.27) 290.29,73.87 292.2,71.96 293.47,71.96 295.37,70.06 295.37,60.15 299.31,56.21 300.96,56.21 302.74,54.44 304.77,54.44 307.94,57.61 307.94,71.33 v3(308.07,71.45)
  BOTTOM w0.097: v3(225.14,120.73) 225.27,120.73 225.9,120.09 R2297.1 ; PR23.2 303.11,195.56 v3(302.79,195.88) PU5.7
I2CC_SDA_R: length 13.4
  TOP w0.097: v3(238.39,119.14) 237.78,119.14 v2(237.71,119.08) 237.32,118.69 233.89,118.69 233.34,119.23 233.34,119.51 233.01,119.84 230.86,119.84 229.74,120.96 R2170.1
  BOTTOM w0.1: G2.BH9 v3(238.39,119.14)
IFP_IOVDD_3: length 0.5
  BOTTOM w0.254: G2.BB18 243.06,125.24 v3(243.34,125.24)
IFPAB_RSET: length 5
  TOP w0.097: v3(241.79,128.27) 241.41,127.89 v1(241.14,127.89) 240.05,127.89 240,127.85 238.93,127.85 238.9,127.81 238.12,127.81 237.79,128.15 R1015.1
  BOTTOM w0.097: v3(241.79,128.27) G2.BD23
IFPCD_RSET: length 4.7
  TOP w0.1: R922.1 238.04,126.57 v1(239.75,126.57) 241.24,126.57 241.64,126.17 v3(241.79,126.17)
  BOTTOM w0.097: G2.BD20 v3(241.79,126.17)
IFPEF_RSET: length 6.7
  TOP w0.1: v3(241.79,124.07) 241.62,124.07 241.22,124.47 238.02,124.47 v2(237.84,124.29) 237.71,124.41 236.49,124.41 R923.1
  BOTTOM w0.097: G2.BD17 v3(241.79,124.07)
ILIM_1PH_A: length 2.6
  TOP w0.203: PU1101.20 126.33,187.2 126.59,186.95 v1(126.59,186.92)
  BOTTOM w0.254: v1(126.59,186.92) 126.72,186.8 PR1211.1
ILIM_3PH_A: length 6
  TOP w0.203: PU1101.46 126.33,195.38
  TOP w0.254: 126.33,195.38 126.33,197.18 v2(126.19,197.33) 125.83,197.69 123.91,197.69 123.64,197.96 PR1208.1
IMON_3PH_A: length 4.1
  TOP w0.203: PU1101.1 122.92,194 122.59,194.33
  TOP w0.254: PR1152.2 PC1160.2 121.51,195.41 122.59,194.33
IR_I2C_CLK: length 334.8
  TOP w0.097: v3(272.51,12.27) 273.02,11.76 U24.B3 ; v3(272.64,16.08) 272.71,16.01 R550.2 ; v1(81.88,99.14) 81.88,99.01 82.65,98.25 U23.B3
  IN03 w0.091: v3(64.99,46.82) 65.5,47.32 65.97,47.32 66.35,46.94 66.35,44.69 70.58,40.47 88.36,40.47 88.87,40.97 98.01,40.97 100.05,38.94 107.45,38.94 118.96,50.45 149.84,50.45 160.96,39.32 202.53,39.32 203.3,38.56 v3(203.3,38.43) ; v3(272.64,16.08) 272.51,15.95 v3(272.51,12.27)
  IN10 w0.091: v3(64.99,46.82) 65.63,47.45 66.14,47.45 69.69,51.01 69.69,52.02 67.91,53.8 62.83,53.8 61.56,55.07 61.56,67.39 60.96,67.99 60.96,76.95 65.37,81.36 76.8,81.36 77.31,81.87 77.31,88.27 80.11,91.07 80.11,98.5 80.74,99.14 v1(81.88,99.14) ; v3(272.64,16.08) 272.13,16.59 269.23,16.59 263.37,22.45 263.37,36.66 264.51,37.8 264.51,40.54 263.06,41.99 260.9,41.99 257.11,38.2 213.69,38.2 210.44,41.45 208.72,41.45 205.71,38.43 v3(203.3,38.43)
IR_I2C_DATA: length 336.5
  TOP w0.097: R551.2 v3(273.7,16.08) ; U23.C3 82.9,97.99 v1(82.9,98.89) ; v3(273.78,12.27) 273.52,12.01 U24.C3
  IN03 w0.091: v3(202.03,38.43) 201.52,38.94 160.98,38.94 149.7,50.23 119.05,50.23 107.51,38.69 99.92,38.69 98.31,40.3 88.7,40.3 88.41,40.01 70.66,40.01 66.14,44.53 66.14,46.46 65.78,46.82 v3(65.63,46.82) ; v3(273.7,16.08) 273.78,16.01 v3(273.78,12.27)
  IN10 w0.091: v1(82.9,98.89) 83.28,98.89 84.04,98.12 84.04,94.69 77.57,88.22 77.57,81.61 77.06,81.11 65.76,81.11 61.18,76.53 61.18,68.15 61.82,67.52 61.82,55.32 62.96,54.18 68.17,54.18 70.07,52.28 70.07,49.74 67.28,46.94 65.76,46.94 v3(65.63,46.82) ; v3(202.03,38.43) 202.53,38.94 205.83,38.94 208.66,41.77 210.43,41.77 213.77,38.43 256.84,38.43 260.7,42.3 263.71,42.3 265.02,41 265.02,37.42 263.62,36.02 263.62,28.53 264.51,27.64 264.51,26.4 263.71,25.6 263.71,22.44 269.33,16.82 272.96,16.82 v3(273.7,16.08)
KBD_GND: length 7.7
  TOP w0.254: v1(75.92,17.99) 76.17,17.73 L2005.1
  BOTTOM w0.254: JKB1.46 69.09,16.54 68.91,16.72 v1(68.3,16.72) 68.59,16.42 JKB1.47 ; JKB1.38 73.09,16.46 v1(73.35,16.72) ; v1(70.2,16.72) 70.59,16.32 JKB1.43 ; JKB1.42 v1(71.09,16.71) ; v1(72.46,16.72) 72.49,16.72 72.59,16.61 JKB1.39
  vias: v1(75.86,17.07)
KBRST_N: length 280
  TOP w0.089: 29.81,53.55 31.24,53.55 31.36,53.42 D2.2
  TOP w0.097: 29.81,53.55 26.26,53.55 v1(23.72,56.09) ; v3(240.76,56.09) 241.02,56.34 244.62,56.34 R181.2
  IN03 w0.091: v1(43.15,37.42) 44.04,36.53 45.18,36.53 47.55,34.16 57.97,34.16 58.77,33.35 70.83,33.35 73.4,30.79 86.1,30.79 86.29,30.6 95.51,30.6 96.11,31.19 96.11,32.85 96.62,33.35 107.62,33.35 119.81,45.55 135.73,45.55 141.07,40.21 141.07,39.45 v1(141.7,38.81)
  IN05 w0.091: v1(23.72,56.09) 23.85,56.21 24.35,56.21 24.86,56.72 25.5,56.72 26.51,55.71 26.51,52.02 27.33,51.2 27.33,41.68 28.93,40.08 28.93,38.59 30.48,37.04 37.82,37.04 38.45,37.67 40.1,37.67 40.85,38.42 40.85,38.93 41.24,39.32 42.77,39.32 43.28,38.81 43.28,37.54 v1(43.15,37.42)
  IN10 w0.091: v3(240.76,56.09) 240.38,55.71 240.38,53.17 239.62,52.4 239.24,52.4 238.73,51.9 235.3,51.9 234.97,51.57 232.33,51.57 232.14,51.38 231.13,51.38 230.22,50.48 227.57,50.48 226.66,51.39 224.08,51.39 222.43,53.04 221.69,53.04 219.86,54.86 218.33,54.86 217.9,54.44 198.05,54.44 197.43,53.82 197.43,52.99 195.75,51.31 179.75,51.31 179.42,51.64 175.99,51.64 175.09,50.74 171.3,50.74 170.3,49.74 149.8,49.74 142.46,42.4 142.46,39.58 v1(141.7,38.81)
  BOTTOM w0.097: v3(240.76,56.09) 240.21,55.53 U2.AT17
KBRST_N_R: length 1.6
  TOP w0.089: v2(33.24,53.72) 32.94,53.42 D2.1
  BOTTOM w0.089: U5.H4 33.77,53.42 33.47,53.72 v2(33.24,53.72)
LAN_CK_REQ_N: length 9.2
  TOP w0.097: Q35.1 50.77,71.98 50.77,71.58 50.26,71.07 v2(50.26,71.05) 50.26,69.88 49.83,69.45 49.83,68.43 49.61,68.2 R277.2 49.37,67.74 47.72,66.09 47.72,65.99 47.56,65.83 U6.4
LAN_LX:
  vias: v2(51.35,65.84)
LAN_PPS: length 2
  TOP w0.097: U6.24 46.36,59.23 46.71,58.88 v2(46.71,58.25)
LAN_RBIAS: length 3.9
  TOP w0.203: R280.1 44.52,67.03 44.52,66.37 44.04,65.89 v2(44.04,65.74) 44.04,65.36 44.53,64.86 45.02,64.86 45.16,65.01 U6.10
LAN_RST_N: length 7.9
  TOP w0.097: v2(53.36,69.96) R274.2 52.85,68.53 51.48,68.53 49.68,66.73 49.09,66.73 48.36,66 U6.2
LAN_WAKE_N: length 55.3
  TOP w0.097: R276.1 50.29,69.32 50.9,69.93 v1(51.02,69.93)
  IN03 w0.091: v1(35.4,63.71) 39.47,63.71 42.72,66.96 45.64,66.96 46.58,67.9 48.99,67.9 v1(51.02,69.93)
  IN10 w0.089: 30.96,46.69 30.96,47.58 30.83,47.7 30.83,53.93 31.97,55.07 31.97,57.61 32.99,58.63
  IN10 w0.091: 32.99,58.63 33.5,59.13 33.5,61.8 v1(35.4,63.71) ; 30.96,46.69 30.96,46.31 32.74,44.53 33.75,44.53 35.78,42.5 v1(35.78,41.61)
  BOTTOM w0.076: U5.B7 35.52,50.16 35.52,49.61
  BOTTOM w0.097: v1(35.78,41.61) 35.26,42.13 35.26,45.33 35.52,45.59 35.52,49.61
LAN_WAKE_N_R: length 5.7
  TOP w0.097: U6.3 47.96,65.98 49.19,67.21 v2(49.42,67.21) 49.42,67.34 R276.2 50.54,68.2 51.38,69.04 R275.2
LC_CK32K/GPJ6: length 3
  TOP w0.076: 70.85,7.18 70.85,7.62 U19.F2
  TOP w0.097: 70.85,7.18 71.04,6.99 71.04,5.57 71.09,5.52 R511.2
LC_CS_N: length 28.8
  TOP w0.089: v2(68.04,10.24) 68.17,10.37 U19.A7
  TOP w0.097: U16.1 v1(47.34,6.18)
  IN03 w0.089: v2(68.04,10.24) 66.77,10.24
  IN03 w0.091: 66.77,10.24 66.14,10.24 65.12,9.22 62.33,9.22 61.06,7.95 49.12,7.95 v1(47.34,6.18)
LC_GPA4: length 7
  TOP w0.089: U19.K6 73.26,9.87 v2(73.63,10.24) ; v2(76.55,13.92) v2(76.55,13.29)
  TOP w0.097: R879.1 76.68,13.16 v2(76.55,13.29)
  IN03 w0.089: v2(76.55,13.29) 76.17,13.29 75.41,12.53 74.65,12.53 74.14,12.02 74.14,10.75 v2(73.63,10.24)
LC_GPA5: length 7.6
  TOP w0.089: U19.J6 72.11,9.87 v2(72.11,9.86)
  TOP w0.097: R880.1 76.73,10.8 v3(76.8,10.87)
  IN03 w0.089: v2(72.11,9.86) 73.88,9.86 74.52,10.49 74.52,10.75 75.66,11.89 76.42,11.89 76.55,11.76
  IN03 w0.091: v3(76.8,10.87) 76.8,11.51 76.55,11.76
LC_GPB0: length 6.1
  TOP w0.089: U19.A4 68.3,8.87 68.02,8.59 67.15,8.59 v2(67.03,8.46)
  BOTTOM w0.089: v2(67.03,8.46) 66.77,8.21
  BOTTOM w0.097: 66.77,8.21 66.67,8.11 66.67,7.73 v2(65.89,6.94) 65.7,6.76 64.41,6.76 64.32,6.85 R814.1
LC_GPB3: length 6.1
  TOP w0.076: 68.21,9.11 68.79,9.11 69.03,8.87 U19.B4
  TOP w0.097: 68.21,9.11 67.94,8.84 66.75,8.84 v2(66.69,8.89) 66.59,8.89 v2(66.26,8.56)
  BOTTOM w0.097: v2(66.26,8.56) 65.59,7.89 64.16,7.89 64,7.73 R825.1
LC_GPF2: length 6.7
  TOP w0.097: U19.A10 68.45,11.87 68.26,11.67 68.26,11.42 67.86,11.03 67.38,11.03 v2(67.03,11.38)
  BOTTOM w0.089: 66.77,10.49 67.03,10.75 v2(67.03,11.38)
  BOTTOM w0.097: 66.77,10.49 66.64,10.37 v2(66.61,10.37) 66.03,10.37 65.42,9.76 R877.1
LC_GPF3: length 7.4
  TOP w0.076: U19.B10 68.84,12.12 68.39,12.12
  TOP w0.097: 68.39,12.12 68.17,11.89 68.17,11.89 68.04,11.76 68.04,11.69 v2(67.74,11.38)
  BOTTOM w0.089: v2(67.74,11.38) 67.74,10.82 66.89,9.98 66.77,9.98
  BOTTOM w0.097: 66.77,9.98 65.98,9.98 65.09,9.1 v2(64.61,9.1) 63.76,9.1 R878.1
LC_HOLD_N: length 1.6
  TOP w0.097: U16.7 R788.1
LC_I2C_CLK: length 9.5
  TOP w0.097: v1(67.15,3.13) 67.53,3.51 R524.2 67.84,3.81 68.04,4.02 68.04,5.16 68.35,5.46 v1(68.35,5.92) 68.35,6.35 69.1,7.1 U19.B1
  BOTTOM w0.097: v1(67.15,3.13) 66.64,3.64 63.47,3.64 TP153.1
LC_I2C_DATA: length 13.3
  TOP w0.097: U19.C1 69.6,6.84 69.18,6.43 v2(69.18,5.92) ; v1(61.82,5.03) 62.15,5.36 R513.2
  IN05 w0.089: v2(69.18,5.92) 68.8,5.54
  IN05 w0.091: 68.8,5.54 68.55,5.29 62.07,5.29 v1(61.82,5.03)
  BOTTOM w0.097: v1(61.82,5.03) 61.06,5.79 TP154.1
LC_INT0_N: length 251.5
  TOP w0.097: R876.2 69.44,3.38 v1(69.57,3.25) R567.2
  IN03 w0.091: v1(63.6,30.65) 64.36,29.89 70.42,29.89 72.83,27.48 76.42,27.48 77.4,26.5 82.14,26.5 83.12,27.48 97.62,27.48 100.2,30.06 109.37,30.06 113.55,34.24 115.03,34.24 115.54,34.75 118.05,34.75 121.05,37.75 121.67,38.37 121.67,41.45 122.87,42.64 129.49,42.64 v1(133.32,38.81)
  IN08 w0.091: v1(63.6,30.65) 63.6,25.1 60.8,22.3 60.8,9.99 60.17,9.35 60.17,7.32 63.72,3.76 69.06,3.76 v1(69.57,3.25)
  IN10 w0.091: v1(133.32,38.81) 132.81,39.32 132.81,42 146.49,55.68 159.01,55.68 162.01,58.69 177.13,58.69 178.4,59.96 178.4,65.61 179.29,66.5 199.74,66.5 203.63,70.39 203.63,72.67 204.44,73.49 209.27,73.49 209.9,72.85 209.9,65.99 212.95,62.94 216.5,62.94 222.73,69.17 227.81,69.17 229.97,67.01 229.97,66.09 v3(229.48,65.61)
  BOTTOM w0.097: U2.R39 229.48,65.9 v3(229.48,65.61)
LC_INT0_N_R: length 3
  TOP w0.076: 69.84,6.71 69.84,7.61 U19.D2
  TOP w0.097: R876.1 69.69,5.36 69.69,6.56 69.84,6.71
LC_INT1_N: length 114.3
  TOP w0.097: R620.2 71.62,3.66 71.62,5.77 v3(71.47,5.92) 71.47,6.99 U19.F1
  IN03 w0.089: 39.85,49.23 38.96,50.12 37.82,50.12 36.16,48.47 32.19,48.47 31.97,48.25 31.97,47.7 30.96,46.69
  IN03 w0.091: v1(43.28,49.23) 39.85,49.23 ; v1(26.13,42.88) 29.43,46.18 30.45,46.18 30.96,46.69
  IN10 w0.089: v3(71.47,5.92) 71.09,5.54
  IN10 w0.091: 71.09,5.54 70.84,5.29 69.82,5.29 68.72,4.19 63.6,4.19 62.18,5.61 60.99,5.61 58.96,7.63 53.24,7.63 52.29,6.68 50.13,6.68 47.51,4.06 42.31,4.06 41.75,3.51 29.69,3.51 25.88,7.32 25.88,13.67 25.37,14.18 25.37,18.11 26.23,18.98 26.23,25.48 27.02,26.27 27.02,31.7 26.49,32.24 26.49,37.06 25.62,37.93 25.62,42.37 v1(26.13,42.88)
  BOTTOM w0.097: R308.1 v1(43.28,49.23)
LC_INT1_N_R: length 4.9
  BOTTOM w0.097: R308.2 41.29,48.85 v2(40.76,48.85) 40.38,49.23 40.38,49.64 38.61,51.41 U5.D13
LC_KSI6: length 14.1
  TOP w0.097: U19.H13 72.1,14.04 72.74,14.68 72.74,15.57 71.98,16.34 71.98,17 v1(72.46,17.48)
  BOTTOM w0.097: TP145.1 71.04,24.64 72.02,23.66 72.02,22.39 72.74,21.67 72.74,17.61 72.61,17.48 v1(72.46,17.48)
LC_KSI7: length 15
  TOP w0.089: U19.G9 71.6,11.26 v2(72.23,10.62)
  IN05 w0.089: 66.77,10.75 69.06,10.75 69.44,10.37 69.82,10.37 70.45,11 71.98,11 72.23,10.75 v2(72.23,10.62)
  IN05 w0.091: v1(60.93,8.72) 61.69,8.72 62.71,9.73 65.5,9.73 66.52,10.75 66.77,10.75
  BOTTOM w0.097: TP146.1 v1(60.93,8.72)
LC_KSO16: length 75
  TOP w0.089: 37.31,46.69 38.2,47.58 39.19,47.58 41.5,49.89
  TOP w0.097: R578.1 41.9,53.83 41.6,53.52 41.6,49.99 41.5,49.89 ; v1(36.8,46.18) 37.31,46.69 ; v1(70.45,22.05) 70.45,21.16 70.84,20.78 71.47,20.78 72.23,20.02 72.23,18.65 73.68,17.2 74.29,17.2 74.52,16.97 74.52,14.18 74,13.66 73.39,13.66 U19.K13
  IN05 w0.091: v1(70.45,22.05) 69.57,21.16 55.34,21.16 54.71,21.8 54.71,25.23 45.56,34.37 43.28,34.37 v1(42.26,35.39)
  IN08 w0.091: v1(42.26,35.39) 41.63,36.02 38.58,36.02 38.07,36.53 38.07,38.05 36.67,39.45 36.67,46.05 v1(36.8,46.18)
LC_KSO17: length 74.2
  TOP w0.076: U19.J10 72.85,12.12 72.85,13.54
  TOP w0.089: 74.26,15.07 74.26,14.43 73.76,13.93 73.24,13.93 72.85,13.54
  TOP w0.097: R579.1 42.41,55.96 v1(42.62,56.16) ; v1(69.44,22.05) 70.07,21.42 70.07,21.16 70.71,20.53 71.34,20.53 71.85,20.02 v2(71.85,19.51) 71.85,18.49 72.23,18.11 72.45,18.11 72.89,17.67 72.89,16.16 73.22,15.83 73.88,15.83 74.26,15.45 74.26,15.07
  IN05 w0.091: v1(43.28,35.39) 44.04,34.62 45.82,34.62 54.96,25.48 54.96,21.92 55.47,21.42 65.63,21.42 66.26,22.05 v1(69.44,22.05)
  IN08 w0.091: v1(43.28,35.39) 43.28,35.89 42.64,36.53 40.86,36.53 39.09,38.31 39.09,39.07 40.23,40.21 40.23,42.5 40.41,42.68 40.41,43.82 42.26,45.67 42.26,50.37 42.62,50.73 v1(42.62,56.16)
LC_SCK: length 20.3
  TOP w0.076: 68.45,9.6 68.46,9.61 68.85,9.61 U19.B5
  TOP w0.097: R431.1 v1(52.34,3.64) ; v3(67.79,9.22) 67.91,9.35 68.19,9.35 68.45,9.6
  IN05 w0.089: v3(67.79,9.22) 67.51,8.94 66.77,8.94
  IN05 w0.091: v1(52.34,3.64) 53.82,3.64 55.72,5.54 59.28,5.54 62.68,8.94 66.77,8.94
LC_SCK_R: length 1.6
  TOP w0.097: U16.6 R431.2
LC_SI: length 21.9
  TOP w0.076: 68.42,8.61 69.21,8.61 69.44,8.84 69.44,9.52 U19.B6
  TOP w0.097: R432.1 v1(52.34,2.37) ; v2(67.03,7.95) 67.28,7.95 67.66,8.33 68.14,8.33 68.42,8.61
  IN05 w0.091: v1(52.34,2.37) 53.31,2.37 56.1,5.16 59.66,5.16 61.39,6.89 65.96,6.89 v2(67.03,7.95)
LC_SI_R: length 3.4
  TOP w0.097: R432.2 v2(50.44,1.22) 49.63,1.22 48.81,2.04 U16.5
LC_SO: length 33.9
  TOP w0.097: v1(39.21,2.29) 39.14,2.37 R434.2 ; v3(67.03,9.35) 67.15,9.35 67.41,9.6 68.17,9.6 68.43,9.87 U19.A6
  IN05 w0.089: v3(67.03,9.35) 66.77,9.6
  IN05 w0.091: v1(39.21,2.29) 39.8,2.87 50.26,2.87 51.66,4.27 53.56,4.27 55.47,6.18 59.53,6.18 62.71,9.35 65.5,9.35 66.01,9.86 66.52,9.86 66.77,9.6
LC_SO_R: length 3.2
  TOP w0.097: U16.2 40.3,4.91 v2(39.8,4.4) 40.05,4.14 R434.1
LC_TEST1: length 14.7
  TOP w0.097: v2(60.4,6.1) R407.1 62,6.1 v1(62.07,6.18) 62.12,6.23 R793.1
  TOP w0.102: U19.E7 70.79,10.37 70.96,10.54 v2(70.96,10.62)
  IN05 w0.089: 66.77,6.43 68.55,6.43 69.95,7.83 69.95,9.6 v2(70.96,10.62)
  IN05 w0.091: 66.77,6.43 65.37,6.43 65.25,6.3 62.2,6.3 v1(62.07,6.18)
LC_VCORE2/CK32KE: length 2.6
  TOP w0.089: v2(72,6.05) 72.36,5.69
  TOP w0.097: 72.36,5.69 C249.1 ; U19.G1 71.85,7.11 71.85,6.2 v2(72,6.05)
LC_WP_N: length 3.1
  TOP w0.097: U16.3 v1(42.9,3.64)
  BOTTOM w0.097: R783.1 v2(42.62,2.87) 42.62,3.36 v1(42.9,3.64)
LC_WRST_N: length 5.5
  TOP w0.089: v2(76.42,6.68) 76.42,5.87 76.09,5.54
  TOP w0.097: 76.09,5.54 R525.2
  TOP w0.203: U19.L1 73.6,6.46 73.75,6.31
  TOP w0.254: R525.2 C1368.1 75.03,5.79 74.77,6.05 74.01,6.05 73.75,6.31
LED_GPB6: length 4
  TOP w0.076: U19.H4 72.1,8.22 72.35,7.96 72.35,6.56
  TOP w0.097: TP142.1 73.2,5.34 72.61,5.92 72.61,6.29 72.35,6.56
LED_GPC0: length 2.1
  TOP w0.097: U19.D1 70.1,6.58 69.95,6.43 69.95,5.67 TP137.1
LED_GPC4: length 3.6
  TOP w0.076: U19.C2 69.34,7.61 69.34,6.97
  TOP w0.097: R896.1 68.75,4.93 68.75,6.38 69.34,6.97
LED_GPC6: length 2.9
  TOP w0.097: U19.E1 70.6,7.13 70.78,6.94 70.78,5.67 70.58,5.46 70.58,5.16 TP139.1
LED_GPH0: length 3.9
  TOP w0.076: U19.D8 69.34,10.11 68.4,10.11
  TOP w0.089: 66.77,9.99 67.51,9.99 67.63,9.86
  TOP w0.097: 66.77,9.99 TP134.1 ; 68.4,10.11 68.14,9.86 67.63,9.86
LED_GPH3: length 2.9
  TOP w0.097: v2(66.03,10.49) 66.36,10.82 67.93,10.82 68.47,11.37 U19.A9
LED_GPH4: length 2.8
  TOP w0.076: U19.B8 68.84,11.12 68.49,11.12
  TOP w0.097: 68.49,11.12 67.93,10.56 66.71,10.56 TP136.1
LED_KB_PWM1: length 26.1
  TOP w0.076: U19.M5 74.35,9.11 74.77,9.11
  TOP w0.097: v2(76.93,8.33) 76.21,9.05 74.83,9.05 74.77,9.11
  BOTTOM w0.097: v2(76.93,8.33) 77.19,8.33 77.65,7.87 78.43,7.87 79.49,6.81 89.5,6.81 90.39,7.7 v2(90.39,8.59) 90.39,9.99 89.76,10.62 89.76,14.94 89.59,15.1 JKB1.5
LED_KB_PWM2: length 23.7
  TOP w0.097: U19.N5 75.38,9.37 v2(75.41,9.39)
  BOTTOM w0.089: 76.55,8.93 75.87,8.93 v2(75.41,9.39)
  BOTTOM w0.097: 76.55,8.93 77.02,8.93 77.19,8.76 78.2,8.76 79.77,7.19 v2(85.19,7.19) 88.11,7.19 89.12,8.21 89.12,14.05 88.82,14.35 88.82,15.14 89.09,15.42 JKB1.6
LED_KB_PWM3: length 23.4
  TOP w0.076: U19.M6 74.34,10.11 74.9,10.11
  TOP w0.097: v2(77.19,9.33) 76.78,9.73 75.92,9.73 75.41,10.24 75.03,10.24 74.9,10.11 74.9,10.11
  BOTTOM w0.097: JKB1.7 88.59,14.2 88.87,13.92 88.87,9.22 87.22,7.57 79.85,7.57 78.44,8.98 77.53,8.98 v2(77.19,9.33)
LED_KB_PWM4: length 22.5
  TOP w0.097: v2(76.3,9.38) 75.91,9.38 75.42,9.87 U19.N6
  BOTTOM w0.089: v2(76.3,9.38) 76.55,9.64
  BOTTOM w0.097: 76.55,9.64 76.71,9.79 78.35,9.79 80.32,7.83 86.71,7.83 v2(87.22,8.33) 87.22,10.75 87.85,11.38 87.85,12.14 86.98,13.02 86.98,13.66 88.09,14.77 JKB1.8
LED_KB_PWM5: length 39.6
  BOTTOM w0.089: 76.47,9.99 76.3,9.81
  BOTTOM w0.097: 76.3,9.81 73.45,9.81 73.27,9.63 73.27,9 72.99,8.72 72.99,7.57 71.72,6.3 68.8,6.3 68.42,6.68 68.42,7.8 67.28,8.94 65.6,8.94 64.86,8.2 62.36,8.2 62.07,8.49 62.07,9.45 62.38,9.76 R877.2 ; JKB1.9 87.59,14.59 86.71,13.7 86.71,12.02 86.08,11.38 83.92,11.38 83.66,11.13 83.66,8.33 83.41,8.08 80.38,8.08 79.47,8.99 79.47,9.48 78.96,9.99 v2(78.71,9.99) 78.58,10.11 76.6,10.11 76.47,9.99
LED_KB_PWM6: length 38.9
  BOTTOM w0.097: JKB1.10 87.09,14.56 86.46,13.92 86.46,12.27 85.95,11.76 83.79,11.76 83.28,11.26 83.28,8.72 v2(83.03,8.46) 82.9,8.33 80.49,8.33 79.73,9.1 79.73,9.86 79.22,10.37 76.55,10.37 76.19,10.01 74.75,10.01 74.14,10.62 73.5,10.62 73.27,10.39 73.27,9.92 73.04,9.69 73.04,9.15 72.74,8.84 72.74,7.7 71.6,6.56 68.9,6.56 68.68,6.78 68.68,7.87 68.17,8.37 68.17,9.48 67.89,9.75 66.08,9.75 64.75,8.43 62.73,8.43 62.63,8.52 R878.2
LED_KB_PWM7: length 21.3
  TOP w0.076: U19.M7 74.24,10.37 74.49,10.62 74.77,10.62
  TOP w0.097: 74.77,10.62 74.9,10.75 74.9,10.94 75.28,11.32 75.59,11.32 76.04,10.87 v2(76.17,10.87)
  BOTTOM w0.089: v2(76.17,10.87) 76.55,11.26
  BOTTOM w0.097: JKB1.11 86.59,14.38 86.2,13.98 86.2,12.53 85.82,12.14 83.54,12.14 82.9,11.51 82.9,9.35 82.39,8.84 v2(80.59,8.84) 80.59,8.87 80.23,9.22 80.23,11 79.85,11.38 76.68,11.38 76.55,11.26
LED_KB_PWM8: length 30.3
  TOP w0.102: U19.K7 73.63,10.9 v2(73.63,11)
  IN10 w0.089: v2(73.63,11) 73.63,10.75 72.87,9.99 72.87,6.56 73.88,5.54
  IN10 w0.091: 73.88,5.54 74.77,4.65 77.57,4.65 78.16,4.06 79.77,4.06 82.27,6.56 82.27,9.48 83.54,10.75 83.54,12.65 v3(85.69,14.81)
  BOTTOM w0.097: v3(85.69,14.81) 86.09,15.21 JKB1.12 ; v2(75.76,10.39) 74.87,10.39 74.26,11 v2(73.63,11)
LED_KB_PWM9: length 21.6
  TOP w0.097: U19.N1 75.03,6.94 75.41,6.94 v2(75.79,6.56)
  IN10 w0.089: v2(75.79,6.56) 75.79,6.05 76.3,5.54 76.55,5.54
  IN10 w0.091: v3(85.69,16.72) 85.69,15.95 81.38,11.64 81.38,7.59 80.34,6.56 78.46,6.56 78.2,6.3 78.2,5.94 77.76,5.5 76.6,5.5 76.55,5.54
  BOTTOM w0.089: v2(75.79,6.56) 75.79,6.18 v2(76.04,5.92)
  BOTTOM w0.097: v3(85.69,16.72) 85.59,16.62 JKB1.13
LED_KB_PWM10: length 20.9
  TOP w0.097: U19.N3 74.9,8.37 75.38,7.89 76.11,7.89 76.3,7.7 v2(76.3,7.45)
  IN10 w0.089: v2(76.3,7.45) 76.55,7.19
  IN10 w0.091: 76.55,7.19 76.73,7.01 80.18,7.01 81,7.83 81,11.76 85.06,15.83 v3(85.06,16.72)
  BOTTOM w0.089: v2(76.3,7.45) 76.55,7.19
  BOTTOM w0.097: v3(85.06,16.72) 85.09,16.68 JKB1.14 ; 76.55,7.19 76.7,7.04 77.67,7.04 v2(77.95,7.32)
LED_KB_PWM11: length 19.9
  TOP w0.076: U19.M4 74.34,8.62 75.13,8.62 v2(75.41,8.33)
  IN10 w0.089: 76.55,8.84 75.92,8.84 75.41,8.34 v2(75.41,8.33)
  IN10 w0.091: 76.55,8.84 79.6,8.84 80.49,9.73 80.49,12.53 82.63,14.66 82.63,17.59 v3(83.28,18.24)
  BOTTOM w0.097: v3(83.28,18.24) 83.79,17.73 83.79,17.35 84.59,16.55 JKB1.15
LED_KB_PWM12: length 18.5
  TOP w0.097: v2(76.3,8.33) 75.76,8.87 U19.N4
  IN10 w0.089: v2(76.3,8.33) 76.55,8.08
  IN10 w0.091: v3(83.28,17.48) 82.88,17.08 82.88,14.54 80.74,12.4 80.74,9.1 79.6,7.95 76.68,7.95 76.55,8.08
  BOTTOM w0.097: v3(83.28,17.48) 84.09,16.67 JKB1.16
LED_KB_PWM13: length 28
  TOP w0.076: 73.85,7.1 73.85,7.61 U19.L2
  TOP w0.097: v2(74.14,6.56) 74.14,6.81 73.85,7.1
  IN10 w0.089: 74.26,5.54 74.14,5.67 v2(74.14,6.56)
  IN10 w0.091: v3(83.28,16.72) 83.68,17.12 85.86,17.12 86.2,16.78 86.2,16.21 85.91,15.92 85.91,15.86 83.15,13.11 83.15,11 82.01,9.86 82.01,6.61 79.68,4.28 78.26,4.28 77.63,4.91 74.9,4.91 74.26,5.54
  BOTTOM w0.097: JKB1.17 83.59,16.4 v3(83.28,16.72)
LED_KB_PWM14: length 15.2
  TOP w0.076: U19.N7 74.9,10.37 75.03,10.49
  TOP w0.097: v2(75.41,10.87) 75.03,10.49
  BOTTOM w0.089: v2(75.41,10.87) 75.41,11.38 75.92,11.89 76.3,11.89 76.42,11.76 76.55,11.76
  BOTTOM w0.097: 76.55,11.76 79.98,11.76 81.63,10.11 v2(82.06,10.11) 82.52,10.57 82.52,11.7 83.09,12.27 JKB1.18
LED_KB_PWM15: length 15.5
  TOP w0.076: U19.M11 74.17,12.37 74.41,12.12 74.89,12.12
  TOP w0.097: v2(75.41,12.12) 74.89,12.12
  BOTTOM w0.097: v2(75.41,12.12) 76.15,12.12 76.55,12.53 78.58,12.53 81.12,15.07 82.39,15.07 82.59,15.27 JKB1.19 82.59,19.84 82.9,20.15 v2(82.9,20.78)
LED_KB_PWM16: length 15.5
  TOP w0.076: 74.87,12.62 74.34,12.62 U19.M12
  TOP w0.097: v2(75.41,13.29) 75.41,13.16 74.87,12.62
  IN10 w0.089: 76.55,12.86 75.83,12.86 v2(75.41,13.29)
  IN10 w0.091: v3(81.76,17.48) 81.6,17.48 81.38,17.26 81.38,16.49 77.74,12.86 76.55,12.86
  BOTTOM w0.097: v2(81.38,19.51) 81.76,19.51 82.27,19 82.27,17.99 v3(81.76,17.48) 82.27,16.97 82.27,16.34 82.09,16.16 JKB1.20
LED_KB_PWM17: length 18.1
  TOP w0.097: v2(75.03,7.45) 75.03,7.7 74.86,7.87 U19.N2
  IN10 w0.089: 76.55,10.11 75.03,10.11 74.65,9.73 74.65,7.83 v2(75.03,7.45)
  IN10 w0.091: 76.55,10.11 77.44,10.11 77.9,10.57 77.9,11.33 78.33,11.76 79.34,11.76 81.25,13.67 81.25,15.07 82.14,15.95 82.14,16.48 v3(81.78,16.84)
  BOTTOM w0.089: v2(75.03,7.45) 75.03,7.7 74.39,8.33 v2(74.39,8.59)
  BOTTOM w0.097: JKB1.21 81.59,16.3 81.78,16.48 v3(81.78,16.84)
LED_KB_PWM18: length 22.1
  TOP w0.097: v2(67.91,13.59) 68.38,13.59 U19.A13
  IN10 w0.089: v2(67.91,13.59) 71.77,13.59 73.25,15.07 76.3,15.07
  IN10 w0.091: v3(81.76,18.11) 82.27,18.62 82.27,18.88 81.88,19.26 81.63,19.26 81.12,18.75 81.12,18.11 80.87,17.86 80.87,16.97 79.6,15.7 76.93,15.7 76.3,15.07
  BOTTOM w0.097: v3(81.76,18.11) 81.73,18.11 v2(81.09,17.48) JKB1.22
LED_KB_PWM19: length 21.1
  TOP w0.097: v2(67.91,12.91) 68.04,12.91 68.08,12.87 U19.A12
  IN10 w0.089: v2(67.91,12.91) 71.72,12.91 73.63,14.81 76.42,14.81 76.55,14.94
  IN10 w0.091: 76.55,14.94 77.06,15.45 79.65,15.45 81.09,16.88 81.09,17.76 81.35,18.02 81.35,18.34 v3(81.76,18.75)
  BOTTOM w0.097: v3(81.76,18.75) 81.76,18.69 80.59,17.52 JKB1.23
LED_KB_PWM20: length 27.4
  TOP w0.076: U19.B12 68.84,13.12 68.48,13.12
  TOP w0.097: 68.48,13.12 68.35,13.25 67.37,13.25 v2(67.03,12.91)
  BOTTOM w0.097: v2(67.03,12.91) 66.64,12.53 66.64,11.89 66.77,11.76 67.91,11.76 68.17,11.51 68.17,10.75 68.4,10.52 68.4,8.43 68.93,7.9 68.93,7.06 v2(69.06,6.94) 71.6,6.94 72.55,7.89 72.55,9.03 72.82,9.3 72.82,9.81 73.07,10.06 73.07,11.08 73.38,11.38 73.88,11.38 74.26,11.76 74.26,12.14 74.65,12.53 76.17,12.53 76.5,12.86 78.53,12.86 80.09,14.42 JKB1.24
LED_KB_PWM21: length 20.2
  TOP w0.076: 70.34,7.07 70.34,7.61 U19.E2
  TOP w0.097: v2(77.95,15.07) 77.97,15.07 v3(78.38,14.66) ; 70.34,7.07 70.34,7.06 70.34,5.93 v3(70.33,5.92)
  IN10 w0.089: 76.55,14.56 74.14,14.56 72.99,13.41 72.99,10.37 72.61,9.99 72.61,8.21 v3(70.33,5.92)
  IN10 w0.091: 76.55,14.56 77.19,15.19 77.85,15.19 v3(78.38,14.66)
  BOTTOM w0.097: v3(78.38,14.66) 78.61,14.43 79.47,14.43 79.59,14.55 JKB1.25
LED_KB_PWM22: length 22
  TOP w0.097: U19.N8 74.6,10.95 75.15,11.51 75.53,11.51 75.92,11.89 75.92,15.07 75.66,15.32 75.66,16.59 75.46,16.8 75.46,16.89 75.28,17.07 75.28,17.35 v2(75.15,17.48) 74.39,17.48 74.14,17.73 v1(73.88,17.73)
  BOTTOM w0.097: JKB1.26 79.09,16.21 80.23,17.35 80.23,17.48 81.07,18.31 81.07,19.18 80.49,19.76 75.15,19.76 73.88,18.49 v1(73.88,17.73)
LED_KB_PWM23: length 14.6
  TOP w0.097: v2(76.8,14.81) 76.89,14.73 v3(77.46,14.73) ; U19.M1 74.1,7.23 74.77,6.56 v2(75.15,6.56)
  IN10 w0.089: 76.55,14.24 75.98,13.67 75.03,13.67 74.39,13.03 74.39,7.19 75.03,6.56 v2(75.15,6.56)
  IN10 w0.091: 76.55,14.24 76.97,14.24 v3(77.46,14.73)
  BOTTOM w0.097: v3(77.46,14.73) 77.63,14.73 77.97,15.07 78.24,15.07 78.59,15.42 JKB1.27
LED_KB_PWM24: length 17.1
  TOP w0.076: 74.89,8.11 74.35,8.11 U19.M3
  TOP w0.097: 74.89,8.11 75.31,7.7 75.41,7.7 v2(75.66,7.45)
  IN05 w0.089: v2(75.66,7.45) 74.65,8.46 74.65,15.07
  IN05 w0.091: v3(74.01,16.72) 74.65,16.08 74.65,15.07
  BOTTOM w0.097: JKB1.28 78.09,16.19 77.82,16.46 75.76,16.46 75.45,16.77 75.45,16.9 75.2,17.15 74.44,17.15 v3(74.01,16.72)
LED_KB_PWM25: length 20.4
  TOP w0.097: v2(67.91,12.14) 68.16,12.14 68.38,12.37 U19.A11
  BOTTOM w0.089: 76.55,14.56 76.17,14.18 76.17,13 75.9,12.73 74.34,12.73 74.01,12.4 74.01,11.89 73.8,11.68 73.29,11.68 72.87,11.26 72.87,10.19 72.61,9.93 72.61,9.48 72.36,9.22 72.36,8.08 71.72,7.45 v2(71.09,7.45) 69.69,7.45 68.63,8.51 68.63,10.67 68.42,10.87 68.42,11.76 68.04,12.14 v2(67.91,12.14)
  BOTTOM w0.097: JKB1.29 77.59,15.42 77.24,15.07 77.06,15.07 76.55,14.56
LED_KB_PWM26: length 22.6
  TOP w0.076: U19.B11 68.84,12.62 68.29,12.62
  TOP w0.097: 68.29,12.62 68.16,12.49 67.37,12.49 v2(67.03,12.14)
  BOTTOM w0.089: 76.55,14.87 75.89,14.21 75.89,13.13 75.66,12.91 73.76,12.91 73.25,12.4 73.25,11.89 72.61,11.26 72.61,10.37 72.49,10.24 71.85,10.24 71.77,10.16 71.77,9.48 71.9,9.35 v2(71.9,9.1) 71.9,8.38 71.47,7.95 69.47,7.95 68.8,8.62 68.8,12.02 68.3,12.53 67.41,12.53 v2(67.03,12.14)
  BOTTOM w0.097: JKB1.30 77.09,15.42 76.55,14.87
LED_KB_PWM27: length 12
  TOP w0.076: U19.D9 v2(69.57,10.84)
  BOTTOM w0.089: 76.24,15.07 75.66,14.48 75.66,14.05 75.28,13.67 73.25,13.67 72.99,13.41 72.99,12.4 72.36,11.76 70.71,11.76 70.4,11.46 v2(70.4,10.32) 70,10.32 69.57,10.75 v2(69.57,10.84)
  BOTTOM w0.097: 76.24,15.07 76.59,15.42 JKB1.31
LED_KB_PWM28: length 12.6
  TOP w0.076: 69.08,11.38 U19.B9
  TOP w0.097: v2(69.57,11.38) 69.08,11.38
  BOTTOM w0.089: v2(69.18,8.84) 69.06,8.97 69.06,10.87 v2(69.57,11.38) 70.2,12.02 72.36,12.02 72.74,12.4 72.74,13.67 72.99,13.92 74.39,13.92 75.3,14.83 75.51,14.83 75.74,15.07
  BOTTOM w0.097: JKB1.32 76.09,15.42 75.74,15.07
LED_KB_PWM29: length 9.9
  TOP w0.076: 73.21,14.65 72.35,13.79 72.35,12.52 v2(72.23,12.4)
  TOP w0.089: v2(73.89,14.75) 73.31,14.75 73.21,14.65 ; 72.13,12.4 U19.G10
  TOP w0.102: v2(72.23,12.4) 72.13,12.4
  BOTTOM w0.089: v2(72.23,12.4) 72.23,13.67 72.74,14.18 74.35,14.18 75.24,15.07
  BOTTOM w0.097: 75.24,15.07 75.59,15.42 JKB1.33
LED_KB_PWM30: length 6.1
  TOP w0.089: v2(72,15.07) 72,14.85 v2(71.6,14.45)
  TOP w0.097: U19.G13 v2(71.6,14.45)
  BOTTOM w0.089: v2(71.6,14.45) 74.12,14.45 74.74,15.07
  BOTTOM w0.097: 74.74,15.07 75.09,15.42 JKB1.34
LED_SPKR_PWM_B: length 479.1
  TOP w0.097: v1(301.09,168.35) 307.15,162.29 307.15,108.89 305.02,106.76 305.02,102.84 305.42,102.44 v1(305.53,102.44) ; v2(71.22,20.02) 70.84,19.64 70.84,19.26 70.43,18.85 70.16,18.85 69.77,18.46 69.77,16.46 70.6,15.63 U19.E13
  IN10 w0.091: v1(301.09,168.35) 301.09,169.75 298.17,172.67 296.13,172.67 289.53,179.28 289.53,180.55 284.58,185.5 282.87,185.5 281.28,187.09 272.66,187.09 271.71,188.04 220.26,188.04 211.37,196.93 210.76,196.93 209.9,197.79 209.9,198.71 209.09,199.52 208.42,199.52 208.06,199.15 198.66,199.15 198.47,199.34 185.44,199.34 184.78,198.68 184.78,197.08 184.42,196.72 179.67,196.72 179.18,197.22 175.1,197.22 174.73,197.59 171.19,197.59 170.58,198.2 166.97,198.2 166.47,198.71 160.52,198.71 159.03,197.22 155.96,197.22 148.31,189.56 148.31,183.85 145.77,181.31 128.62,181.31 126.46,179.15 119.22,179.15 114.14,174.07 114.14,132.03 111.09,128.98 111.09,113.62 105.89,108.41 97.89,108.41 89.25,99.77 89.25,94.06 84.82,89.62 84.82,75.4 84.42,75.01 84.42,68.15 82.28,66 82.28,62.47 80.87,61.06 80.87,56.59 82.52,54.94 82.52,40.97 73.5,31.96 73.5,20.78 71.6,18.88 71.07,18.88 70.84,19.11 70.84,19.64 v2(71.22,20.02)
  BOTTOM w0.097: JSPBL1.3 306.44,103.35 v1(305.53,102.44)
LED_SPKR_PWM_G: length 475.7
  TOP w0.076: 70.84,13.47 70.84,13.12 U19.F12
  TOP w0.097: v2(71.22,19.26) 70.84,18.88 70.84,18.32 70.63,18.11 70.63,16.45 70.84,16.25 70.84,13.47 70.84,13.47 ; v1(305.53,101.81) 304.64,102.7 304.64,107.01 306.8,109.17 306.8,160.48 v1(301.09,166.2)
  IN10 w0.091: v2(71.22,19.26) 72.49,20.53 72.49,31.7 82.27,41.48 82.27,48.34 81.38,49.23 81.38,50.24 82.14,51.01 82.14,54.82 80.61,56.34 80.61,61.29 82.06,62.74 82.06,66.17 84.17,68.28 84.17,75.14 84.6,75.56 84.6,89.79 88.87,94.06 88.87,99.9 97.63,108.66 100.81,108.66 110.78,118.63 110.78,129.05 113.51,131.78 113.51,173.74 119.17,179.4 126.33,179.4 128.46,181.53 145.48,181.53 148.05,184.1 148.05,189.82 155.67,197.44 158.94,197.44 160.43,198.93 166.76,198.93 167.23,198.45 170.63,198.45 171.28,197.81 174.86,197.81 175.23,197.44 179.55,197.44 180.04,196.94 184.27,196.94 184.52,197.18 184.52,198.75 185.36,199.6 198.6,199.6 198.83,199.37 207.89,199.37 208.26,199.73 209.25,199.73 210.14,198.84 210.14,197.86 210.82,197.18 211.42,197.18 220.31,188.29 271.77,188.29 272.71,187.35 281.33,187.35 282.93,185.75 284.68,185.75 289.91,180.53 289.91,179.28 296.01,173.18 298.42,173.18 301.72,169.88 301.72,166.83 v1(301.09,166.2)
  BOTTOM w0.097: JSPBL1.4 306.27,102.55 v1(305.53,101.81)
LED_SPKR_PWM_R: length 477.5
  TOP w0.097: v1(305.53,101.17) 303.5,103.2 303.5,106.57 306.42,109.49 306.42,159.97 v1(301.09,165.31)
  TOP w0.102: U19.F10 71.1,12.14 v2(70.84,12.4)
  IN08 w0.089: v2(70.84,12.4) 70.84,15.07
  IN08 w0.091: v1(71.22,21.29) 70.84,20.91 70.84,18.11 70.66,17.94 70.66,16.13 70.84,15.95 70.84,15.07
  IN10 w0.091: v1(71.22,21.29) 71.22,21.92 71.47,22.18 71.47,31.58 80.61,40.72 80.61,47.65 79.6,48.67 79.6,64.34 83.15,67.9 83.41,67.9 83.92,68.41 83.92,75.39 84.3,75.77 84.3,80.6 83.54,81.36 83.54,89.12 88.6,94.19 88.6,99.94 97.58,108.92 100.55,108.92 110.46,118.82 110.46,129.24 113.13,131.91 113.13,173.67 119.11,179.66 126.21,179.66 128.33,181.78 145.22,181.78 147.8,184.36 147.8,189.94 155.58,197.73 158.92,197.73 160.33,199.14 166.92,199.14 167.36,198.71 170.69,198.71 171.37,198.03 175.12,198.03 175.46,197.69 178.02,197.69 178.2,197.86 182.01,197.86 182.54,197.34 184.07,197.34 184.3,197.56 184.3,198.91 185.24,199.85 198.72,199.85 198.99,199.59 207.73,199.59 208.1,199.95 209.42,199.95 210.36,199.01 210.36,197.95 210.87,197.44 211.81,197.44 220.7,188.55 271.82,188.55 272.8,187.57 281.49,187.57 283.07,185.99 284.85,185.99 297.4,173.43 298.55,173.43 302.17,169.82 302.17,166.39 v1(301.09,165.31)
  BOTTOM w0.097: JSPBL1.5 306.24,101.75 305.66,101.17 v1(305.53,101.17)
LED_TP_PWM_B: length 283.5
  TOP w0.097: U19.F13 71.1,14.57 71.52,14.99 71.52,18.19 v2(71.22,18.49)
  IN03 w0.091: v1(71.85,42.24) 73.38,40.72 82.9,40.72 83.43,41.25 98.12,41.25 100.21,39.16 107.36,39.16 118.87,50.67 151.69,50.67 159.35,43.01 209.52,43.01 214.32,38.2 256.91,38.2 260.19,41.48 262.48,41.48 264.26,39.7 264.26,35.89 264.76,35.39 264.76,32.97 264.26,32.46 264.26,28.27 265.02,27.51 265.02,22.18 269.72,17.48 282.42,17.48 287.31,22.38 287.31,22.38 v1(287.75,22.81)
  IN08 w0.091: v2(71.22,18.49) 71.6,18.49 73.42,20.32 73.42,22.64 72.02,24.04 72.02,42.07 v1(71.85,42.24)
  BOTTOM w0.097: v1(287.75,22.81) 287.85,22.91 JTPBL1.3
LED_TP_PWM_G: length 283.1
  TOP w0.076: 71.09,11.37 U19.F9
  TOP w0.089: v2(71.6,10.62) 71.09,11.13 71.09,11.37
  IN03 w0.091: v1(73.63,42.24) 74.93,40.94 82.77,40.94 83.31,41.47 105.9,41.47 106.91,40.47 108.36,40.47 118.78,50.88 152.01,50.88 159.51,43.39 209.65,43.39 214.61,38.42 256.49,38.42 259.81,41.74 262.73,41.74 265.4,39.07 265.4,22.3 269.84,17.86 281.91,17.86 v1(286.87,22.82)
  IN08 w0.089: v2(71.6,10.62) 71.6,11.76 71.85,12.02 71.85,13.67 72.36,14.18 72.36,15.07
  IN08 w0.091: 72.36,15.07 72.36,15.8 72.89,16.34 72.89,18.01 74.26,19.38 74.26,22.85 72.46,24.66 72.46,38.41 73.63,39.58 v1(73.63,42.24)
  BOTTOM w0.097: v1(286.87,22.82) 286.85,22.84 JTPBL1.4
