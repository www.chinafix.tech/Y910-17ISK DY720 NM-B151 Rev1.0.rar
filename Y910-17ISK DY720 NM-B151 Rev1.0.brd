# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDC4: length 28.4
  IN10 w0.14: v3(291.43,113.09) 291.03,112.69 291.03,110.38 288.86,108.21 278.84,108.21 276.72,110.34 276.72,112.04 274.62,114.14 272.01,114.14 v3(271.19,114.97)
  BOTTOM w0.152: U2025.N4 291.03,113.48 v3(291.43,113.09) ; v3(271.19,114.97) G2.B4
MDC5: length 22.8
  IN10 w0.14: v3(272.74,114.64) 272.77,114.61 273.16,114.61 273.16,114.61 275.04,114.61 280.61,114.61 284.39,110.82 286.23,110.82 286.97,110.08 289.92,110.08 290.23,110.38 290.23,111.09 290.63,111.49 v3(290.63,111.49)
  BOTTOM w0.152: U2025.N2 291.02,111.88 v3(290.63,111.49) ; G2.A4 271.71,115.14 272.24,115.14 v3(272.74,114.64)
MDC6: length 31
  IN10 w0.14: v3(272.73,113.33) 273.37,113.33 275.6,111.1 275.6,109.87 278.37,107.1 290.04,107.1 292.86,109.91 292.86,112.46 v3(292.23,113.09)
  BOTTOM w0.152: v3(272.73,113.33) 271.84,114.22 271.24,114.22 G2.B3 ; U2025.M4 291.83,113.48 v3(292.23,113.09)
MDC7: length 28.9
  IN10 w0.14: v3(291.43,111.49) 291.83,111.09 291.83,109.93 289.55,107.65 278.61,107.65 276.16,110.1 276.16,111.6 273.96,113.8 271.95,113.8 271.29,114.47 270.99,114.47 v3(270.49,114.97)
  BOTTOM w0.152: G2.C4 v3(270.49,114.97) ; v3(291.43,111.49) 291.82,111.88 U2025.M2
MDC8: length 19.3
  IN03 w0.14: v3(269.79,119.07) 270.3,118.55 271.37,118.55 272.36,119.54 287.37,119.54 v3(287.43,119.49)
  BOTTOM w0.152: v3(287.43,119.49) U2025.U11 ; G2.D9 v3(269.79,119.07)
MDC9: length 18.8
  IN03 w0.14: v3(287.43,121.09) 286.44,120.1 271.52,120.1 v3(270.49,119.07)
  BOTTOM w0.152: v3(287.43,121.09) U2025.U13 ; G2.C9 v3(270.49,119.07)
MDC10: length 21.4
  IN03 w0.14: v3(288.23,119.49) 287.72,118.98 274.22,118.98 273.62,118.38 272.12,118.38 271.86,118.12 270.01,118.12 v3(268.94,119.2)
  BOTTOM w0.152: v3(268.94,119.2) 268.94,118.92 G2.E9 ; U2025.T11 288.63,119.08 v3(288.23,119.49)
MDC11: length 19.2
  IN05 w0.076: v3(288.23,121.08) 287.82,120.68 287.13,120.68
  IN05 w0.14: 287.13,120.68 286.3,119.84 273.26,119.84 v3(272.26,118.84)
  BOTTOM w0.152: v3(288.23,121.09) U2025.T13 ; v3(272.26,118.84) 271.84,118.42 271.24,118.42 G2.B9
MDC12: length 23.4
  IN03 w0.14: v3(272.99,117.01) 273.96,116.04 283.94,116.04 284.23,115.74 287.87,115.74 290.23,118.1 290.23,119.09 v3(290.63,119.49)
  BOTTOM w0.152: v3(272.99,117.01) 272.3,117.7 271.25,117.7 G2.B8 ; v3(290.63,119.49) U2025.N11
MDC13: length 23.3
  IN03 w0.14: v3(290.63,121.09) 290.23,120.69 290.23,120.08 290.03,119.89 289.63,119.89 289.43,119.69 289.43,118.17 288.18,116.92 284.25,116.92 283.93,116.6 274.57,116.6 v3(274.15,117.01)
  BOTTOM w0.152: G2.A8 273.11,118.07 274.15,117.03 v3(274.15,117.01) ; v3(290.63,121.09) 291.03,120.68 U2025.N13
MDC14: length 28.6
  IN03 w0.14: v3(291.43,119.49) U2025.M11 291.83,117.65 288.79,114.61 273.35,114.61 272.64,115.32 272.64,115.56 272.08,116.12 268.63,116.12 v3(268.39,116.37)
  BOTTOM w0.152: v3(291.43,119.49) U2025.M11 ; G2.F6 v3(268.39,116.37)
MDC15: length 28.7
  IN03 w0.14: v3(291.43,121.09) 291.43,121.09 291.03,120.69 291.03,118.01 288.2,115.18 282.76,115.18 282.47,115.48 273.78,115.48 272.7,116.56 268.9,116.56 v3(268.49,116.97)
  BOTTOM w0.152: v3(268.49,116.97) G2.E6 ; v3(291.43,121.09) U2025.M13
MDC16: length 43.1
  IN03 w0.076: 268.86,126.35 268.66,126.55 268.16,126.55 267.98,126.38 267.98,125.77 v3(267.69,125.47)
  IN03 w0.14: v3(301.02,118.69) 301.03,118.69 302.55,120.2 302.55,122.88 299.55,125.88 271.54,125.88 271.07,126.35 268.86,126.35
  BOTTOM w0.152: G2.F18 v3(267.69,125.47) ; U2025.A11 300.63,119.08 v3(301.02,118.69)
MDC17: length 38.3
  IN03 w0.14: v3(267.09,125.37) 267.09,125.37 267.53,124.93 270.55,124.93 271.16,124.32 285.65,124.32 285.95,124.62 299.19,124.62 301.43,122.38 301.43,121.49 v3(301.03,121.08)
  BOTTOM w0.152: G2.G18 v3(267.09,125.37) ; v3(301.03,121.08) U2025.A13
MDC18: length 40.8
  IN03 w0.14: v3(300.22,118.69) 300.23,118.69 300.63,119.09 300.63,119.66 300.86,119.88 301.26,119.88 301.99,120.62 301.99,122.64 299.45,125.18 285.69,125.18 285.39,124.88 271.73,124.88 270.55,126.07 269.78,126.07 v3(269.09,125.37)
  BOTTOM w0.152: v3(269.09,125.37) G2.E18 ; v3(300.22,118.69) 299.83,119.08 U2025.B11
MDC19: length 39.8
  IN03 w0.14: v3(300.22,120.29) 300.63,120.69 300.63,122.38 298.95,124.06 286.29,124.06 285.56,123.33 271.52,123.33 270.37,124.48 267.28,124.48 v3(266.21,125.54)
  BOTTOM w0.152: U2025.B13 299.83,120.68 v3(300.22,120.29) ; G2.H18 v3(266.21,125.54)
MDC20: length 34
  IN03 w0.14: v3(269.96,123.54) 270.17,123.33 270.82,123.33 271.39,122.77 285.79,122.77 286.53,123.5 297.45,123.5 298.22,122.72 298.22,119.88 297.83,119.49 v3(297.82,119.49)
  BOTTOM w0.152: v3(269.96,123.54) 269.96,123.46 269.49,122.99 G2.D15 ; v3(297.82,119.49) 297.43,119.09 U2025.E11
MDC21: length 33.1
  IN03 w0.14: v3(297.02,120.29) 297.42,120.69 297.42,122.1 296.63,122.89 292.95,122.89 292.65,122.59 290.85,122.59 290.55,122.89 286.71,122.89 286.03,122.21 271.35,122.21 270.58,122.98 269.44,122.98 v3(268.87,123.55)
  BOTTOM w0.152: v3(268.87,123.55) 268.79,123.46 G2.E15 ; U2025.E13 297.42,120.68 v3(297.02,120.29)
MDC22: length 34.1
  IN03 w0.14: v3(297.02,119.49) 296.62,119.89 296.62,122.08 296.37,122.33 286.94,122.33 286.26,121.65 271.3,121.65 270.36,122.59 269.06,122.59 v3(267.69,123.97)
  BOTTOM w0.152: G2.G17 267.39,124.32 267.69,124.02 v3(267.69,123.97) ; v3(297.02,119.49) 296.63,119.09 U2025.F11
MDC23: length 33
  IN03 w0.14: v3(266.39,124.07) 266.64,123.82 266.64,122.87 266.98,122.53 267.95,122.53 268.26,122.21 270.13,122.21 271.26,121.09 286.44,121.09 286.84,121.49 294.08,121.49 294.48,121.08 v3(296.22,121.08)
  BOTTOM w0.152: U2025.F13 296.62,120.68 v3(296.22,121.08) ; G2.H17 v3(266.39,124.07)
MDC24: length 41.6
  IN10 w0.14: v3(301.02,113.89) 301.02,113.89 301.42,114.29 301.42,115.36 300.3,116.49 299.58,116.49 298.81,117.26 294.03,117.26 293.52,117.77 288.53,117.77 285.05,121.26 276.67,121.26 276.36,121.57 272.57,121.57 271.77,122.36 266.59,122.36 v3(265.69,123.27)
  BOTTOM w0.152: G2.J15 v3(265.69,123.27) ; U2025.A4 300.63,113.49 v3(301.02,113.89)
MDC25: length 44.8
  IN10 w0.14: v3(301.02,112.29) 302.13,113.4 302.13,115.49 300.48,117.14 299.53,117.14 298.46,118.21 288.85,118.21 288.63,118.43 288.63,119.74 288.48,119.89 287.21,119.89 285.28,121.81 276.61,121.81 276.45,121.98 272.86,121.98 272.23,122.6 267.05,122.6 v3(266.24,123.42)
  BOTTOM w0.152: v3(301.02,112.29) 300.63,111.9 U2025.A2 ; G2.H15 v3(266.24,123.42)
MDC26: length 36.2
  IN10 w0.14: v3(300.22,113.89) 299.82,114.29 299.82,115 298.58,116.24 293.71,116.24 293.01,116.94 287.28,116.94 284.08,120.14 275.67,120.14 275.18,120.64 272.27,120.64 271.1,121.81 268.96,121.81 v3(268.87,121.72)
  BOTTOM w0.152: v3(268.87,121.72) 268.79,121.81 G2.E14 ; U2025.B4 299.83,113.49 v3(300.22,113.89)
MDC27: length 40.2
  IN10 w0.14: v3(300.22,112.29) 300.22,113.12 300.62,113.52 300.62,115.32 300.14,115.8 299.67,115.8 298.7,116.77 293.82,116.77 293.23,117.35 288.01,117.35 284.66,120.7 276.22,120.7 275.82,121.1 272.37,121.1 271.35,122.12 267.94,122.12 267.68,121.86 v3(267.68,121.86)
  BOTTOM w0.152: v3(267.68,121.86) 267.68,121.86 G2.F14 ; v3(300.22,112.29) 299.83,111.9 U2025.B2
MDC28: length 36.9
  IN10 w0.14: v3(266.39,119.87) 267.22,120.7 271.58,120.7 272.12,120.15 274.64,120.15 275.21,119.58 283.62,119.58 286.68,116.52 292.72,116.52 293.61,115.63 296.9,115.63 297.43,115.1 297.43,113.49 v3(297.02,113.09)
  BOTTOM w0.152: U2025.E4 297.42,113.48 v3(297.02,113.09) ; G2.H11 v3(266.39,119.87)
MDC29: length 37
  IN10 w0.14: v3(297.02,111.49) 296.62,111.89 296.62,114.15 296.4,114.38 295.99,114.38 295.41,114.96 293.5,114.96 292.36,116.1 285.86,116.1 285.09,116.87 284.69,116.87 282.54,119.02 274.76,119.02 274.11,119.67 271.89,119.67 271.45,120.11 270.9,120.11 270.56,120.44 267.79,120.44 267.39,120.03 267.39,119.37 v3(267.44,119.32)
  BOTTOM w0.102: G2.G11 267.39,119.37 v3(267.44,119.32)
  BOTTOM w0.152: U2025.E2 297.42,111.88 v3(297.02,111.49)
MDC30: length 31.6
  IN10 w0.14: v3(296.22,113.89) 295.85,113.89 295.47,114.26 293.48,114.26 292.2,115.53 285.11,115.53 282.18,118.46 274.41,118.46 273.53,119.34 271.59,119.34 271.27,119.67 270.63,119.67 270.12,120.18 268.7,120.18 v3(268.39,119.87)
  BOTTOM w0.152: v3(296.22,113.89) 296.63,113.48 U2025.F4 ; v3(268.39,119.87) G2.F11
MDC31: length 32
  IN10 w0.14: v3(296.22,112.29) 295.82,112.69 295.82,113.28 295.46,113.64 293.24,113.64 291.95,114.94 284.92,114.94 281.95,117.9 272.02,117.9 271.29,118.63 269.59,118.63 269.34,118.89 269.34,119.47 v3(269.04,119.77)
  BOTTOM w0.152: U2025.F2 296.63,111.88 v3(296.22,112.29) ; G2.E11 269.04,119.92 v3(269.04,119.77)
MDC32: length 25.2
  IN03 w0.076: v3(265.69,132.47) 266.16,132.94 271.18,132.94
  IN03 w0.14: v3(287.43,137.51) 287.02,137.92 283.29,137.92 278.54,133.17 271.41,133.17 271.18,132.94
  BOTTOM w0.152: v3(287.43,137.51) 287.82,137.12 U2024.A4 ; G2.J29 v3(265.69,132.47)
MDC33: length 22.6
  IN03 w0.076: v3(268.39,133.77) 268.76,133.39 270.68,133.39
  IN03 w0.14: v3(287.43,139.11) 287.43,139.11 282.83,139.11 278.15,134.43 271.72,134.43 270.68,133.39
  BOTTOM w0.152: G2.F30 v3(268.39,133.77) ; v3(287.43,139.11) 287.82,138.72 U2024.A2
MDC34: length 24.7
  IN03 w0.076: 270.31,132.73 267.24,132.73 v3(266.99,132.47)
  IN03 w0.14: 270.31,132.73 270.71,132.33 275.74,132.33 276.01,132.6 278.78,132.6 283.28,137.1 287.81,137.1 v3(288.23,137.51)
  BOTTOM w0.152: G2.H29 v3(266.99,132.47) ; U2024.B4 288.62,137.12 v3(288.23,137.51)
MDC35: length 24.8
  IN03 w0.076: v3(267.09,133.77) 267.68,133.17 270.95,133.17
  IN03 w0.14: v3(288.23,139.11) 287.67,138.55 283.12,138.55 278.42,133.86 271.64,133.86 270.95,133.17
  BOTTOM w0.152: v3(288.23,139.11) 288.62,138.72 U2024.B2 ; G2.G30 v3(267.09,133.77)
MDC36: length 27.2
  IN03 w0.14: v3(276.22,134.87) 276.22,135.08 277,135.86 277.94,135.86 282.45,140.36 286.21,140.36 286.86,141.02 290.38,141.02 291.03,140.37 291.03,137.92 v3(291.43,137.51)
  BOTTOM w0.102: 275.29,133.94 275.13,133.78 271.4,133.78 271.09,133.47 G2.B30
  BOTTOM w0.152: v3(291.43,137.51) 291.03,137.12 U2024.E4 ; v3(276.22,134.87) 275.29,133.94
MDC37: length 23.4
  IN03 w0.14: v3(290.63,139.11) 290.23,139.51 290.23,140.12 289.89,140.46 287.13,140.46 286.45,139.77 282.69,139.77 278.21,135.29 277.23,135.29 v3(276.8,134.87)
  BOTTOM w0.102: G2.A30 275.4,133.47 275.53,133.59
  BOTTOM w0.152: v3(290.63,139.11) 291.02,138.72 U2024.E2 ; v3(276.8,134.87) 275.53,133.59
MDC38: length 35.7
  IN03 w0.076: 271.01,134.83 268.69,134.83 268.55,134.97 266.79,134.97 266.61,134.78 266.61,133.99 v3(266.39,133.77)
  IN03 w0.14: v3(292.23,137.51) 292.65,137.93 292.65,141.01 291.42,142.23 286.43,142.23 285.8,141.6 281.96,141.6 277.34,136.98 276.53,136.98 275.8,136.24 273.37,136.24 273.02,135.89 273.02,135.53 272.8,135.31 271.49,135.31 271.01,134.83
  BOTTOM w0.152: G2.H30 v3(266.39,133.77) ; U2024.F4 291.83,137.12 v3(292.23,137.51)
MDC39: length 27.7
  IN03 w0.14: v3(291.43,139.11) 291.83,139.51 291.83,140.65 290.86,141.61 286.65,141.61 286.04,141 282.18,141 277.6,136.42 276.76,136.42 275.65,135.3 275.48,135.3 v3(275.05,134.87)
  BOTTOM w0.102: G2.C30 270.41,133.47 270.74,133.79 271,133.79 271.22,134 274.19,134 274.4,134.21
  BOTTOM w0.152: U2024.F2 291.82,138.72 v3(291.43,139.11) ; v3(275.05,134.87) 274.4,134.21
MDC40: length 21.4
  IN10 w0.14: v3(287.43,131.12) 287.43,131.41 286.72,132.11 282.83,132.11 280.44,129.71 276.14,129.71 275.59,130.26 271.91,130.26 271.57,130.59 271.57,131.24 271.23,131.58 269.87,131.58 v3(269.79,131.67)
  BOTTOM w0.152: G2.D27 v3(269.79,131.67) ; U2024.A11 v3(287.43,131.12)
MDC41: length 25.4
  IN10 w0.14: v3(287.43,129.52) 286.75,129.52 285.84,130.43 283.54,130.43 281.14,128.03 275.12,128.03 274.15,129.01 271.74,129.01 271.39,129.37 270.85,129.9 269.99,130.77 266.14,130.77 v3(265.7,130.33)
  BOTTOM w0.152: v3(287.43,129.52) U2024.A13 ; G2.J26 265.7,130.38 v3(265.7,130.33)
MDC42: length 24.1
  IN10 w0.14: v3(288.23,131.12) 287.83,130.72 287.13,130.72 286.3,131.55 283.07,131.55 280.67,129.15 275.83,129.15 275.07,129.9 271.81,129.9 271.29,130.42 271.29,130.69 270.72,131.27 268.19,131.27 v3(267.79,131.67)
  BOTTOM w0.152: G2.F27 v3(267.79,131.67) ; v3(288.23,131.12) U2024.B11
MDC43: length 25
  IN10 w0.14: v3(267.09,131.67) 267.73,131.02 270.23,131.02 271.79,129.46 274.58,129.46 275.45,128.59 280.91,128.59 283.3,130.99 286.07,130.99 287.14,129.92 287.83,129.92 v3(288.23,129.52)
  BOTTOM w0.152: v3(288.23,129.52) U2024.B13 ; G2.G27 v3(267.09,131.67)
MDC44: length 26.7
  IN10 w0.14: v3(273.8,132.77) 274.64,131.93 276.78,131.93 277.09,131.63 279.43,131.63 282.85,135.05 289.48,135.05 290.23,134.3 290.23,131.52 v3(290.63,131.12)
  BOTTOM w0.102: 273.17,132.13 273.1,132.06 271.43,132.06 271.09,131.72 270.74,131.72 270.39,131.37 G2.C27
  BOTTOM w0.152: v3(290.63,131.12) U2024.E11 ; v3(273.8,132.77) 273.17,132.13
MDC45: length 28.6
  IN10 w0.14: v3(274.39,132.77) 274.39,132.76 274.8,132.35 277.34,132.35 277.5,132.19 279.19,132.19 282.62,135.61 290,135.61 291.03,134.58 U2024.E13 v3(291.43,129.52)
  BOTTOM w0.102: 273.53,131.91 273.36,131.74 271.46,131.74 271.09,131.37 G2.B27
  BOTTOM w0.152: v3(274.39,132.77) 273.53,131.91 ; U2024.E13 v3(291.43,129.52)
MDC46: length 27.5
  IN10 w0.14: v3(291.43,131.12) 291.83,131.52 291.83,135.17 290.8,136.2 282.41,136.2 278.96,132.74 275.58,132.74 v3(275.56,132.77)
  BOTTOM w0.102: 273.53,131.37 G2.A27
  BOTTOM w0.152: v3(275.56,132.77) 274.16,131.37 273.53,131.37 ; v3(291.43,131.12) U2024.F11
MDC47: length 32.9
  IN10 w0.14: v3(268.52,132.32) 269.11,132.91 271.2,132.91 271.95,132.16 273.44,132.16 274.07,131.53 276.39,131.53 276.86,131.07 279.66,131.07 283.08,134.49 288.83,134.49 289.43,133.88 289.43,130.93 289.64,130.72 290.07,130.72 290.23,130.56 290.23,129.31 290.42,129.12 291.83,129.12 v3(292.23,129.52)
  BOTTOM w0.102: G2.G29 267.63,132.77 268,132.39 268.45,132.39 v3(268.52,132.32)
  BOTTOM w0.152: U2024.F13 291.83,129.92 v3(292.23,129.52)
MDC48: length 44.9
  IN10 w0.14: v3(301.03,131.12) 301.19,131.28 301.61,131.28 302.18,130.71 302.18,127.17 299.44,124.43 290.5,124.43 290.31,124.23 284.16,124.23 283.45,123.53 272.67,123.53 271.68,124.52 267.13,124.52 266.66,124.99 266.66,125.73 266.39,126.01 v3(266.39,126.17)
  BOTTOM w0.152: v3(301.03,131.12) U2024.U11 ; G2.H20 v3(266.39,126.17)
MDC49: length 36
  IN10 w0.14: v3(269.79,125.37) 269.95,125.2 272.28,125.2 272.83,124.64 282.98,124.64 284.17,125.83 285.33,125.83 285.81,125.35 289.83,125.35 290.03,125.55 298.82,125.55 300.63,127.36 300.63,129.12 v3(301.03,129.52)
  BOTTOM w0.152: G2.D18 v3(269.79,125.37) ; v3(301.03,129.52) U2024.U13
MDC50: length 42.1
  IN10 w0.14: v3(267.61,126.05) 267.71,126.05 268.09,125.67 268.09,125.26 268.42,124.93 271.68,124.93 272.52,124.09 283.22,124.09 283.92,124.79 290.07,124.79 290.27,124.99 299.06,124.99 301.59,127.52 301.59,130.4 301.27,130.72 300.63,130.72 v3(300.23,131.12)
  BOTTOM w0.152: v3(300.23,131.12) 299.83,131.52 U2024.T11 ; G2.G20 267.61,126.25 v3(267.61,126.05)
MDC51: length 36.8
  IN10 w0.14: v3(268.92,125.92) 269.19,126.19 272.17,126.19 273.16,125.2 282.75,125.2 283.94,126.39 285.56,126.39 286.04,125.91 289.6,125.91 289.8,126.11 298.03,126.11 299.83,127.91 299.83,129.92 v3(300.23,130.32)
  BOTTOM w0.152: G2.E20 268.99,126.27 268.99,125.99 v3(268.92,125.92) ; v3(300.23,130.32) 299.83,129.92 U2024.T13
MDC52: length 37.9
  IN10 w0.14: v3(297.83,131.12) 298.23,130.72 298.23,127.54 297.28,126.59 289.48,126.59 289.36,126.47 286.28,126.47 285.74,127 283.76,127 282.52,125.76 273.53,125.76 272.68,126.61 268.7,126.61 268.12,127.19 268.12,127.81 v3(268.49,128.17)
  BOTTOM w0.152: v3(297.83,131.12) 297.43,131.52 U2024.N11 ; v3(268.49,128.17) G2.F23
MDC53: length 32.9
  IN10 w0.14: v3(269.09,127.47) 269.52,127.03 273.12,127.03 273.83,126.32 282.29,126.32 283.91,127.94 285.72,127.94 286.63,127.03 292.91,127.03 293.11,127.23 296.6,127.23 297.43,128.06 297.43,129.12 v3(297.03,129.52)
  BOTTOM w0.152: v3(269.09,127.47) G2.E21 ; v3(297.03,129.52) U2024.N13
MDC54: length 33.8
  IN10 w0.14: v3(297.03,131.12) 296.63,130.72 296.63,128.2 296.34,127.92 290.84,127.92 290.56,127.65 286.81,127.65 285.27,129.18 284.36,129.18 282.06,126.88 274.22,126.88 272.92,128.18 270.14,128.18 269.79,127.82 v3(269.79,127.47)
  BOTTOM w0.152: G2.D21 v3(269.79,127.47) ; v3(297.03,131.12) U2024.M11
MDC55: length 31
  IN10 w0.14: v3(296.23,129.52) 296.23,129.52 295.76,129.05 294.03,129.05 293.3,128.32 286.93,128.32 285.5,129.74 284.13,129.74 281.83,127.44 274.7,127.44 273.54,128.6 269.46,128.6 v3(269.04,128.17)
  BOTTOM w0.152: U2024.M13 296.63,129.92 v3(296.23,129.52) ; G2.E23 269.04,128.32 v3(269.04,128.17)
MDC56: length 40.5
  IN03 w0.14: v3(300.23,137.51) 300.71,137.04 300.71,135.65 298.54,133.48 296.37,133.48 295.35,132.46 288.02,132.46 285.85,130.3 283.46,130.3 281.15,127.99 271.04,127.99 270.34,128.7 267.96,128.7 v3(267.09,129.57)
  BOTTOM w0.152: v3(300.23,137.51) 300.63,137.12 U2024.U4 ; v3(267.09,129.57) 267.39,129.27 G2.G24
MDC57: length 41.8
  IN03 w0.14: v3(266.39,130.37) 267.28,131.26 270.28,131.26 270.75,131.73 276.07,131.73 276.3,131.96 279.31,131.96 283.73,136.37 287.33,136.37 287.42,136.29 292.44,136.29 293.43,137.27 293.43,139.47 293.73,139.77 293.73,140.36 294,140.63 299.36,140.63 299.83,140.16 299.83,139.52 v3(300.23,139.11)
  BOTTOM w0.152: G2.H26 v3(266.39,130.37) ; v3(300.23,139.11) 300.62,138.72 U2024.U2
MDC58: length 37.6
  IN03 w0.14: v3(300.23,136.72) 299.83,136.31 299.83,135.64 298.42,134.24 296.36,134.24 295.41,133.28 293.77,133.28 293.51,133.02 287.79,133.02 285.62,130.85 283.23,130.85 280.94,128.57 271.39,128.57 270.8,129.15 268.2,129.15 v3(267.79,129.57)
  BOTTOM w0.152: v3(267.79,129.57) 268.09,129.27 G2.F24 ; v3(300.23,136.72) 299.83,137.12 U2024.T4
MDC59: length 37.5
  IN03 w0.14: v3(299.43,139.11) 299.03,139.52 295.08,139.52 294.23,138.66 294.23,137.25 292.8,135.81 284,135.81 279.58,131.4 271.13,131.4 270.7,130.96 268.28,130.96 v3(267.69,130.37)
  BOTTOM w0.152: U2024.T2 299.82,138.72 v3(299.43,139.11) ; v3(267.69,130.37) G2.G26
MDC60: length 35.6
  IN03 w0.14: v3(297.03,137.51) 297.52,137.03 297.52,135.7 297.12,135.29 296.03,135.29 294.32,133.58 287.52,133.58 285.48,131.54 283.06,131.54 280.66,129.14 271.96,129.14 270.47,130.64 270.22,130.64 268.66,130.64 v3(268.39,130.37)
  BOTTOM w0.152: U2024.N4 297.43,137.12 v3(297.03,137.51) ; G2.F26 v3(268.39,130.37)
MDC61: length 33
  IN03 w0.14: v3(272.67,130.72) 273.68,129.71 280.39,129.71 282.84,132.16 285.2,132.16 287.17,134.14 293.77,134.14 296.63,136.99 296.63,137.91 v3(297.03,138.31)
  BOTTOM w0.102: G2.D26 269.84,131.02 271.79,131.02 271.89,131.12 272.27,131.12 v3(272.67,130.72)
  BOTTOM w0.152: v3(297.03,138.31) 297.43,138.71 U2024.N2
MDC62: length 29.4
  IN03 w0.14: v3(296.23,137.51) 293.41,134.7 284.52,134.7 280.09,130.26 273.71,130.26 v3(273.25,130.72)
  BOTTOM w0.102: 272.92,130.38 272.86,130.32 271.45,130.32 271.11,130.67 G2.B26
  BOTTOM w0.152: U2024.M4 296.63,137.12 v3(296.23,137.51) ; v3(273.25,130.72) 272.92,130.38
MDC63: length 32.1
  IN03 w0.14: v3(297.03,139.11) 296.63,138.71 295.88,138.71 295.03,137.86 295.03,137.17 293.12,135.26 284.24,135.26 279.82,130.83 275.6,130.83 275.31,131.12 274.83,131.12 v3(274.42,130.72)
  BOTTOM w0.102: 273.27,130.15 273.19,130.07 271.32,130.07 271.07,130.32 270.54,130.32 G2.C26
  BOTTOM w0.152: v3(274.42,130.72) 273.86,130.15 273.27,130.15 ; U2024.M2 296.63,138.72 v3(297.03,139.11)
MDD0: length 23.7
  IN03 w0.14: v3(250.99,117.77) 251.83,116.92 251.83,113.07 252.49,112.41 252.49,106.89 249.09,103.49 249.09,102.45 246.23,99.59 246.23,98.48 v2(246.07,98.32)
  BOTTOM w0.152: U2026.U4 v2(246.07,98.32) ; G2.AK8 v3(250.99,117.77)
MDD1: length 20.7
  IN03 w0.14: v3(244.47,98.32) 244.31,98.48 244.31,101.08 250.06,106.83 250.06,112.24 251.14,113.32 251.14,114.61 v3(250.88,114.87)
  BOTTOM w0.152: v3(244.47,98.32) U2026.U2 ; v3(250.88,114.87) G2.AK4
MDD2: length 20.4
  IN03 w0.14: v3(251.3,112.03) 251.93,111.41 251.93,107.12 248.53,103.72 248.53,102.68 245.67,99.82 245.67,97.92 v3(246.07,97.52)
  BOTTOM w0.102: 250.77,113 250.77,113.14 251.29,113.65 G2.AK2
  BOTTOM w0.152: v3(251.3,112.03) 251.23,112.03 250.77,112.49 250.77,113 ; U2026.T4 v3(246.07,97.52)
MDD3: length 21.8
  IN03 w0.14: v3(244.47,97.52) 244.87,97.92 244.87,99.81 247.97,102.91 247.97,103.95 251.34,107.32 251.34,108.41 250.86,108.89 250.86,111.19 251.13,111.46 v3(251.3,111.46)
  BOTTOM w0.102: 250.42,113.27 250.92,113.77 250.92,114.01 251.29,114.37 G2.AK3
  BOTTOM w0.152: v3(244.47,97.52) U2026.T2 ; 250.42,113.27 250.42,112.17 251.13,111.46 v3(251.3,111.46)
MDD4: length 27.4
  IN03 w0.14: v3(246.07,94.32) 245.67,94.72 244.1,94.72 243.91,94.92 243.91,98.27 243.59,98.58 243.59,101.18 249.47,107.06 249.47,112.35 249.74,112.61 249.74,114.6 250.81,115.67 v3(250.99,115.67)
  BOTTOM w0.152: U2026.N4 v3(246.07,94.32) ; G2.AK5 v3(250.99,115.67)
MDD5: length 25.9
  IN05 w0.14: v3(250.81,116.23) 250.23,116.23 249.91,115.9 249.91,115.27 250.04,115.13 250.04,111 248.98,109.94 248.98,103.88 243.93,98.83 243.93,95.66 v3(244.47,95.12)
  BOTTOM w0.152: G2.AK6 251.24,116.67 v3(250.81,116.23) ; U2026.N2 v3(244.47,95.12)
MDD6: length 33.7
  IN03 w0.14: v3(246.07,93.52) 245.44,92.89 243.4,92.89 242.81,93.48 242.81,101.2 248.91,107.31 248.91,112.47 249.18,112.74 249.18,115.18 249.75,115.75 249.75,117.83 v3(250.99,119.07)
  BOTTOM w0.152: G2.AK9 v3(250.99,119.07) ; U2026.M4 v3(246.07,93.52)
MDD7: length 28.3
  IN05 w0.076: 243.23,95.12 243.67,95.12 v3(244.47,94.32)
  IN05 w0.14: 243.23,95.12 243,95.35 243,98.86 246.49,102.35 246.49,103.01 247.58,104.09 247.58,109.86 249.06,111.34 249.06,115.82 249.89,116.65 250.57,116.65 v3(250.99,117.07)
  BOTTOM w0.152: v3(244.47,94.32) U2026.M2 ; G2.AK7 v3(250.99,117.07)
MDD8: length 19.8
  IN10 w0.14: v3(252.47,98.32) 252,98.32 251.43,98.89 251.43,103.58 251.91,104.07 251.91,106.58 253.05,107.72 253.05,111.3 253.88,112.13 v3(254.09,112.13)
  BOTTOM w0.102: G2.AG4 253.7,114.95 253.7,112.44 254.02,112.13 v3(254.09,112.13)
  BOTTOM w0.152: U2026.U11 v3(252.47,98.32)
MDD9: length 23.8
  IN10 w0.076: v3(254.39,119.07) 254.82,118.63 254.82,118.05 254.9,117.96
  IN10 w0.14: 254.9,117.96 255.05,117.96 255.66,117.36 255.66,115.66 255.52,115.52 255.52,114.63 255.06,114.18 255.06,107.42 253.21,105.57 253.21,100.03 254.15,99.09 254.15,98.4 v3(254.07,98.32)
  BOTTOM w0.152: G2.AF9 v3(254.39,119.07) ; U2026.U13 v3(254.07,98.32)
MDD10: length 22.9
  IN10 w0.14: v3(252.47,97.52) 251.99,98 251.43,98 250.81,98.62 250.81,104.11 251.35,104.65 251.35,106.89 252.48,108.02 252.48,111.94 253.69,113.15 253.69,116.36 v3(253.09,116.97)
  BOTTOM w0.152: U2026.T11 v3(252.47,97.52) ; G2.AG6 v3(253.09,116.97)
MDD11: length 25.6
  IN10 w0.14: v3(254.07,97.52) 253.67,97.92 253.67,98.77 252.57,99.87 252.57,105.72 254.65,107.81 254.65,113.64 253.98,114.31 253.98,117.47 v3(252.97,118.48)
  BOTTOM w0.152: v3(252.97,118.48) 253.04,118.41 253.52,118.41 253.75,118.17 253.75,117.73 G2.AG7 ; U2026.T13 v3(254.07,97.52)
MDD12: length 23.7
  IN10 w0.14: v3(252.47,95.12) 252.07,95.52 251.16,95.52 249.61,97.06 249.61,105.07 250.11,105.56 250.11,112.07 252.29,114.25 v3(252.29,114.97)
  BOTTOM w0.152: v3(252.47,95.12) U2026.N11 ; G2.AJ4 v3(252.29,114.97)
MDD13: length 27.5
  IN10 w0.14: v3(254.07,95.12) 253.67,94.72 250.86,94.72 248.93,96.64 248.93,105.53 249.55,106.15 249.55,112.06 251.79,114.29 251.79,115.17 v3(252.29,115.67)
  BOTTOM w0.152: v3(254.07,95.12) U2026.N13 ; G2.AJ5 v3(252.29,115.67)
MDD14: length 28.7
  IN10 w0.14: v3(252.29,116.97) 251.41,116.09 251.41,114.58 248.93,112.1 248.93,107.16 248.27,106.49 248.27,96.26 250.61,93.92 252.07,93.92 v3(252.47,94.32)
  BOTTOM w0.152: G2.AJ6 v3(252.29,116.97) ; v3(252.47,94.32) U2026.M11
MDD15: length 27.4
  IN10 w0.14: v3(254.07,94.32) 254.47,94.72 254.47,96.11 254.26,96.32 251.42,96.32 250.24,97.5 250.24,104.56 250.79,105.11 250.79,107.17 251.9,108.28 251.9,112.19 253.42,113.71 253.42,115.33 v3(253.09,115.67)
  BOTTOM w0.152: U2026.M13 v3(254.07,94.32) ; G2.AG5 v3(253.09,115.67)
MDD16: length 42.3
  IN10 w0.14: v3(251.67,84.72) 252.65,83.74 256.63,83.74 259.38,86.5 259.38,104.73 260.33,105.68 260.33,115.78 259.46,116.66 259.18,116.66 v3(258.73,117.11)
  BOTTOM w0.152: U2026.A11 v3(251.67,84.72) ; G2.Y6 v3(258.73,117.11)
MDD17: length 34.2
  IN10 w0.14: v3(253.27,85.52) 253.67,85.92 255.19,85.92 257.7,88.43 257.7,113.31 258.16,113.77 258.16,115.24 v3(258.59,115.67)
  BOTTOM w0.152: U2026.A13 v3(253.27,85.52) ; v3(258.59,115.67) G2.Y5
MDD18: length 39
  IN10 w0.14: v3(259.36,115.66) 259.73,115.28 259.73,107.29 258.82,106.38 258.82,86.89 256.24,84.31 252.88,84.31 v3(251.67,85.52)
  BOTTOM w0.152: G2.V5 259.38,115.66 v3(259.36,115.66) ; U2026.B11 v3(251.67,85.52)
MDD19: length 34.2
  IN10 w0.14: v3(254.07,85.52) 254.47,85.12 255.8,85.12 258.26,87.58 258.26,106.75 258.97,107.46 258.97,113.77 258.59,114.16 v3(258.59,114.97)
  BOTTOM w0.152: U2026.B13 v3(254.07,85.52) ; G2.Y4 v3(258.59,114.97)
MDD20: length 33.7
  IN10 w0.14: v3(257.18,116.26) 257.91,115.54 257.91,114.06 257.14,113.29 257.14,89.79 255.67,88.32 255.04,88.32 255.04,88.32 254.7,88.32 254.24,88.32 254.24,88.32 253.9,88.32 253.9,88.32 252.87,88.32 v3(252.47,88.72)
  BOTTOM w0.152: G2.AA6 v3(257.18,116.26) ; U2026.E11 v3(252.47,88.72)
MDD21: length 30
  IN10 w0.14: v3(257.21,115.66) 257.62,115.24 257.62,114.49 256.59,113.46 256.59,90.6 255.11,89.12 254.47,89.12 v3(254.07,88.72)
  BOTTOM w0.152: G2.AA5 257.29,115.67 257.22,115.67 v3(257.21,115.66) ; v3(254.07,88.72) U2026.E13
MDD22: length 29
  IN10 w0.14: v3(256.6,115.7) 255.98,115.08 255.98,114.38 255.47,113.87 255.47,106.92 255.28,106.73 255.28,93.32 254.68,92.73 254.68,91.73 v3(252.47,89.52)
  BOTTOM w0.152: U2026.F11 v3(252.47,89.52) ; G2.AC5 256.46,115.7 v3(256.6,115.7)
MDD23: length 27.5
  IN10 w0.14: v3(256.62,114.83) 256.33,114.54 256.33,114.07 255.98,113.72 255.98,95.1 255.75,94.87 255.75,92.05 254.07,90.37 v3(254.07,89.52)
  BOTTOM w0.152: G2.AC4 v3(256.62,114.83) ; U2026.F13 v3(254.07,89.52)
MDD24: length 40.6
  IN03 w0.14: v3(254.89,117.52) 255.24,117.52 255.84,116.93 255.84,113.98 257.29,112.53 257.29,104.5 250.68,97.89 250.68,92.24 250.27,91.84 250.27,87.67 249.3,86.7 249.3,85.73 248.08,84.51 247.08,84.51 246.87,84.72 v3(246.87,84.72)
  BOTTOM w0.152: v3(254.89,117.52) 255.33,117.52 G2.AD7 ; U2026.A4 v3(246.87,84.72)
MDD25: length 42.3
  IN03 w0.14: v3(245.27,84.72) 246.13,83.86 248.33,83.86 248.99,84.52 250.11,85.64 250.11,86.3 251.24,87.43 251.24,97.65 257.85,104.27 257.85,112.61 256.17,114.29 256.17,116.65 v3(256.49,116.97)
  BOTTOM w0.152: v3(256.49,116.97) G2.AC6 ; U2026.A2 v3(245.27,84.72)
MDD26: length 36.8
  IN03 w0.14: v3(246.87,85.52) 247.27,85.92 247.27,86.54 249.26,88.53 249.26,92.7 249.56,93 249.56,98.36 256.17,104.97 256.17,112.27 253.98,114.46 253.98,115.97 v3(254.39,116.37)
  BOTTOM w0.152: U2026.B4 v3(246.87,85.52) ; G2.AF6 v3(254.39,116.37)
MDD27: length 39.6
  IN03 w0.14: v3(245.27,85.52) 245.67,85.12 247.94,85.12 248.45,85.63 248.45,86.8 249.74,88.09 249.74,92.2 250.12,92.58 250.12,98.12 256.73,104.74 256.73,112.46 255.51,113.68 255.51,115.95 255.24,116.22 v3(255.04,116.22)
  BOTTOM w0.152: v3(255.04,116.22) G2.AD6 ; U2026.B2 v3(245.27,85.52)
MDD28: length 36
  IN03 w0.14: v3(246.07,88.72) U2026.E4 247.97,88.32 248.78,89.13 248.78,93.11 249,93.33 249,98.59 255.61,105.21 255.61,112.33 253.74,114.2 253.74,116.42 v3(254.39,117.07)
  BOTTOM w0.152: U2026.E4 v3(246.07,88.72) ; G2.AF7 v3(254.39,117.07)
MDD29: length 37.2
  IN03 w0.14: v3(244.47,88.72) 244.47,88.72 244.87,89.12 247.87,89.12 248.27,89.52 248.27,93.66 248.44,93.84 248.44,98.82 255.06,105.44 255.06,112.34 253.5,113.89 253.5,116.88 v3(254.39,117.77)
  BOTTOM w0.152: v3(244.47,88.72) U2026.E2 ; G2.AF8 v3(254.39,117.77)
MDD30: length 28.6
  IN03 w0.14: v3(246.87,89.52) 246.87,89.52 247.88,90.53 247.88,99.06 251.44,102.62 251.44,103.22 254.5,106.28 254.5,108.77 v3(254.07,109.19)
  BOTTOM w0.102: v3(254.07,109.19) 254.47,109.59 254.47,113.28 254.09,113.66 G2.AF2
  BOTTOM w0.152: v3(246.87,89.52) U2026.F4
MDD31: length 31.2
  IN03 w0.14: v3(254.07,108.62) 253.84,108.86 253.3,108.86 253.06,108.62 253.06,108.03 253.42,107.66 253.42,105.99 250.89,103.46 250.89,102.85 247.32,99.29 247.32,90.95 246.29,89.92 245.67,89.92 245.27,89.52 v3(245.27,89.52)
  BOTTOM w0.102: v3(254.07,108.62) 254.73,109.28 254.73,113.42 254.44,113.72 254.44,114 254.09,114.35 G2.AF3
  BOTTOM w0.152: v3(245.27,89.52) U2026.F2
MDD32: length 20.6
  IN10 w0.14: v3(267.54,115.78) 267.54,115.5 268.14,114.9 268.14,112.14 267.93,111.93 267.93,109.59 271.11,106.4 271.11,98.8 v3(270.63,98.32)
  BOTTOM w0.152: U60.A4 v3(270.63,98.32) ; v3(267.54,115.78) 268.05,115.27 G2.F4
MDD33: length 17
  IN10 w0.14: v3(269.1,112.42) 269.3,112.42 269.54,112.18 269.54,110.52 272.23,107.83 v3(272.23,98.32)
  BOTTOM w0.152: v3(269.1,112.42) 269.1,112.86 G2.E1 ; U60.A2 v3(272.23,98.32)
MDD34: length 19.6
  IN10 w0.14: v3(270.63,97.52) 270.23,97.92 270.23,106.47 267,109.71 267,113.58 267.69,114.27 v3(267.71,114.27)
  BOTTOM w0.152: G2.F3 268.01,114.57 v3(267.71,114.27) ; U60.B4 v3(270.63,97.52)
MDD35: length 21.6
  IN10 w0.14: v3(267.79,116.27) 267.79,116.27 267.96,116.1 267.96,115.47 268.6,114.83 268.6,109.79 271.67,106.71 271.67,98.78 271.83,98.63 271.83,97.92 v3(272.23,97.52)
  BOTTOM w0.152: v3(267.79,116.27) G2.F5 ; v3(272.23,97.52) U60.B2
MDD36: length 25.5
  IN10 w0.14: v3(270.49,112.21) 270.7,112.21 271.36,111.54 272.23,111.54 272.71,111.07 272.71,109.2 274.21,107.7 274.21,95.6 273.33,94.72 271.03,94.72 v3(270.63,94.32)
  BOTTOM w0.152: G2.D2 269.84,113.52 269.84,112.86 v3(270.49,112.21) ; U60.E4 v3(270.63,94.32)
MDD37: length 21.2
  IN10 w0.14: v3(270.49,111.62) 270.76,111.62 271.62,110.76 271.62,109.28 273.45,107.44 273.45,96.5 273.27,96.32 272.84,96.32 272.63,96.11 272.63,95.52 v3(272.23,95.12)
  BOTTOM w0.152: G2.D1 269.49,112.62 v3(270.49,111.62) ; v3(272.23,95.12) U60.E2
MDD38: length 29.5
  IN10 w0.14: v3(270.49,114.27) 270.71,114.04 271.28,114.04 271.68,113.65 271.68,113.13 272.03,112.78 272.88,112.78 273.98,111.68 273.98,109.52 276.04,107.46 276.04,95.67 273.32,92.95 271.2,92.95 v3(270.63,93.52)
  BOTTOM w0.152: v3(270.49,114.27) G2.C3 ; U60.F4 v3(270.63,93.52)
MDD39: length 25.1
  IN10 w0.14: v3(272.23,94.32) 272.23,94.32 272.63,93.92 273.38,93.92 274.95,95.49 274.95,107.76 273.37,109.34 273.37,111.28 272.64,112.01 271.5,112.01 270.91,112.6 270.91,112.6 270.9,112.61 270.9,113.15 v3(270.49,113.57)
  BOTTOM w0.152: v3(270.49,113.57) G2.C2 ; U60.F2 v3(272.23,94.32)
MDD40: length 23.7
  IN03 w0.14: v3(264.23,98.32) 266.67,98.32 268.06,99.71 268.06,113.17 267.71,113.52 266.48,113.52 266.09,113.92 266.09,115.87 v3(265.69,116.27)
  BOTTOM w0.152: v3(265.69,116.27) 265.99,115.97 G2.J5 ; U60.A11 v3(264.23,98.32)
MDD41: length 20.2
  IN03 w0.14: v3(262.63,98.32) 262.86,98.32 266.94,102.4 266.94,109.46 266.42,109.98 266.42,110.99 v3(265.99,111.43)
  BOTTOM w0.102: v3(265.99,111.43) 266.4,111.85 266.4,112.9 266.34,112.97 266.34,114.92 G2.J4
  BOTTOM w0.152: U60.A13 v3(262.63,98.32)
MDD42: length 28.4
  IN03 w0.14: v3(264.23,97.52) 263.83,97.12 263.23,97.12 263.03,97.32 263.03,97.72 262.83,97.92 262.33,97.92 262.19,98.06 262.19,98.45 266.38,102.64 266.38,108.71 265.58,109.51 265.58,113.17 264.36,114.39 264.36,118.53 264.75,118.92 v3(264.99,118.92)
  BOTTOM w0.152: G2.L8 264.53,118.12 264.53,118.57 264.87,118.92 v3(264.99,118.92) ; U60.B11 v3(264.23,97.52)
MDD43: length 19.7
  IN03 w0.14: v3(263.43,97.52) 263.83,97.92 263.83,98.49 267.5,102.16 267.5,110.74 266.22,112.02 v3(265.99,112.02)
  BOTTOM w0.102: G2.J2 265.99,113.65 265.6,113.27 265.6,112.4 v3(265.99,112.02)
  BOTTOM w0.152: U60.B13 v3(263.43,97.52)
MDD44: length 21.8
  IN03 w0.14: v3(264.23,95.12) 264.63,95.52 265.46,95.52 267.12,97.18 267.12,97.97 268.62,99.47 268.62,110.37 268.91,110.66 v3(269.1,110.66)
  BOTTOM w0.152: G2.F1 268.09,112.75 268.28,112.55 268.28,111.24 268.86,110.66 v3(269.1,110.66) ; v3(264.23,95.12) U60.E11
MDD45: length 25.1
  IN03 w0.14: v3(269.1,111.25) 269.5,110.85 269.5,99.56 267.72,97.78 267.72,96.76 265.67,94.72 U60.E13 v3(262.63,94.32)
  BOTTOM w0.152: v3(269.1,111.25) 268.63,111.71 268.63,112.83 268.45,113 268.45,113.5 G2.F2 ; v3(262.63,94.32) U60.E13
MDD46: length 27.8
  IN03 w0.14: v3(264.23,94.32) U60.F11 265.9,93.92 268.53,96.55 268.53,97.79 270.05,99.32 270.05,110.28 269.79,110.55 269.79,112.52 269.44,112.86 268.76,112.86 267.76,113.86 267.13,113.86 266.76,114.23 266.76,114.74 v3(266.99,114.97)
  BOTTOM w0.152: G2.H4 v3(266.99,114.97) ; v3(264.23,94.32) U60.F11
MDD47: length 31.4
  IN03 w0.14: v3(262.63,93.52) 263.03,93.12 266.19,93.12 269.39,96.32 269.39,97.86 270.61,99.09 270.61,110.32 270.09,110.85 270.09,112.81 269.74,113.15 268.87,113.15 268.31,113.71 268.31,114.88 267.91,115.27 267.38,115.27 v3(266.99,115.67)
  BOTTOM w0.152: v3(262.63,93.52) U60.F13 ; v3(266.99,115.67) G2.H5
MDD48: length 43.7
  IN03 w0.14: v3(259.3,117.13) 259.3,116.98 259,116.68 258.47,116.68 258.16,116.37 258.16,114.69 259.48,113.37 259.48,111.74 260.75,110.47 260.75,103.83 257.28,100.36 257.28,96.15 257.81,95.61 257.81,86.95 261.11,83.66 264.17,83.66 264.41,83.89 264.41,84.55 264.23,84.72 v3(264.23,84.72)
  BOTTOM w0.152: v3(264.23,84.72) U60.U11 ; G2.V7 259.54,117.37 v3(259.3,117.13)
MDD49: length 39.3
  IN03 w0.14: v3(262.63,84.72) 262.23,85.12 261.4,85.12 258.93,87.59 258.93,96.08 258.39,96.61 258.39,99.89 261.87,103.37 261.87,110.94 260.04,112.77 260.04,116.49 259.82,116.71 259.82,117.94 v3(259.39,118.37)
  BOTTOM w0.152: G2.V8 v3(259.39,118.37) ; U60.U13 v3(262.63,84.72)
MDD50: length 40.7
  IN03 w0.14: v3(259.28,116.26) 259.45,116.26 259.79,115.91 259.79,112.22 261.31,110.7 261.31,103.6 257.83,100.13 257.83,96.38 258.37,95.84 258.37,87.27 261.37,84.27 263.63,84.27 263.83,84.47 263.83,85.12 v3(264.23,85.52)
  BOTTOM w0.152: U60.T11 v3(264.23,85.52) ; G2.V6 v3(259.28,116.26)
MDD51: length 39.1
  IN03 w0.14: v3(262.63,85.52) 262.23,85.92 261.6,85.92 259.49,88.03 259.49,96.31 258.95,96.85 258.95,99.66 262.43,103.13 262.43,111.19 260.29,113.33 260.29,116.81 260.16,116.94 260.16,118.29 v3(259.39,119.07)
  BOTTOM w0.152: G2.V9 v3(259.39,119.07) ; v3(262.63,85.52) U60.T13
MDD52: length 35.1
  IN03 w0.14: v3(260.79,114.87) 260.53,114.61 260.53,113.9 262.99,111.45 262.99,102.9 259.51,99.42 259.51,97.09 260.05,96.55 260.05,88.36 260.88,87.52 263.83,87.52 v3(264.23,87.92)
  BOTTOM w0.152: U60.N11 v3(264.23,87.92) ; v3(260.79,114.87) G2.U4
MDD53: length 33
  IN03 w0.14: v3(261.33,115.69) 261.57,115.44 261.57,113.65 263.54,111.68 263.54,102.67 260.07,99.19 260.07,97.32 260.97,96.42 260.97,92.35 260.62,92 260.62,89.24 261.54,88.32 262.23,88.32 v3(262.63,88.72)
  BOTTOM w0.152: G2.R5 261.5,115.69 v3(261.33,115.69) ; U60.N13 v3(262.63,88.72)
MDD54: length 34.8
  IN03 w0.14: v3(264.23,88.72) 263.83,89.12 261.6,89.12 261.23,89.49 261.23,96.95 260.63,97.55 260.63,98.96 264.8,103.13 264.8,107.03 264.27,107.56 264.27,111.76 262.11,113.92 262.11,115.74 261.62,116.23 v3(261.34,116.23)
  BOTTOM w0.152: v3(261.34,116.23) 261.77,116.67 G2.R6 ; U60.M11 v3(264.23,88.72)
MDD55: length 34.8
  IN03 w0.14: v3(260.69,118.37) 260.96,118.09 261.72,118.09 262.41,117.4 262.41,114.43 264.85,111.99 264.85,108.04 265.36,107.53 265.36,102.89 261.19,98.72 261.19,97.79 261.46,97.52 261.9,97.52 262.09,97.33 262.09,90.8 262.63,90.26 v3(262.63,89.52)
  BOTTOM w0.152: U60.M13 v3(262.63,89.52) ; G2.U8 v3(260.69,118.37)
MDD56: length 40.9
  IN10 w0.076: v3(262.89,117.07) 262.89,116.94 263.23,116.59 263.88,116.59 263.99,116.48
  IN10 w0.14: v3(270.63,85.52) 271.03,85.92 271.27,85.92 272.44,85.92 272.63,86.11 272.63,86.95 272.63,87.38 272.49,87.52 270.2,87.52 269.88,87.83 268.72,87.83 267.63,88.93 267.63,90.25 267.25,90.63 267.25,98.58 264.68,101.16 264.68,107.4 263.88,108.2 263.88,115.98 263.99,116.09 263.99,116.48
  BOTTOM w0.152: U60.U4 v3(270.63,85.52) ; v3(262.89,117.07) G2.P6
MDD57: length 43.8
  IN10 w0.14: v3(261.49,119.07) 262.38,118.18 262.38,115.27 262.1,114.99 262.1,101.25 265.63,97.72 265.63,93.48 265.33,93.18 265.33,90.6 266.37,89.55 266.37,86.43 268.49,84.31 271.8,84.31 272.23,84.75 v3(272.23,85.52)
  BOTTOM w0.152: G2.R9 v3(261.49,119.07) ; U60.U2 v3(272.23,85.52)
MDD58: length 34.8
  IN10 w0.14: v3(262.89,114.87) 262.63,114.61 262.63,113.36 262.78,113.21 262.78,101.37 266.44,97.72 266.44,90.2 266.75,89.89 266.75,87.1 268.75,85.09 269.4,85.09 v3(269.83,85.52)
  BOTTOM w0.152: G2.P4 v3(262.89,114.87) ; U60.T4 v3(269.83,85.52)
MDD59: length 36.3
  IN10 w0.14: v3(262.84,115.62) 262.84,115.49 263.52,114.81 263.52,108.12 263.42,108.02 263.42,101.55 266.87,98.1 266.87,90.35 267.2,90.02 267.2,88.12 268.6,86.72 271.83,86.72 v3(272.23,86.32)
  BOTTOM w0.152: G2.P5 262.84,115.61 v3(262.84,115.62) ; U60.T2 v3(272.23,86.32)
MDD60: length 34.8
  IN10 w0.14: v3(270.63,88.72) 270.15,88.24 268.66,88.24 268.11,88.79 268.11,90.48 267.65,90.94 267.65,99.27 265.31,101.61 265.31,107.6 264.61,108.3 264.61,113.82 264.15,114.28 264.15,115.88 264.43,116.15 264.43,117.21 v3(264.89,117.67)
  BOTTOM w0.152: U60.N4 v3(270.63,88.72) ; v3(264.89,117.67) G2.L7
MDD61: length 33
  IN10 w0.14: v3(271.43,88.72) 271.03,89.12 268.84,89.12 268.5,89.46 268.5,90.9 268.24,91.16 268.24,99.51 265.88,101.87 265.88,107.9 264.95,108.84 264.95,113.92 264.43,114.43 264.43,115.8 264.89,116.25 v3(264.89,116.37)
  BOTTOM w0.152: G2.L6 264.59,116.67 v3(264.89,116.37) ; v3(271.43,88.72) U60.N2
MDD62: length 28.8
  IN10 w0.14: v3(264.89,114.97) 264.89,114.4 265.51,113.78 265.51,109.13 266.44,108.19 266.44,102.1 268.8,99.74 268.8,91.35 v3(270.63,89.52)
  BOTTOM w0.152: v3(270.63,89.52) U60.M4 ; v3(264.89,114.97) G2.L4
MDD63: length 31.7
  IN10 w0.14: v3(272.23,88.72) U60.M2 271.83,89.87 270.98,90.72 270.33,90.72 269.21,91.84 269.21,98.37 269.36,98.52 269.36,99.97 267,102.33 267,108.5 266.47,109.04 266.47,114.43 265.73,115.17 265.38,115.17 v3(264.89,115.67)
  BOTTOM w0.152: v3(272.23,88.72) U60.M2 ; v3(264.89,115.67) G2.L5
MDI_N0: length 51.8
  TOP w0.081: v1(42.9,66.5) 43.14,66.26 43.14,64.42 43.42,64.14 43.63,64.14 43.68,64.09 U6.12
  IN10 w0.081: v1(42.9,66.5) 43.27,66.87 43.27,70.55 45.44,72.72 45.44,74.73 46.08,75.37 46.08,78.84 44.68,80.24 44.68,84.27 44.29,84.66 42.29,84.66 41.38,85.58 41.38,86.72 38.32,89.77 38.32,96.89 35.94,99.27 35.25,99.27 35.02,99.5 35.02,99.77 34.74,100.06 v1(34.64,100.06)
  BOTTOM w0.081: TL1.3 32.26,100.48 32.34,100.56 32.34,100.9 32.41,100.97 32.82,100.97 33.53,101.69 v1(34.26,101.69) 34.58,101.69 34.89,101.37 34.89,101.08 34.32,100.5 D7.6 34.21,100.06 v1(34.64,100.06)
MDI_N1: length 53.6
  TOP w0.081: U6.15 43.68,62.89 43.63,62.94 41.77,62.94 41.51,63.19 41.51,63.57 v1(41.37,63.71)
  IN10 w0.081: v1(35.4,98.15) 35.15,97.9 35.15,96.57 37.55,94.16 37.55,89.37 39.21,87.71 39.21,83.61 42.51,80.31 42.51,75.14 40.99,73.61 40.99,70.18 41.75,69.42 41.75,65.87 40.3,64.42 40.3,63.38 40.61,63.07 41.63,63.07 41.81,63.26 41.81,63.83 41.71,63.93 41.59,63.93 v1(41.37,63.71)
  BOTTOM w0.081: TL1.6 32.26,97.48 32.4,97.62 32.83,97.62 33.8,96.65 34.87,96.65 35.23,97.01 35.23,97.35 35.4,97.52 35.78,97.52 36.27,98.01 D7.3 35.85,98.6 v1(35.4,98.15)
MDI_N2: length 47.4
  TOP w0.081: v3(42.6,61.47) 42.86,61.74 43.63,61.74 43.68,61.69 U6.18
  IN10 w0.081: v1(34.64,94.06) 34.83,93.87 34.83,93.62 35.14,93.31 35.39,93.31 36.16,92.54 36.16,89.96 35.28,89.08 35.28,85.83 38.2,82.91 38.2,79.1 39.85,77.45 39.85,72.48 39.6,72.22 39.6,67.36 39.22,66.98 39.22,62.81 40.22,61.81 42.27,61.81 v3(42.6,61.47)
  BOTTOM w0.081: v1(34.64,94.06) 34.21,94.06 D6.6 34.32,94.5 34.89,95.08 34.89,95.5 34.69,95.71 33.55,95.71 32.82,94.97 32.41,94.97 32.34,94.9 32.34,94.56 32.26,94.48 TL1.9
MDI_N3: length 50.8
  TOP w0.081: U6.21 45.16,60.39 45.08,60.47 44.9,60.47 44.3,59.87 44.3,59.38 44.42,59.26 v1(44.67,59.26)
  IN10 w0.081: v1(44.67,59.26) 44.35,59.58 44.35,59.84 43.41,60.78 39.73,60.78 38.58,61.93 38.58,67.26 38.82,67.51 38.82,68.53 38.32,69.03 38.32,72.12 38.82,72.62 38.82,77.14 37.43,78.54 37.43,82.64 34.39,85.68 34.39,90.63 35.14,91.39 35.14,91.9 v1(35.4,92.15)
  BOTTOM w0.081: TL1.12 31.81,91.48 31.91,91.59 32.61,91.59 32.81,91.39 32.81,91.19 33.55,90.45 34.84,90.45 35.25,90.86 35.25,91.37 35.4,91.52 35.78,91.52 36.27,92.01 D6.3 35.85,92.6 v1(35.4,92.15)
MDI_P0: length 51.7
  TOP w0.081: v1(43.88,66.5) 43.75,66.63 43.51,66.63 43.45,66.57 43.45,64.55 43.55,64.45 43.63,64.45 43.68,64.49 U6.11
  IN10 w0.081: v1(35.4,100.06) 35.28,99.93 35.28,99.88 35.27,99.88 35.27,99.6 35.36,99.51 36.04,99.51 38.57,96.99 38.57,89.88 41.63,86.82 41.63,85.68 42.39,84.91 44.39,84.91 44.93,84.38 44.93,80.34 46.32,78.95 46.32,75.27 45.68,74.63 45.68,72.62 43.51,70.45 43.51,66.87 v1(43.88,66.5)
  BOTTOM w0.081: TL1.2 32.26,101.48 32.46,101.28 32.69,101.28 33.4,102 34.71,102 35.2,101.5 35.2,101.02 35.72,100.5 D7.1 35.83,100.06 v1(35.4,100.06)
MDI_P1: length 53.6
  TOP w0.081: v1(42.26,63.71) 42.14,63.83 41.93,63.83 41.82,63.71 41.82,63.32 41.89,63.25 43.63,63.25 43.68,63.29 U6.14
  IN10 w0.081: v1(42.26,63.71) 42.06,63.5 42.06,63.16 41.73,62.83 40.51,62.83 40.06,63.27 40.06,64.52 41.51,65.97 41.51,69.32 40.74,70.08 40.74,73.71 42.27,75.24 42.27,80.21 38.97,83.51 38.97,87.61 37.31,89.27 37.31,94.06 34.9,96.47 34.9,97.89 v1(34.64,98.15)
  BOTTOM w0.081: v1(34.64,98.15) 34.19,98.6 D7.4 33.77,98.18 34.43,97.52 34.77,97.52 34.92,97.37 34.92,97.14 34.74,96.96 33.93,96.96 32.96,97.93 32.41,97.93 32.34,98 32.34,98.4 32.26,98.48 TL1.5
MDI_P2: length 47.4
  TOP w0.081: v3(42.6,62.31) 42.86,62.05 43.63,62.05 43.68,62.09 U6.17
  IN10 w0.081: v1(35.4,94.06) 35.15,94.06 35.07,93.98 35.07,93.72 35.24,93.55 35.5,93.55 36.41,92.64 36.41,89.86 35.53,88.98 35.53,85.93 38.45,83.01 38.45,79.2 40.1,77.55 40.1,72.38 39.85,72.12 39.85,67.26 39.47,66.88 39.47,62.91 40.32,62.06 42.35,62.06 v3(42.6,62.31)
  BOTTOM w0.081: TL1.8 32.26,95.48 32.46,95.28 32.69,95.28 33.43,96.02 34.81,96.02 35.2,95.63 35.2,95.02 35.72,94.5 D6.1 35.83,94.06 v1(35.4,94.06)
MDI_P3: length 50.8
  TOP w0.081: U6.20 44.67,60.89 44.74,60.83 44.74,60.74 43.99,60 43.99,59.47 v1(43.78,59.26)
  IN10 w0.081: v1(43.78,59.26) 44.11,59.58 44.11,59.73 43.31,60.53 39.63,60.53 38.33,61.83 38.33,67.36 38.58,67.61 38.58,68.43 38.08,68.93 38.08,72.22 38.58,72.72 38.58,77.04 37.18,78.44 37.18,82.54 34.14,85.58 34.14,90.73 34.9,91.49 34.9,91.9 v1(34.64,92.15)
  BOTTOM w0.081: TL1.11 32.17,92.48 32.27,92.38 32.27,91.95 32.32,91.9 32.74,91.9 33.12,91.52 33.12,91.32 33.68,90.76 v1(34.13,90.76) 34.71,90.76 34.94,90.99 34.94,91.34 34.77,91.52 34.43,91.52 33.77,92.18 D6.4 34.19,92.6 v1(34.64,92.15)
MDO_N0: length 12.7
  IN08 w0.081: JRJ1.2 14.28,106.59 14.45,106.76 15.34,106.76 19.41,102.69 19.41,101.32 19.8,100.93 20.34,100.93 v1(20.8,100.48)
  BOTTOM w0.081: v1(20.8,100.48) 20.8,100.69 20.92,100.82 21.41,100.82 21.74,100.48 TL1.22
MDO_N1: length 13.7
  IN08 w0.081: JRJ1.6 15.46,102.7 15.46,103.46 15.72,103.72 16.38,103.72 17.63,102.47 17.63,101.45 18.9,100.18 18.9,98.53 19.57,97.86 20.42,97.86 v1(20.8,97.48)
  BOTTOM w0.081: v1(20.8,97.48) 20.8,97.69 20.92,97.82 21.41,97.82 21.74,97.48 TL1.19
MDO_N2: length 14.3
  IN10 w0.081: JRJ1.5 14.07,102.51 14.07,102.51 14.12,102.45 14.2,102.37 15.16,102.37 17.25,100.28 17.25,97.39 19.9,94.73 20.55,94.73 v1(20.8,94.48)
  BOTTOM w0.081: v1(20.8,94.48) 20.8,94.69 20.92,94.82 21.41,94.82 21.74,94.48 TL1.16
MDO_N3: length 15.2
  IN08 w0.081: JRJ1.8 14.25,100.37 14.3,100.43 15.19,100.43 15.46,100.16 15.46,96.22 19.72,91.96 20.32,91.96 v1(20.8,91.48)
  BOTTOM w0.081: TL1.13 21.74,91.48 21.41,91.82 20.92,91.82 20.8,91.69 v1(20.8,91.48)
MDO_P0: length 12.8
  IN08 w0.081: JRJ1.1 13.96,106.62 14.34,107.01 15.44,107.01 19.65,102.79 19.65,101.43 19.9,101.18 20.5,101.18 v3(20.8,101.48)
  BOTTOM w0.081: v3(20.8,101.48) 20.8,101.33 21,101.13 21.33,101.13 21.69,101.48 TL1.23
MDO_P1: length 13.8
  IN08 w0.081: JRJ1.3 15.09,104.58 15.34,104.33 15.34,104.15 15.53,103.97 16.48,103.97 17.88,102.57 17.88,101.55 19.15,100.28 19.15,98.63 19.67,98.1 20.42,98.1 v1(20.8,98.48)
  BOTTOM w0.081: TL1.20 21.69,98.48 21.33,98.13 21,98.13 20.8,98.33 v1(20.8,98.48)
MDO_P2: length 14.2
  IN10 w0.081: JRJ1.4 14.25,102.67 14.3,102.62 14.3,102.61 15.26,102.61 17.5,100.38 17.5,97.49 20.01,94.98 20.29,94.98 v1(20.8,95.48)
  BOTTOM w0.081: TL1.17 21.69,95.48 21.33,95.13 21,95.13 20.8,95.33 v1(20.8,95.48)
MDO_P3: length 15.3
  IN08 w0.081: JRJ1.7 14.07,100.53 14.12,100.59 14.2,100.67 15.29,100.67 15.71,100.26 15.71,96.32 19.82,92.21 20.52,92.21 v1(20.8,92.48)
  BOTTOM w0.081: TL1.14 21.69,92.48 21.33,92.13 21,92.13 20.8,92.33 v1(20.8,92.48)
ME_FLASH: length 240
  TOP w0.097: R2286.1 246.93,50.32 246.6,49.99 v3(246.6,49.86)
  IN03 w0.091: v1(39.21,41.35) 39.85,40.72 41.63,40.72 43.91,38.43 46.71,38.43 47.59,37.54 47.59,36.66 48.1,36.15 49.88,36.15 50.77,35.26 63.72,35.26 64.49,34.5 71.29,34.5 72.18,33.61 79.34,33.61 80.23,32.72 84.55,32.72 84.81,32.97 87.09,32.97 87.73,33.61 95.47,33.61 96.11,34.24 107.21,34.24 119.62,46.65 146.74,46.65 151.86,41.53 v1(151.86,40.08)
  IN10 w0.091: v1(151.86,40.08) 151.86,40.65 154.47,43.26 202.79,43.26 206.07,46.54 213.73,46.54 215.93,44.34 224.53,44.34 225.11,43.77 236.06,43.77 237.08,44.78 239.75,44.78 241.02,46.05 241.02,47.2 242.29,48.47 243.43,48.47 243.68,48.72 243.68,49.36 244.7,50.37 246.1,50.37 v3(246.6,49.86)
  BOTTOM w0.089: U5.A9 36.28,48.47
  BOTTOM w0.097: 36.28,48.47 36.28,46.07 36.67,45.67 36.67,43.26 v2(38.45,41.48) 38.58,41.35 v1(39.21,41.35)
MIC1_VREF_L: length 2.2
  TOP w0.203: U7.38 292.43,34.61 292.83,35 293.21,35 293.31,35.11 R846.1
MIC1_VREF_R: length 3.5
  TOP w0.203: U7.39 292.33,35.01 292.7,35.39 293.06,35.39 293.64,35.97 R845.1 293.85,36.2 v2(293.85,36.91)
MIC1L_RING2: length 16.8
  TOP w0.254: v1(293.09,33.81) U7.36
  TOP w0.508: R846.2 294.69,35.23 295.35,35.23 v1(295.38,35.26) 297.02,35.26 298.54,33.74 298.54,31.31 297.66,30.43 v2(297.66,29.29) 297.66,26.5 v1(297.78,26.37)
  IN05 w0.508: v1(293.09,33.81) 293.29,33.81 294.75,35.26 v1(295.38,35.26)
MIC1R_SLEEVE: length 16.9
  TOP w0.203: U7.37 292.69,34.21 292.98,34.5 v1(293.09,34.5)
  TOP w0.508: v1(298.42,27.38) 298.42,30.18 299.17,30.93 299.17,34.04 297.32,35.89 v2(296.11,35.89) v1(295.38,35.89) 294.66,35.89 R845.2
  IN05 w0.508: v1(293.09,34.5) 294.48,35.89 v1(295.38,35.89)
MIC2_VREF: length 5.3
  TOP w0.254: v1(292.88,35.89) 292.7,35.89 292.22,35.41 U7.40
  BOTTOM w0.508: v1(292.88,35.89) v2(293.84,34.93) 293.99,34.78 D10.2 D9.2
MIC2L: length 2.7
  TOP w0.203: C510.1 293.55,33.3 v2(292.78,33.3) 292.42,33.3 292.32,33.41 291.61,33.41 U7.35
MIC2L_C: length 17.3
  TOP w0.381: R849.1 297.19,33.36 v1(297.52,33.03)
  IN10 w0.356: v1(297.91,22.81) 297.91,23.7 295.5,26.11 295.5,31.45 297.08,33.03 v1(297.52,33.03)
  BOTTOM w0.254: JIO1.74 298.82,23.72 v1(297.91,22.81)
  BOTTOM w0.508: R848.2 296.99,33.03 v1(297.52,33.03)
MIC2R: length 2.8
  TOP w0.203: C511.1 293.35,32.87 292.6,32.87 292.5,32.97 292.23,32.97 292.2,33.01 U7.34
MIC2R_C: length 15.3
  TOP w0.381: v1(297.52,32.36) 297.03,32.36 R850.1
  IN10 w0.356: v1(297.52,32.36) 297.28,32.36 296.01,31.08 296.01,26.37 298.42,23.96 298.42,23.07 v1(298.67,22.81)
  BOTTOM w0.254: v1(298.67,22.81) 299.18,23.32 JIO1.75
  BOTTOM w0.508: v1(297.52,32.36) 296.56,32.36 R847.2
MIC_JD: length 4.2
  TOP w0.097: R312.2 v2(302.53,27.31) 302.48,27.26 301.98,27.26 301.72,27.51 v1(301.72,28.27)
  BOTTOM w0.097: JIO1.62 301.47,28.52 v1(301.72,28.27)
MPHY_EXT_PWR_GATE_N: length 1.5
  TOP w0.097: TP76.1 236.32,56.98 v3(235.94,56.59)
  BOTTOM w0.097: v3(235.94,56.59) 236.4,57.06 U2.AN24
MX0: length 29.9
  IN10 w0.091: v1(57.63,49.61) 60.42,49.61 v1(62.07,51.26)
  BOTTOM w0.076: 38.58,53.66 38.04,53.66 37.78,53.91 U5.J12
  BOTTOM w0.097: v1(57.63,49.61) 57.63,49.36 57.25,48.97 50.13,48.97 49.25,49.86 49.25,50.12 48.36,51.01 48.36,51.26 45.44,54.18 40.71,54.18 40.19,53.66 38.58,53.66 ; JEC1.15 62.97,51.91 62.33,51.26 v1(62.07,51.26)
MX1: length 23.1
  BOTTOM w0.097: U5.J13 40.1,53.91 40.63,54.44 45.56,54.44 48.48,51.51 v2(49.25,51.51) 50.01,51.51 52.04,49.48 54.59,49.48 55.86,50.75 56.43,50.75 57.47,51.8 JEC1.26
MX2: length 27
  IN03 w0.089: 39.97,54.05 38.7,54.05 37.82,54.94 v2(37.31,54.94)
  IN03 w0.091: 39.97,54.05 40.61,54.05 40.86,54.31 54.58,54.31 54.6,54.28 56.58,54.28 56.61,54.32 57.64,54.32 v1(57.88,54.56)
  BOTTOM w0.076: v2(37.31,54.94) 37.03,54.67 37.03,54.31 36.88,54.16 36.67,54.16 36.52,54.16 U5.J9
  BOTTOM w0.097: v1(57.88,54.56) 58.26,54.18 59.66,54.18 60.97,52.87 JEC1.19
MX3: length 30.4
  BOTTOM w0.076: U5.H12 37.78,53.41 38.04,53.16 38.58,53.16
  BOTTOM w0.097: JEC1.18 61.47,50.15 59.79,48.47 49.88,48.47 49.25,49.1 47.72,49.1 46.32,50.5 v2(46.32,51.9) 46.32,52.53 45.2,53.66 41.11,53.66 40.61,53.16 38.58,53.16
MX4: length 24.8
  IN03 w0.089: 39.97,53.55 37.81,53.55 v2(37.43,53.17)
  IN03 w0.091: v1(57.25,53.67) 56.74,53.17 54.07,53.17 53.47,53.77 46.83,53.77 46.61,53.55 39.97,53.55
  BOTTOM w0.076: v2(37.43,53.17) 37.43,53.17 36.88,53.17 36.67,53.17 36.43,53.41 U5.H9
  BOTTOM w0.097: v1(57.25,53.67) 57.5,53.42 59.15,53.42 59.47,53.1 JEC1.22
MX5: length 25
  IN03 w0.089: 39.97,53.78 v2(37.38,53.78)
  IN03 w0.091: v1(57.88,53.93) 57.71,54.1 56.91,54.1 56.23,53.42 54.2,53.42 53.63,53.99 46.71,53.99 46.5,53.78 39.97,53.78
  BOTTOM w0.089: U5.H10 37.15,53.78 v2(37.38,53.78)
  BOTTOM w0.097: v1(57.88,53.93) 59.28,53.93 59.97,53.23 JEC1.21
MX6: length 26.4
  BOTTOM w0.097: U5.H13 40.47,53.41 40.99,53.93 45.31,53.93 47.47,51.78 47.47,50.75 v2(47.59,50.63) TP147.1 48.61,49.61 49.12,49.61 50.01,48.72 57.5,48.72 58.47,49.69 JEC1.24
MX7: length 36.3
  IN05 w0.089: 33.62,54.56 33.62,53.04 34.6,52.07 35.57,52.07 35.81,52.3 v2(35.81,52.91)
  IN05 w0.091: v1(49.63,50.5) 49.25,50.5 45.71,54.03 41.25,54.03 40.97,54.31 39.82,54.31 38.04,56.09 34.26,56.09 33.62,55.45 33.62,54.56
  BOTTOM w0.089: U5.G9 v2(35.81,52.91)
  BOTTOM w0.097: JEC1.25 57.97,50.97 57.12,50.12 57.12,49.36 56.99,49.23 51.15,49.23 TP152.1 49.88,50.5 v1(49.63,50.5)
MXLID_N: length 302.8
  TOP w0.097: R369.1 182.93,194.01 C416.2 182.04,194.69 181.83,194.9 180.82,194.9 180.56,195.15 180.56,196.29 181.2,196.93 182.09,196.93 182.34,197.18 v1(182.34,198.2)
  IN03 w0.091: v1(78.46,46.05) 77.06,44.66 68.04,44.66 67.37,45.33 67.37,47.67 66.39,48.64 64.15,48.64 61.31,45.8 53.71,45.8 51.8,43.89 46.83,43.89 46.58,44.15 37.31,44.15 36.55,43.39 36.55,43.01 35.28,41.74 35.28,41.61 v1(34.64,40.97)
  IN05 w0.089: v2(32.48,47.2) 32.99,46.69
  IN05 w0.091: v1(34.64,40.97) 32.99,42.62 32.99,46.69
  IN10 w0.091: v1(182.34,198.2) 182.22,198.08 178.03,198.08 177.87,197.92 175.54,197.92 173.48,199.98 166.72,199.98 166.2,199.46 160.34,199.46 158.83,197.95 155.42,197.95 147.54,190.07 147.54,184.48 145.13,182.07 128.24,182.07 126.08,179.91 118.97,179.91 112.75,173.69 112.75,131.91 110.14,129.3 110.14,119.14 100.3,109.3 97.51,109.3 88.11,99.9 88.11,94.06 83.28,89.23 83.28,82.25 81.8,80.77 81.8,75.94 80.74,74.88 80.74,73.1 73.83,66.2 73.83,64.54 71.6,62.31 71.6,59.52 72.87,58.25 72.87,54.18 73.63,53.42 73.63,50.88 v1(78.46,46.05)
  BOTTOM w0.097: v2(32.48,47.2) 32.48,47.55 33.12,48.19 33.12,49.32 33.27,49.48 U5.A3
