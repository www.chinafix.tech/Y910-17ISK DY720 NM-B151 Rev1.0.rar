# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+2.5V_MEM: length 8.5
  BOTTOM w0.254: v1(208.63,105.36) 208.63,106.76 210,108.13 210,110.82 209.8,111.03 PR438.2 PR429.1
  vias: v1(202.66,88.34) v1(202.66,87.07) v1(203.3,75.01) v1(203.3,73.74) v2(206.22,92.28)
+3V: length 647.2
  TOP w0.254: v1(271.37,12.27) 272.39,11.25 U24.A3 ; v1(298.42,77.68) 299.31,76.79 R2187.1 ; JDIMM4.255 v1(196.6,64.47) ; R787.1 237.46,58.09 234.51,58.09 234.18,57.76 234.18,56.34 233.9,56.06 233.06,56.06 R171.2 232.99,56.49 v1(232.63,56.85) ; PR1413.2 113.82,68.47 v1(113.38,68.91) ; v1(198.27,81.74) 197.38,80.85 196.57,80.85 196.4,80.69 JDIMM2.255 ; R179.2 239.87,50.5 239.49,50.12 v3(239.36,50.12) ; R2327.2 85.64,72.93 84.04,71.33 84.04,67.77 83.66,67.39 79.47,67.39 v1(78.84,68.02) ; U23.A3 81.53,97.74 81.24,97.45 C626.1 ; U24.C1 273.52,9.61 v1(274.04,9.1) ; v1(107.03,96.35) 106.8,96.12 R49.2 ; R2313.2 12.16,144.86 11.58,145.44 R2312.2 ; v1(305.02,77.17) 305.02,78.01 R2188.1 ; JDIMM2.256 196.65,88.56 196.44,88.78 196.44,90.21 v1(196.98,90.76) ; JDIMM4.260 197.85,72.96 v1(197.96,72.85) 197.2,72.85 196.85,73.2 JDIMM4.256 ; v1(284.96,173.31) R2185.1 285.64,172.88 285.85,172.67 289.53,172.67 290.62,173.76 R2184.1 ; R254.1 39.09,59.13 v1(38.7,59.52) 38.2,59.01 R253.1 ; R113.2 231.82,61.12 231.11,60.4 228.65,60.4 R856.2 227.54,59.3 227.18,59.3 226.89,59.01 222.47,59.01 222.27,59.21 R185.2 ; C628.1 v1(268.57,12.4)
  TOP w0.305: R103.2 R108.1 R182.1 223.31,69.37 222.52,68.58 R173.1 221.86,66.25 221.2,65.59 221.2,62.06 v1(220.82,61.67)
  TOP w0.356: R112.2 230.09,46.49 v1(230.09,45.8) ; v1(79.09,97.45) C627.2 C626.1 ; R233.1 32.35,57.48 31.85,57.99 27.66,57.99 v1(27.02,58.63) ; v1(80.11,46.05) 80.11,46.36 PR624.1 ; v1(231.87,45.8) R164.2 R304.1 ; v1(220.82,61.67) 220.19,61.04 220.19,60.18 220.72,59.64 R185.2 ; C629.2 v1(274.42,6.18) ; R2327.2 R2328.2
  TOP w0.457: L12.1 279.5,29.67 v1(279.37,29.8) ; v1(246.6,47.45) 246.65,47.4 C179.2 ; 220.72,59.64 220.72,58.6 221.61,57.71 221.61,56.29 v1(221.71,56.19) 221.74,56.21 221.74,56.06 221.96,55.83 R106.2 R109.2 ; v3(246.25,55.55) 246.3,55.6 R181.1 ; R304.1 230.09,46.49
  TOP w0.508: R169.1 225.85,46.49 v1(226.54,45.8) 226.54,45.42 226.92,45.04 231.36,45.04 231.87,45.55 v1(231.87,45.8) ; R461.1 279.88,70.37 C553.1 279.56,71.9 279.37,72.09 v2(279.37,72.98) 279.37,75.77 v1(278.61,76.53) ; R552.1 278.18,10.16 v1(280,8.33) ; R2312.2 v1(10.76,146)
  IN03 w0.508: v1(150.76,199.6) 150.76,198.09 v1(151.8,197.04) 152.43,196.42 158.08,196.42 159.1,197.44 168.5,197.44 171.17,194.77 172.05,194.77 ; v1(271.37,12.27) 269.84,12.27 ; 269.84,12.27 269.84,8.33 271.11,7.06 272.51,7.06 273.02,6.56 274.04,6.56 ; 269.84,12.27 268.7,12.27 v1(268.57,12.4) ; v1(218.54,46.56) 218.54,46.18 219.43,45.29 226.03,45.29 v1(226.54,45.8) ; v1(274.04,9.1) 274.04,6.56 ; 274.04,6.56 v1(274.42,6.18) 277.85,6.18 v1(280,8.33) 285.21,8.33 298.17,21.29 304.9,21.29 308.96,25.35 308.96,44.4 v1(305.15,48.21)
  IN03 w1.016: 36.29,88.34 36.29,102.82 21.81,117.3 18.89,117.3 11.78,124.41 11.78,125.43 12.67,126.32 12.67,141.18 9.62,144.22 9.62,145.11 10.51,146 v1(10.76,146) 12.16,146 14.32,148.16 15.97,148.16
  IN05 w0.508: v1(116.3,192.23) 116.56,192.48 116.56,195.53 117.7,196.68 117.7,197.56 121.89,201.76 130.14,201.76 131.92,199.98 131.92,196.68 135.86,192.74 142.84,192.74 148.05,197.95 149.1,197.95 v1(150.76,199.6) ; v1(255.37,66.75) 255.37,67.01 253.84,68.53 253.84,70.56 254.6,71.33 267.69,71.33 271.75,75.39 275.18,75.39 275.56,75.77 277.21,75.77 v1(277.97,76.53) ; v1(266.1,24.84) 266.1,18.43 269.08,15.45 269.08,12.91 v1(268.57,12.4)
  IN08 w0.508: v1(266.1,24.84) 266.16,24.84 268.19,26.88 273.4,26.88 274.04,26.24 276.7,26.24 279.37,28.91 v1(279.37,29.8) 279.37,31.58 279.75,31.96 279.75,34.12 v1(280.51,34.88) ; v1(221.71,56.19) 220.95,55.43 220.95,49.23 221.14,49.03 221.14,47.64 220.7,47.2 219.17,47.2 v1(218.54,46.56)
  IN10 w0.508: v1(305.91,75.77) 310.48,80.34 310.48,96.35 310.87,96.73 310.87,108.41 310.23,109.05 v1(310.23,113.74)
  BOTTOM w0.254: v1(25.24,47.32) 25.75,47.83 26.82,47.83 R337.2 ; R102.2 R99.2 250.11,46.49 249.91,46.69 249.91,47.7 v3(249.02,48.59) ; v1(185.26,198.48) 185.01,198.23 PR1315.2 ; 151.15,199.19 PU1303.B4 ; v1(87.47,81.99) 86.84,81.99 86.2,81.36 86.2,80.01 R2339.1 ; R162.1 192.83,54.69 Q1.2 ; v1(199.11,64.47) 199.55,64.91 JDIMM3.260 ; JDIMM3.255 198.3,73.19 v1(197.96,72.85) ; v1(196.98,90.76) 197.58,90.76 198.07,90.27 JDIMM1.255 ; R165.1 218.59,43.97 218.41,44.15 Q2.5 ; R61.2 47.16,43.18 46.83,43.51 45.56,43.51 v1(45.44,43.39) 45.04,43.78 U26.5 ; v1(218.54,46.56) 218.28,46.82 217.19,46.82 R166.1 ; v1(246.6,47.45) 246.69,47.37 U4.5 ; Q1.5 195.22,54.69 R161.1 ; R566.1 v1(44.17,49.23)
  BOTTOM w0.305: Q2.5 Q2.2 218.41,46.43 v1(218.54,46.56) ; PU1303.B1 v1(151.8,197.04) ; v1(50.9,45.77) 50.41,46.26 R827.2
  BOTTOM w0.356: 151.15,199.19 150.73,198.77 PC1323.1 150.35,199.2 v1(150.76,199.6) ; TP19.1 219.55,57.61 v1(219.43,57.48) ; R548.1 R549.1 R186.2 221.2,59.39 220.95,59.13 220.95,56.98 221.71,56.21 v1(221.71,56.19) 221.74,56.21 221.74,56.06 221.96,55.83 R106.2 R109.2 ; v1(56.56,39.4) 56.23,39.07 R830.1 ; v1(40.86,43.39) R241.2 R242.2 ; PR1240.1 v1(116.3,192.23) ; R170.2 229.41,46.49 v1(230.09,45.8) ; R255.2 v1(27.02,58.63)
  BOTTOM w0.457: R574.1 279.19,29.62 v1(279.37,29.8) ; v1(255.37,66.75) 255.37,66.88 254.86,67.39 253.37,67.39 252.45,66.47 R219.1 ; v1(191.97,57.23) 192.5,56.7 R162.1 ; v1(196.95,53.42) 196.13,54.23 R161.1 ; R285.2 v1(280.51,34.88) ; L11.1 266.29,28.35 266.36,28.27 C348.2 266.36,27.38 266.22,27.25 C347.1
  BOTTOM w0.508: v1(284.96,173.31) 284.96,169.37 287.5,166.83 302.61,166.83 308.33,161.12 308.33,121.87 306.55,120.09 306.55,114.89 307.69,113.74 v1(310.23,113.74) ; v1(266.1,24.84) 266.22,24.97 C347.1 ; v1(305.91,75.77) 305.91,76.53 305.28,77.17 v1(305.02,77.17) 305.02,76.79 304.77,76.53 302.86,76.53 302.36,77.04 298.67,77.04 298.42,77.3 v1(298.42,77.68)
  vias: v1(16.99,149.3) v1(16.99,148.54) v1(36.55,87.45) v1(36.55,86.69) v1(37.19,88.09) v1(37.18,87.46) v1(37.18,86.7) v1(37.76,87.71) v1(57.88,71.58) v1(58.26,72.22) v1(63.47,11.13) v1(63.47,10.49) v1(64.1,40.59) v1(64.49,39.7) v1(64.87,40.34) v1(65.25,39.7) v1(65.25,36.53) v1(65.63,40.34) v1(65.76,38.94) v1(65.76,38.18) v1(66.01,39.7) v1(66.01,36.53) v1(66.39,40.34) v1(66.52,38.94) v1(66.52,38.18) v1(66.77,39.7) v1(66.77,36.53) v1(67.15,41.1) v1(67.15,40.34) v1(67.28,38.94) v1(67.28,38.18) v1(67.53,36.53) v1(69.18,80.34) v1(69.95,80.34) v1(72.99,83.52) v1(73.63,83.52) v1(87.47,81.23) v1(89.89,63.07) v1(90.31,63.67) v1(90.39,62.67) v1(90.9,63.05) v1(90.98,64.32) v1(90.95,63.69) v1(91.62,64.32) v1(91.61,63.69) v1(91.59,63.05) v1(192.45,195.15) v1(193.09,195.15) v1(195.68,53.42) v1(196.98,84.28) v1(196.98,83.01) v1(196.98,70.95) v1(196.98,69.68) v1(198.22,53.42) v1(199.03,81.74) v1(199.74,81.44) v1(206.22,105.57) v1(206.22,104.93) v1(206.22,104.3) v1(206.22,103.64) v1(206.22,103) v1(277.97,77.17) v1(278.61,77.17) v1(282.93,78.44) v1(282.93,77.3) v1(284.45,78.44) v1(284.45,77.3) v1(293.34,70.18) v1(293.34,69.55) v1(293.97,70.18) v1(293.97,69.55) v1(294.61,70.18) v1(294.61,69.55) v1(303.12,49.23) v1(303.12,48.21) v1(304.13,49.23) v1(304.13,48.21) v1(305.15,49.23) v3(196.95,92.64)
+3V_1.8V_EC: length 6.2
  TOP w0.305: C242.2 34.54,54.13 v2(34.82,54.41) 34.82,53.47 v2(34.77,53.43)
  TOP w0.356: C242.2 33.88,54.56 33.78,54.66 33.78,55.05 33.24,55.58 33.24,56.39 R233.2
  BOTTOM w0.254: v2(34.77,53.43) 34.29,53.91 U5.J5
+3V_CAMERA:
  vias: v2(155.8,196.8)
+3V_DP_CON: length 3.7
  TOP w0.254: R410.2 17.62,161.88 16.86,162.64 15.08,162.64
  vias: v2(14.96,150.83)
+3V_DPA_REP: length 39.4
  TOP w0.305: 73.2,95.25 72.92,95.25 71.09,93.42 ; 73.2,95.25 v1(73.2,97.54) ; 73.2,95.25 73.58,95.25 v1(74.39,94.44) 74.65,94.69 76.04,94.69 76.8,95.46 77.57,95.46 78.15,96.04 v1(78.15,96.47)
  BOTTOM w0.254: U2016.9 73.97,90.38 73.72,90.63 73.72,90.97 73.88,91.14 73.88,92.08 C2715.2 74.18,92.88 74.18,93.59 73.53,94.24 72.41,94.24 72.23,94.06 71.47,94.06 70.47,93.06 ; U2015.6 v1(70.53,91.37) ; U2015.12 v1(70.53,88.37) ; v1(74.39,94.44) R387.2 ; v1(78.15,96.47) 78.15,97.11 R396.2 ; U2015.24 v1(65.8,86.87) ; U2015.15 70.31,86.87 70.53,86.65 v1(70.53,86.61) ; U2015.27 v1(65.8,88.37) ; R2144.2 66.01,83.14 66.52,82.63 68.88,82.63 R2109.2 R2108.2 ; v1(70.47,93.03) 70.47,93.06 ; 70.47,93.06 70.28,92.87 U2015.3 ; U2015.9 v1(70.53,89.87) ; U2015.30 v1(65.8,89.87) ; U2015.33 v1(65.8,91.37) ; U2015.36 v1(65.63,92.87) ; R395.2 v1(73.2,97.54)
  BOTTOM w0.305: R2108.2 70.63,83.19 71.09,83.65 71.09,85.42 70.53,85.98 v1(70.53,86.61)
  vias: v2(67.03,85.93)
+3V_DPE_REP: length 18
  TOP w0.254: C493.2 76.22,75.14 R2280.2
  TOP w0.305: v1(76.93,65.1) R518.1 76.12,65.79 75.92,65.99 75.92,67.52 ; v1(77.82,69.55) 77.82,70.31 77.36,70.77 R454.1 ; C493.2 75.48,75.09 75.28,74.88 v1(75.28,74.5) ; v1(72.87,74.5) 72.87,74.88 73.07,75.09 C526.1 ; C527.2 77.24,75.09 v1(77.82,74.5)
  BOTTOM w0.254: v1(77.82,74.5) 77.82,74.88 78.03,75.09 U2013.36 ; v1(72.87,74.5) 72.87,74.7 72.53,75.04 U2013.25 ; U2013.32 76.03,74.87 75.66,74.5 v1(75.28,74.5) ; U2013.1 78.03,69.14 77.82,69.35 v1(77.82,69.55) ; R518.1 v1(76.93,65.1) ; v1(72.87,69.55) 72.87,69.47 72.53,69.14 U2013.12 ; U2013.6 75.53,69.3 v1(75.28,69.55)
  BOTTOM w0.356: 71.01,78.9 R510.2
  vias: v1(70.2,79.07) v1(70.2,78.18) v1(70.2,77.3) v2(71.09,76.41)
+3V_DPF_REP: length 14.9
  BOTTOM w0.254: U2014.36 68.38,64.93 68.04,64.6 v1(68.04,64.34) ; v1(68.04,59.39) 68.04,59.31 68.38,58.98 U2014.1 ; R590.1 v1(65.88,54.82) ; R439.2 61.77,68.61 60.42,67.26 60.42,66.12 60.68,65.87 62.58,65.87 62.88,65.57 U2014.25 62.88,64.93 63.22,64.6 v1(63.22,64.34) ; v1(68.8,68.15) 68.8,68.25 68.45,68.61 R2281.2 ; R591.1 v1(68.55,54.82) ; U2014.6 v1(65.88,59.38) ; U2014.12 62.88,58.98 63.22,59.31 v1(63.22,59.39) ; U2014.32 v1(66.38,64.35)
  vias: v2(61.82,64.21)
+3V_EDP: length 12.7
  BOTTOM w0.203: 198.52,194.06 198.52,193.4 198.67,193.25 198.67,192.48 198.98,192.18 v2(199.61,192.18) 200.45,192.18 200.71,192.43 200.71,192.97 201.87,194.14 204.95,194.14 205.2,194.39 205.2,194.82 v1(205.71,195.33)
  BOTTOM w0.254: 198.6,194.14 198.52,194.06
  BOTTOM w0.356: R784.2 205.46,195.51 205.63,195.33 v1(205.71,195.33) 205.91,195.33 206.52,194.72 PR1411.2
+3V_EDP_CONN:
  vias: v2(198.06,197.72)
+3V_GPU: length 881.3
  TOP w0.254: R2298.2 241.14,115.65 241.63,115.16 243.69,115.16 243.94,115.41 243.94,116.28 244.16,116.51 244.17,116.51 244.44,116.78 244.44,116.79 244.44,116.79 244.44,117.17 244.32,117.3 ; v3(247.06,112.65) 247.19,112.78 248.33,112.78 250.82,110.29 250.82,108.03 v1(250.82,108.03) ; 244.32,117.3 244.19,117.42 244.02,117.42 R2299.2 ; 244.32,117.3 245.46,117.3 245.59,117.17 245.59,116.84 245.84,116.59 246.07,116.59 246.4,116.26 v3(246.65,116.26) 248.53,116.26 249.27,115.52 249.27,114.25 249.66,113.86 250.79,113.86 250.92,114 251.68,114 253.08,112.6 253.08,108.41 251.18,106.51 248.64,106.51 247.37,105.24 247.37,103.84 246.86,103.33 246.86,102.44 247.24,102.06 247.24,100.54 246.22,99.52 243.68,99.52 243.43,99.27 242.29,99.27 241.78,98.76 241.78,92.54 241.02,91.77 241.02,84.92 239.62,83.52 221.84,83.52 221.46,83.14 v1(221.46,77.93) ; v1(220.06,120.35) Q80.5 219.04,120.35 218.92,120.22 218.92,119.7 219.17,119.44 220.27,119.44 220.54,119.71 223.11,119.71 223.62,120.22 v1(224,120.22) 224,119.84 225.22,118.62 228.77,118.62 229.56,117.83 233.5,117.83 233.52,117.86 R2295.2 R2294.2 ; v1(217.39,120.73) 217.77,120.35 Q80.2 ; U2029.5 207.47,166.16 C2696.1 207.44,167.8 207.74,168.1 208.88,168.1 v1(209.27,167.72)
  TOP w0.305: v1(297.28,70.82) 297.91,70.18 299.69,70.18 300.53,69.35 R2244.1 300.58,67.85 v1(300.58,67.14) ; R1006.2 v1(290.93,70.44) ; v1(299.18,81.87) 299.94,81.11 R2270.2 ; R798.1 v1(304.59,60.4)
  TOP w0.356: U2027.5 202.9,198.44 202.66,198.2 202.66,197.56 C2694.1 203.22,196.6 202.92,196.29 200.91,196.29 v1(200.4,195.79) ; v1(84.93,101.68) 84.93,100.67 84.04,99.77 79.85,99.77 v2(79.34,99.27) 76.3,96.22 75.15,96.22 74.77,96.6 74.77,96.98 73.12,98.63 71.6,98.63 69.57,96.6 v2(67.53,96.6) 61.06,96.6 60.8,96.85 59.66,96.85 59.47,97.05 58.39,97.05 57.19,97.31 55.86,98.64 55.86,99 54.83,100.03 54.07,100.03 53.44,100.66 50.9,100.66 49.88,99.65 49.88,95.96 v1(48.86,94.95) ; v1(211.17,197.95) 211.09,198.02 C2695.1 210.79,198.71 210.17,199.33 U2028.5 ; PR720.1 v1(219.93,166.07) ; v1(250.82,108.03) 250.54,108.03 250.16,108.41 R797.1
  TOP w0.508: v1(307.69,196.29) 307.69,195.41 305.4,193.12 305.4,193.12 301.67,189.39 PR3525.1 302.23,185.37 v1(302.36,185.25) ; v1(299.18,79.96) 299.08,79.96 298.44,80.6 291.05,80.6 290.67,80.22 290.67,78.44 289.66,77.42 286.74,77.42 285.72,76.41 282.67,76.41 280.64,78.44 273.65,78.44 273.02,77.8 273.02,74.5 273.4,74.12 v1(273.91,74.12)
  IN03 w0.305: v1(200.4,195.79) 200.4,195.94 200.88,196.42 209.65,196.42 v1(211.17,197.95)
  IN03 w0.508: v1(304.01,104.73) 303.56,104.28 303.3,104.28 301.47,102.44 301.47,101.17 303.63,99.01 303.63,96.35 303.25,95.96 303.25,94.31 v1(301.21,92.28)
  IN05 w0.254: v3(247.06,112.65) 247.24,112.83 247.24,115.19 246.65,115.78 v3(246.65,116.26)
  IN05 w0.305: v1(290.93,70.44) 291.56,71.07 294.48,71.07 294.86,70.69 297.15,70.69 v1(297.28,70.82)
  IN08 w0.305: v1(297.28,70.82) 297.28,72.98 296.16,74.1 296.16,78.21 297.15,79.2 298.42,79.2 v1(299.18,79.96)
  IN08 w0.356: v1(304.59,60.4) 300.32,64.67 300.32,66.88 v1(300.58,67.14) ; 210.79,168.35 210.03,167.59 209.39,167.59 v1(209.27,167.72) 208.63,167.08 208.63,164.29 211.44,161.48 211.44,147.67 208.25,144.48 v1(208.25,130.38) 208.88,129.75 208.88,128.1 207.87,127.08 207.87,124.97 211.09,121.75 216.76,121.75 217.39,121.11 v1(217.39,120.73) 219.68,120.73 v1(220.06,120.35) ; 210.79,168.35 211.68,168.35 212.82,167.21 218.16,167.21 219.3,166.07 v1(219.93,166.07) ; 210.79,168.35 210.92,168.48 210.92,172.16 212.95,174.2 212.95,196.65 211.65,197.95 v1(211.17,197.95) ; v1(4.92,120.22) 7.72,120.22 v1(8.73,119.21) ; v1(84.93,101.68) 87.6,101.68 97.12,111.2 100.81,111.2 102.08,112.47 102.08,114.51 108.43,120.86 108.43,126.06 112.11,129.75 v1(114.9,129.75) ; v1(9.37,122.25) 8.35,123.27 6.45,123.27 v1(5.68,122.51) ; v1(273.91,73.49) 272.26,71.83 259.43,71.83 259.05,72.22 259.05,74.5 258.54,75.01 253.59,75.01 251.45,72.88 250.69,72.88 246.73,68.91 245.08,68.91 244.32,69.68 242.03,69.68 241.27,70.44 241.27,71.07 240.89,71.45 237.84,71.45 236.19,73.1 235.43,73.1 234.92,72.6 233.65,72.6 232.38,73.87 232.38,75.01 231.62,75.77 230.22,75.77 228.57,77.42 221.97,77.42 v1(221.46,77.93) 220.95,77.42 214.47,77.42 211.9,79.99 211.9,93.22 v1(212.24,93.55) 211.21,94.58 211.21,102.1 213.96,104.85 214.73,104.85 215.62,103.97 216.28,103.97 216.71,104.4 216.71,105.18 ; v1(217.12,111.13) 217.12,107.41 217.57,106.96 217.57,105.51 217.24,105.18 216.71,105.18 ; 216.71,105.18 216.58,105.31 v1(216,105.31)
  IN08 w0.508: v1(302.36,185.25) 302.86,184.74 302.86,160.99 304.9,158.96 304.9,108.66 305.15,108.41 305.15,105.74 304.13,104.73 v1(304.01,104.73) ; v1(299.18,79.96) 299.44,79.96 299.94,80.47 299.94,81.36 299.44,81.87 v1(299.18,81.87)
  IN10 w0.356: v1(8.73,119.21) 9.37,119.84 v1(9.37,122.25) 12.03,122.25 15.97,118.32 20.92,118.32 38.07,101.17 38.07,99.75 39.47,98.35 39.47,94.57 39.85,94.19 48.1,94.19 v1(48.86,94.95) ; v1(114.9,129.75) 115.92,128.73 129.64,128.73 v1(130.53,129.62)
  BOTTOM w0.254: v1(8.73,119.21) 8.22,119.21 7.59,119.84 Q41.2 ; PR3449.1 215.36,104.98 215.69,105.31 v1(216,105.31) ; R2146.1 5.1,120.78 4.92,120.6 v1(4.92,120.22) ; v1(212.24,93.55) 212.36,93.68 212.36,94.16 PR3428.1 ; PR703.1 v1(301.21,92.28) ; PR3424.1 303.12,103.84 v1(304.01,104.73) ; Q41.5 7.59,121.9 6.98,122.51 v1(5.68,122.51)
  BOTTOM w0.305: PR801.2 300.91,184.81 301.21,185.12 302.23,185.12 v1(302.36,185.25)
  BOTTOM w0.356: 224,118.49 223.72,118.22 218.43,118.22 217.01,116.79 217.01,112.86 217.12,112.75 v1(217.12,111.13) ; 224,118.49 R2296.2 R2297.2 ; 224,118.49 v1(224,120.22) ; R2145.1 v1(9.37,122.25) ; v1(130.53,129.62) 130.4,129.49 130.4,119.08 135.61,113.87 197.33,113.87 199.74,116.28 202.53,116.28 205.71,119.46 207.11,119.46 207.87,118.7 212.19,118.7 213.71,117.17 215.74,117.17 216.12,117.55 216.12,119.56 217.29,120.73 v1(217.39,120.73) ; PR712.1 308.66,109.6 307.82,110.44 305.53,110.44 303.63,108.54 303.63,107.9 302.99,107.27 302.99,105.74 v1(304.01,104.73) ; v1(208.25,130.38) 207.79,129.92 R600.1 207.23,129.8 R1004.1
  BOTTOM w0.508: v1(299.18,81.87) 300.71,83.39 300.71,91.27 301.21,91.77 v1(301.21,92.28) ; PR28.2 306.19,194.28 307.69,195.79 v1(307.69,196.29) 307.68,196.3 PR22.1
+3V_GPU_EN_N: length 3.4
  TOP w0.097: Q94.5 303.8,82.76 R2260.2 303.93,83.98 v2(303.88,84.03) 303.75,84.03 Q94.6
+3V_HDMI_REP: length 17.1
  TOP w0.254: 79.98,81.23 79.98,80.6 79.22,79.84 R2131.2 79.22,78.18 80.23,77.17 v1(80.49,77.17)
  TOP w0.305: v1(84.07,88.22) 84.04,88.22 83.74,87.91 C2168.2 ; C2170.2 79.73,88.85 v1(79.34,88.47) ; C2722.2 79.78,84.08 v1(79.34,83.65) ; v1(84.04,85.42) 83.74,85.73 C2166.2 ; C2721.2 79.73,87.2 v1(79.34,86.82)
  BOTTOM w0.254: U2019.15 83.37,82.32 84.12,82.32 v1(84.17,82.38) ; U2019.36 79.65,88.3 79.47,88.47 v1(79.34,88.47) ; R2143.2 79.29,77.85 79.98,77.17 v1(80.49,77.17) ; U2019.3 83.99,88.3 v1(84.07,88.22) ; v1(79.34,86.82) 79.37,86.8 U2019.33 ; v1(79.34,82.12) 79.6,82.12 79.77,82.3 U2019.24 ; v1(79.34,83.65) 79.47,83.65 79.62,83.8 U2019.27 ; U2019.9 83.92,85.3 v1(84.04,85.42)
  vias: v2(85.31,84.41)
+3V_SATA: length 19.8
  TOP w0.254: v1(281.66,67.9) 281.29,67.53 U14.20
  TOP w0.305: U14.10 283.29,62.2 283.69,61.8 284.07,61.8 ; C556.2 v1(281.66,67.9)
  TOP w0.457: C557.2 C555.2 284.96,61.42 284.58,61.8 284.07,61.8 ; R462.1 R465.2 281.4,59.9 v1(281.91,59.39) ; R469.2 282.54,70.31 283.43,71.2 v2(283.81,71.2) 284.2,71.2 v1(285.08,70.31) 285.21,70.18 R470.2 ; R466.2 v1(284.07,59.39)
  TOP w0.508: v1(285.72,59.39) 286.35,59.39 286.74,59.77 286.74,60.53 286.28,60.99 C557.2 ; C556.2 C554.1 R461.2
  BOTTOM w0.356: v1(281.66,67.9) 281.83,68.08 R468.2 ; v1(285.08,70.31) 285.47,69.93 R467.2
+3V_SSD1: length 10.7
  BOTTOM w0.254: R480.2 96.11,49.99 96.36,50.24 96.36,52.02 95.09,53.29 Q9.2
  BOTTOM w0.356: 90.39,48.82 90.42,48.85 94.46,48.85 95.04,49.43 R480.2
  vias: v2(89.17,42.35)
+3V_SSD2: length 15.2
  IN10 w0.305: v1(92.81,66.12) 92.68,65.99 92.68,57.44 92.53,57.28 92.53,52.68 v1(92.55,52.66)
  BOTTOM w0.305: Q9.5 92.73,53.29 R486.2 92.68,52.91 92.55,52.78 v1(92.55,52.66)
  vias: v1(93.44,66.12) v1(95.85,82.38) v1(95.85,81.74) v1(96.49,82.38) v1(96.49,81.74) v1(96.87,66.12) v1(97,67.39)
+3V_THERM: length 3.7
  BOTTOM w0.254: U25.1 205.09,113.63 204.82,113.36 204.01,113.36 C631.2
  BOTTOM w0.457: R553.2 203.88,110.77 203.55,110.44 R554.1
+3V_TP:
  vias: v1(278.1,23.45)
+3V_WLAN: length 1.9
  TOP w0.254: Q8.2 268.32,75.09 R460.2
  TOP w0.356: R460.2 268.8,75.01 v1(269.13,74.68)
  vias: v1(259.68,75.64) v1(259.68,73.99) v1(259.68,72.72) v1(261.08,75.64) v1(282.8,75.64) v1(282.8,74.37) v1(282.8,73.36) v1(283.94,75.64)
+3VA_AMP: length 3.9
  TOP w0.254: U8.14 267.58,30.95 267.19,30.56 v1(267.19,30.43)
  BOTTOM w0.457: v2(267.84,30.43) v1(267.19,30.43) C349.2 266.49,29.74 L11.2
+3VALW: length 503.8
  TOP w0.254: v1(105.51,87.84) 105.73,88.06 106.09,88.06 PR411.2 PR407.2 ; R368.1 184.45,194.06 185.77,192.74 198.04,192.74 v1(198.17,192.61) ; 262.99,46.05 262.52,46.52 PU501.7 ; v1(264.33,49.36) 264.89,49.36 265.22,49.69 PR509.1 ; 31.97,47.27 31.97,46.94 32.2,46.71 32.72,46.71 33,46.99 R297.1 ; PR1406.2 117.7,64.59 117.32,64.21 v1(117.32,64.21) ; PU403.7 211.92,117.06 ; PR423.1 207.79,113.82 207.49,114.13 207.49,115.27 207.82,115.6 PR427.1 208.83,116.59 208.25,117.17 208.25,117.81 209.14,118.7 210.41,118.7 210.73,118.38 PC434.1
  TOP w0.305: U51.1 6.59,143.78 C512.2 10.43,144.4 v1(11.15,145.11)
  TOP w0.356: 262.99,46.05 264.26,44.78 264.26,44.4 v1(264.38,44.28) 264.89,43.77 PC513.1 ; PR723.1 219.81,167.85 v1(219.93,167.72) ; R2098.1 37.26,64.93 v1(37.18,64.85) ; PR626.1 71.85,44.02 71.22,44.66 71.22,45.29 70.33,46.18 69.18,46.18
  TOP w0.457: 211.92,117.06 v1(211.92,117.68) 211.92,117.7 211.55,118.06 PC434.1
  TOP w0.508: v1(83.92,92.15) PR105.1 ; 30.58,47.81 L2.1 ; PC719.1 215.04,169.41 215.5,168.95 v3(216.03,168.95) ; v1(135.4,148.01) 136.62,149.23 PR1221.1 ; R2056.1 60.04,95.46 v1(60.29,95.71)
  IN03 w0.508: v1(105.51,87.84) 106.78,89.11 106.78,90.12 107.41,90.76 111.73,90.76 112.87,89.61 114.14,89.61 114.9,88.85 114.9,77.3 116.17,76.03 126.46,76.03 v1(126.56,76.13) ; v1(264.38,44.28) 264.99,44.89 264.99,48.7 v1(264.33,49.36) ; v1(202.02,151.91) 202.34,152.23 203.55,152.23 204.5,153.18 206.03,153.18 206.85,154 206.85,159.46 v1(206.22,160.1) ; v1(64.23,93.81) 63.47,93.04 63.47,90.63 63.72,90.38 63.72,86.69 56.87,79.84 54.96,79.84 51.02,75.9 51.02,73.23 v1(49.75,71.96)
  IN05 w0.508: v1(135.4,148.01) 135.4,147.35 136.75,146 136.75,140.92 135.22,139.4 125.7,139.4 123.86,137.56 v1(123.86,136.09)
  IN05 w0.762: v1(66.52,20.27) 65.63,20.27 63.09,17.73 63.09,13.92 61.82,12.65 v1(61.82,10.24) v1(61.18,9.6)
  IN08 w0.254: v1(198.17,192.61) 199.94,190.83 208.13,190.83 209.39,189.57 209.39,183.72 208.5,182.83 208.5,176.48 207.49,175.47 207.49,171.53 206.22,170.26 v1(206.22,160.1) ; v1(11.15,145.11) 15.84,140.41 15.84,127.33 42.64,100.54 53.18,100.54 54.45,99.27 54.45,96.6 55.34,95.71 v1(60.29,95.71)
  IN08 w0.508: v1(66.24,79.58) 66.24,79.61 65.25,80.6 65.25,84.41 66.64,85.8 66.64,93.04 65.88,93.81 v1(64.23,93.81) ; v1(282.8,30.18) 282.04,30.94 282.04,36.02 283.56,37.54 283.56,39.07 284.3,39.81 284.3,40.29 283.79,40.8 281.22,40.8 280.41,39.98 278.1,39.98 277.74,40.34 276.42,40.34 276.19,40.11 268.29,40.11 267.18,41.23 267.18,41.46 264.38,44.25 v1(264.38,44.28)
  IN10 w0.305: v1(83.92,92.15) 81.5,89.74 79.86,89.74 78.33,88.21 78.33,81.23 77.44,80.34 71.34,80.34 70.61,79.61 66.26,79.61 v1(66.24,79.58)
  IN10 w0.508: v1(123.86,136.09) 124.44,136.09 125.83,134.7 125.83,131.14 126.47,130.5 v1(126.91,130.5) ; v1(135.4,148.01) 135.4,147.35 140.56,142.19 140.56,137.11 135.86,132.41 135.86,125.81 127.71,117.66 127.71,109.15 124.68,106.12 124.68,77.88 124.71,77.85
  IN10 w1.016: 213.33,94.57 211.81,96.09 211.81,101.55 ; 212.19,126.95 212.19,125.3
  BOTTOM w0.254: PC3539.1 v1(123.86,136.09) 123.23,136.09 122.63,135.5 PU1309.7 ; C623.2 42.77,41.23 43.29,41.75 U61.5 ; PU702.7 215.82,168.74 v3(216.03,168.95) ; R64.1 48.61,48.34 49.45,47.5 v1(49.45,47.25)
  BOTTOM w0.305: U58.5 47.5,34.86 C622.2 47.52,35.59 v1(47.47,35.64)
  BOTTOM w0.356: PR3464.1 PR3463.1 126.81,130.6 v1(126.91,130.5) ; C623.2 42.59,41.35 v1(42.59,41.99) ; v1(135.4,148.01) 135.78,148.39 R51.2 ; R831.2 v1(57.32,39.4)
  BOTTOM w0.508: PR501.2 264.26,49.43 v1(264.33,49.36) ; v1(64.23,93.81) 62.2,93.81 v1(60.29,95.71) ; R273.2 41.88,68.91 40.99,68.02 39.97,68.02 37.18,65.23 v1(37.18,64.85)
  vias: v1(48.1,71.96) v1(48.99,71.96) v1(48.99,71.05) v1(57.5,26.11) v1(57.5,25.23) v1(57.5,24.34) v1(58.26,26.11) v1(58.26,25.23) v1(58.26,24.34) v1(59.15,26.11) v1(59.15,25.23) v1(59.15,24.34) v1(59.79,39.07) v1(59.79,38.43) v1(60.04,26.11) v1(60.04,25.23) v1(60.04,24.34) v1(60.42,39.07) v1(60.42,38.43) v1(60.8,26.11) v1(60.8,25.23) v1(60.8,24.34) v1(61.06,39.07) v1(61.06,38.43) v1(61.69,26.11) v1(61.69,25.23) v1(61.69,24.34) v1(81.12,45.99) v1(81.12,45.36) v1(81.12,44.72) v1(92.3,24.34) v1(93.19,24.34) v1(93.95,24.34) v1(94.71,24.34) v1(111.73,52.28) v1(111.7,51.52) v1(111.7,50.63) v1(111.7,49.87) v1(127.35,76.97) v1(128.59,77.93) v1(128.57,76.05) v1(202.02,151.14) v1(217.01,78.95) v1(217.65,78.95) v1(219.63,47.83) v1(220.44,47.83) v1(220.44,46.56) v1(251.96,39.86) v1(252.98,39.86) v2(31.47,48.34) v2(31.47,47.73) v2(55.98,40.72) v2(60.17,48.47) v2(113.13,50.88)
+3VALW_AUD: length 1.2
  TOP w0.203: U7.10 284.66,32.61 283.5,32.61 v1(283.48,32.59)
  vias: v2(281.68,32.39)
+3VALW_EC_FSPI: length 4.5
  TOP w0.203: R297.2 34.01,48.42 34.01,49.74 33.93,49.81 C308.2 33.5,50.66 v2(33.72,50.88)
  BOTTOM w0.152: U5.D5 34.21,51.41 33.72,50.93 v2(33.72,50.88)
+3VALW_LC: length 24.1
  TOP w0.203: U19.E9 U19.D10 ; U19.J5 U19.K4
  TOP w0.254: R567.1 71.17,2.82 71.35,2.64 72.74,2.64 72.94,2.85 R620.1 73.48,2.72 75,2.72 v1(75.92,3.64) ; v2(69.58,9.86) 70.07,9.37 U19.D5 ; v3(67.79,5.92) 67.79,6.28 68.6,7.09 U19.A1 ; U19.K4 v2(73.4,8.56) ; v2(73.63,12.02) 73.25,12.02 U19.K10 ; U19.E4 70.6,8.48 v2(70.45,8.33) ; U19.D4 v2(69.57,8.33) ; 69.84,11.87 U19.D10
  TOP w0.305: C1369.2 v3(76.8,6.02)
  TOP w0.356: C1367.1 66.64,7.32 v2(67.03,6.94) ; C1363.2 77.01,7.52 v3(76.93,7.45) ; v3(66.26,7.95) 65.96,7.95 C1361.2 ; v3(66.26,9.35) 66.14,9.22 C1359.2 ; v2(69.51,11.99) 69.64,11.87 69.84,11.87
  TOP w0.457: C1362.2 v2(75.15,14.05) ; R525.1 v1(75.92,3.64)
  BOTTOM w0.254: v1(66.52,5.92) 66.12,6.32 62.94,6.32 62.76,6.49 R814.2 R825.2
  vias: v2(53.82,7.06)
+3VALW_LC_SPI: length 14.4
  TOP w0.508: C475.1 51.28,5.11 51.35,5.03 R788.2 ; C475.1 C476.2 49.63,5.85 49.3,6.18 U16.8 ; C475.1 52.05,5.85 52.29,5.6 R433.1 v1(52.42,4.78)
  BOTTOM w0.254: v1(52.42,4.78) 50.52,2.87 v2(49.47,2.87) R783.2
+3VALW_PCH: length 46.4
  TOP w0.254: 221.7,62.07 221.58,61.95 221.58,61.47 220.82,60.71 v1(220.82,60.4) ; 221.7,62.07 RP1.8 ; 221.7,62.07 221.58,62.18 221.58,62.56 ; RP1.6 221.59,63.07 221.58,63.07 ; 221.58,63.58 221.58,63.83 221.84,64.09 222.22,64.09 222.35,64.21 222.47,64.09 224.76,64.09 225.39,63.45 226.28,63.45 226.87,64.04 226.87,65.46 R875.1 ; 221.58,63.58 221.6,63.57 RP1.5 ; 221.58,63.58 221.58,63.07 ; 221.58,63.07 221.58,62.56 ; 221.58,62.56 221.59,62.57 RP1.7
  TOP w0.356: R142.2 R138.2 240.21,47.46 L38.1 241.52,47.13 v1(241.52,46.69) 241.47,46.69 241.22,46.43 C2692.2 ; R143.2 253.08,51.64 253.46,51.26 253.46,50.12 253.84,49.74 v1(254.1,49.74)
  TOP w0.457: R151.2 v1(227.43,45.8)
  TOP w0.508: v1(254.1,57.61) 253.21,58.5 249.84,58.5 R215.2
  IN08 w0.508: v1(220.82,60.4) 220.82,59.52 v1(221.58,58.75)
  BOTTOM w0.305: R137.2 238.09,47.12 238.09,46.43 237.33,45.67 237.33,43.39
  BOTTOM w0.356: v1(221.58,54.05) 221.58,54.94 220.44,56.09 220.44,59.9 220.82,60.28 v1(220.82,60.4) ; v1(221.58,58.75) 221.58,57.48 222.35,56.72 R266.1
  BOTTOM w0.457: R213.2 221.65,61.23 v1(220.82,60.4)
  BOTTOM w0.508: R115.2 219.68,61.55 v1(220.82,60.4)
  vias: v1(254.1,48.57) v1(254.99,57.36)
+3VALW_SLG: length 4.4
  BOTTOM w0.203: 54.76,41.81 54.51,42.06 U22.1
  BOTTOM w0.356: R831.1 C505.1 C506.2 v2(55.47,41.99) 55.27,41.99 55.09,41.81 54.76,41.81
+3VALW_SPI: length 30
  TOP w0.356: R937.1 217.27,52.53 217.06,52.73 R936.1 ; R936.1 215.82,52.73 215.49,52.4 215.49,49.74 215.16,49.41 R938.1 R931.1 ; R936.1 216.38,54.56 v1(217.14,55.32)
  BOTTOM w0.254: v1(217.14,55.32) 217.39,55.07 217.39,53.17 218.28,52.28 218.28,48.34 217.8,47.86 217.16,47.86 216.89,48.14 216.53,48.14 216.17,47.78 R116.2
  BOTTOM w0.356: v1(217.14,55.32) 217.65,55.83 U3.8 ; C178.2 216.63,60.4 216.38,60.15 R118.2
  BOTTOM w0.508: R115.1 217.33,60.42 C178.2 C177.1 217.32,58.45 217.65,58.12 U3.8
+3VALWP: length 18.3
  TOP w0.381: PR301.1 46.32,8.08 46.83,7.57 49.25,7.57 v2(49.58,7.91) 49.7,8.03 58.54,8.03 60.75,10.24 60.75,12.02
+3VD_AMP:
  vias: v2(280.46,28.3)
+3VD_AUD: length 378
  TOP w0.203: U7.7 284.66,33.81 283.54,33.81 v1(283.48,33.86) ; v1(286.23,28.27) 286.81,28.86 286.81,29.11 287.13,29.43 U7.19
  TOP w0.457: v1(281.53,40.08) 283.05,41.61 284.7,41.61 286.23,40.08 R292.2 ; R289.2 R310.2 v1(280.51,33.86)
  IN03 w0.508: v1(281.53,40.08) 281.53,34.88 v1(280.51,33.86)
  IN05 w0.508: v1(283.48,33.86) 284.85,32.49 284.85,31.81 286.23,30.43 v1(286.23,28.27) 286.23,24.84 287.24,23.83 290.67,23.83 291.31,23.19 291.31,21.92 296.77,16.46 305.02,16.46 309.85,21.29 309.85,59.9 307.18,62.56 307.18,65.99 309.09,67.9 309.09,72.34 307.18,74.25 307.18,76.79 310.48,80.09 310.48,111.59 308.45,113.62 308.45,119.46 309.47,120.48 309.47,171.91 v1(308.58,172.8)
  IN10 w0.508: v1(293.59,171.66) 293.59,174.45 288.13,179.91 288.13,180.04 287.75,180.42 287.75,181.08 285.24,183.59 282.93,183.59 282.29,184.23 279.23,184.23 277.45,186.01 273.05,186.01 271.44,187.61 219.85,187.61 211.39,196.07 210.77,196.07 208.12,198.72 198.23,198.72 198.22,198.71 186.68,198.71 185.64,197.67 185.64,197.34 184.6,196.29 178.18,196.29 177.69,196.78 174.87,196.78 174.72,196.93 171.24,196.93 170.48,197.69 166.59,197.69 166.06,198.22 v1(164.31,198.22)
  BOTTOM w0.356: C303.2 286.18,28.22 v1(286.23,28.27)
  BOTTOM w0.508: JCAM1.8 v1(164.31,198.22) ; v1(308.58,172.8) 305.66,169.88 301.59,169.88 300.71,170.77 295.5,170.77 294.61,171.66 v1(293.59,171.66)
+3VLP: length 154.5
  TOP w0.508: v1(28.29,52.02) 28.54,52.27 L1.1 ; PR304.2 v1(45.18,8.08)
  IN03 w0.508: v1(45.18,8.08) 45.18,6.18 46.45,4.91 50.64,4.91 52.17,6.43 59.25,6.43 61.28,4.4 63.09,4.4 63.98,5.29 71.98,5.29 72.42,5.73 74.07,5.73 75.15,4.65 77.69,4.65 77.92,4.42 79.72,4.42 81.6,6.3 82.52,6.3 83.66,7.45 88.11,7.45 89.63,8.97 93.44,8.97 94.46,9.99 v1(94.46,11.51)
  IN10 w0.508: v1(77.69,22.3) 78.07,22.3 80.36,20.02 85.06,20.02 89.89,15.19 89.89,13.03 91.16,11.76 94.2,11.76 v1(94.46,11.51) ; v1(28.29,52.02) 27.53,51.26 27.53,45.55 28.04,45.04 28.04,39.58 30.07,37.54 30.07,20.53 28.04,18.49 28.04,7.06 29.18,5.92 43.02,5.92 v1(45.18,8.08)
  BOTTOM w0.356: PR103.1 94.91,11.97 v1(94.46,11.51) ; v1(45.18,8.08) 45.44,8.08 v2(46.39,9.03) 47.64,10.29 PR355.2
+3VLP_EC: length 110.5
  TOP w0.254: v1(36.29,62.18) 35.4,61.29 35.4,58.5 34.26,57.36 R244.1 R238.1 35.83,56.54 36.04,56.34 36.04,55.83 36.24,55.63 C233.2 ; v2(33.24,51.11) 32.81,51.11 C234.2 ; v2(33.24,51.64) 33.67,51.64 C235.2 ; R299.1 38.15,49.69 37.36,48.9 R563.1 R564.1
  TOP w0.356: v2(36.78,54.94) 36.8,54.97 C233.2 ; v1(29.69,45.04) 29.69,45.04 29.69,45.11 R250.1 ; v2(33.28,54.82) 32.77,55.32 C230.1 ; v1(27.02,54.31) 27.53,54.31 27.71,54.49 R246.1 R259.2 ; v2(37.31,50.88) C237.2 37.99,50.02 R299.1
  TOP w0.508: C237.2 37.99,51.44 38.45,51.9 38.45,55.2 38.02,55.63 C233.2
  IN08 w0.381: v2(33.28,54.82) 32.1,54.82 30.83,53.55 28.8,53.55 28.04,54.31 v1(27.02,54.31)
  IN10 w0.356: v1(33.62,43.77) 32.48,42.62 32.48,31.19 39.59,24.08 40.1,24.08 44.29,19.89 47.98,19.89 48.61,20.53 59.28,20.53 60.17,19.64 69.18,19.64 v3(69.57,19.26)
  BOTTOM w0.254: v1(36.29,62.18) 36.29,62.06 35.48,61.24 R251.1 ; v2(33.24,51.11) 33.36,51.11 33.66,51.41 U5.D4 ; R268.1 69.41,19.1 v3(69.57,19.26) ; U5.K10 v2(36.78,54.94) ; U5.K4 33.77,54.54 33.5,54.82 v2(33.28,54.82) ; v2(33.24,51.64) 33.51,51.91 U5.E4 ; U5.D10 v2(37.31,50.88)
  BOTTOM w0.356: R243.1 R236.1 v1(38.96,43.39) ; R247.1 43.53,47.96 43.71,47.78 44.42,47.78 44.76,48.12 44.76,48.99 45,49.23 v1(45,50.12) 45,52.2 44.67,52.54 L3.1 ; R379.1 v1(35.99,43.39) ; R245.1 31.97,42.37 32.23,42.62 32.23,43.26 32.74,43.77 v1(33.62,43.77)
  BOTTOM w0.508: v1(33.62,43.77) R249.1 ; R232.1 v1(29.69,45.04)
  vias: v2(28.42,51.13)
+3VLP_EC_AVCC: length 22.2
  TOP w0.356: v2(35.28,52.4) 35.4,52.28 C241.2
  IN10 w0.254: 33.9,52.76 32.96,52.76
  IN10 w0.356: 33.9,52.76 34.26,52.4 v2(35.28,52.4) ; 32.96,52.76 32.35,52.15 32.35,50.88 33.12,50.12 37.43,50.12 39.34,52.02 41.24,52.02 41.75,52.53 43.66,52.53 v1(44.3,51.9)
  BOTTOM w0.254: v2(35.28,52.4) 35.41,52.27 35.92,52.27 U5.E9
  BOTTOM w0.356: R557.1 43.79,52.78 L3.2 43.92,52.28 v1(44.3,51.9)
+5V: length 713.9
  TOP w0.254: v1(113.76,59.77) 113.76,60.66 111.35,63.07 109.49,63.07 PR1412.2 ; PC1257.1 189.91,127.82 190.22,128.12 190.22,128.48 190.05,128.64 PU1254.1
  TOP w0.457: R341.2 v1(276.96,51.9) R342.2
  TOP w0.508: v1(193.03,130.1) 193.19,130.1 193.64,129.65 193.64,127.77 192.88,127 190.13,127 189.91,127.23 PC1257.1
  IN03 w0.508: v1(77.44,93.09) 77.44,94.19 76.04,95.58 73.76,95.58 72.36,96.98 v1(72.36,97.49)
  IN05 w0.091: v1(84.04,30.36) 74.14,30.36 71.29,27.51 64.87,27.51 63.34,29.03 58.14,29.03 57.15,30.02 56.65,30.02 51.42,35.24 51.42,39.81 49.5,41.74 48.61,41.74 48.36,41.48 47.21,41.48 46.45,42.24 44.67,42.24 44.18,42.74 41.56,42.74 v1(40.81,41.99)
  IN05 w0.508: v1(195.04,193.25) 195.04,192.74 194.53,192.23 190.47,192.23 188.82,193.88 177.96,193.88 v1(175.8,196.04)
  IN08 w0.305: 113.76,58.12 v1(113.76,59.77) ; v1(218.79,52.4) 217.9,51.51 217.9,46.23 218.21,45.93 222.5,45.93 v1(223.11,46.54)
  IN08 w0.762: v1(193.03,130.1) 193.64,129.49 193.64,128.45 165.58,100.38 165.58,73.49 166.59,72.47 166.59,67.01 168.75,64.85 168.75,58.63 167.48,57.36 157.07,57.36 156.18,56.47 117.57,56.47 115.92,58.12 111.35,58.12 110.21,56.98 104.3,56.98 102.82,58.46 v1(102.82,58.63) ; v1(67.66,73.61) v1(68.42,73.61) 69.82,73.61 70.96,74.76 70.96,76.03 70.45,76.53 69.57,76.53 68.3,77.8 68.3,81.55 68.45,81.7 68.45,85.7 69.44,86.69 69.44,94.44 70.84,95.84
  IN10 w0.508: v1(92.81,97.74) 92.81,101.17 98.39,106.76 106.78,106.76 113.76,113.74 113.76,129.5 115.15,130.89 115.79,130.89 ; 115.79,130.89 117.19,129.49 128.75,129.49 129.64,130.38 131.03,130.38 v1(131.67,129.75) ; 115.79,130.89 115.79,161.62 119.73,165.56 119.73,168.35 117.95,170.13 117.95,175.72 119.98,177.75 125.83,177.75 128.87,180.8 146.15,180.8 148.94,183.59 148.94,189.44 156.18,196.68 159.23,196.68 159.99,197.44 165.7,197.44 166.09,197.06 170.15,197.06 170.91,196.29 174.34,196.29 174.59,196.04 v1(175.8,196.04)
  BOTTOM w0.356: TP15.1 v1(218.79,52.4) ; PR1309.2 v1(175.8,196.04)
  BOTTOM w0.508: v1(131.67,129.75) 131.03,129.11 131.03,119.46 135.99,114.51 196.82,114.51 199.36,117.05 202.28,117.05 206.73,121.49 ; R560.1 98.84,91.46 98.14,90.76 95.47,90.76 94.97,91.27 94.97,92.92 94.2,93.68 92.3,93.68 91.92,94.06 91.92,96.85 v1(92.81,97.74) ; R327.1 44.11,6.84 43.89,7.06 42.39,7.06 41.88,7.57 41.88,8.06 40.97,8.97 34.64,8.97 31.59,5.92 23.72,5.92 20.54,9.1 19.91,9.1 18.89,10.11 18.89,14.18 17.24,15.83 v1(16.23,15.83) ; R386.2 v1(77.44,93.09)
  BOTTOM w0.762: v1(71.6,97.49) 69.31,97.49 68.68,96.85 65.77,96.85 65.5,96.58 57.31,96.58 55.26,98.63 53.56,98.63 53.06,98.12 48.74,98.12 46.45,100.41 42.64,100.41 21.31,121.75 17.8,121.75 15.21,124.34 15.21,141.18 14.27,142.12 C541.2 11.51,142.12 PU1.3
  vias: v1(13.18,17.73) v1(13.18,16.46) v1(13.18,15.83) v1(13.94,17.73) v1(13.94,16.46) v1(13.94,15.83) v1(14.7,17.73) v1(14.7,16.46) v1(14.7,15.83) v1(15.46,16.46) v1(15.46,15.83) v1(16.23,16.46) v1(80.23,23.5) v1(81.12,23.5) v1(81.88,23.5) v1(82.65,23.5) v1(95.85,72.34) v1(96.24,73.61) v1(96.87,73.61) v1(96.87,72.34) v1(99.54,91.77) v1(100.17,91.77) v1(100.27,44.53) v1(100.27,43.9) v1(100.81,91.77) v1(103.7,43.9) v1(104.47,43.9) v1(286.74,79.84) v1(286.74,79.2) v1(287.37,79.84) v1(287.37,79.2) v1(288.13,79.84) v1(288.13,79.2) v1(288.77,79.84) v1(288.77,79.2) v1(292.07,18.62) v1(292.07,17.48) v1(293.09,18.62) v1(293.09,17.48) v1(296.51,40.67) v1(296.51,40.03) v1(307.31,90.88) v1(307.31,90.25) v1(307.31,89.61) v1(307.94,90.88) v1(307.94,90.25) v1(307.94,89.61) v1(308.96,51.39) v1(308.96,50.5) v1(308.96,49.61) v1(308.96,48.72) v1(308.96,47.83) v2(12.67,16.84)
+5V_DEBUG: length 5
  BOTTOM w0.305: 40.21,4.25 JDBUG1.1
  BOTTOM w0.508: R327.2 R326.2 42.13,4.65 v2(41.73,4.25) 40.21,4.25
+5V_FAN1:
  vias: v2(291.82,76.79)
+5V_FAN2:
  vias: v2(97.51,94.47)
+5V_HDD: length 2.8
  BOTTOM w0.097: 286.74,81.74 284.45,81.74 v2(284.07,81.36)
+5V_HDMI_CON: length 19.1
  TOP w0.254: JHDMI1.18 8.06,135.75 v1(7.72,136.1)
  TOP w0.356: D2014.2 D2015.2 12.53,140.26 v2(12.16,139.88) 11.53,139.25 11.53,138.38 10.38,137.24 8.07,137.24 7.72,136.89 v1(7.72,136.1)
  BOTTOM w0.635: 5.43,138 5.43,140.22 R440.1
+5V_KB_LED:
  vias: v1(89.63,16.72) v1(90.27,16.72) v1(90.9,16.72) v2(86.33,16.01)
+5V_SPKR_LED:
  vias: v1(305.53,104.35) v1(306.42,104.35) v2(305.66,105.24)
+5V_TP_LED: length 1.1
  BOTTOM w0.508: JTPBL1.2 288.85,22.82 v1(288.86,22.81)
  vias: v2(288.13,19.51)
+5V_USB1:
  vias: v1(14.7,66.37) v1(14.7,65.36) v1(14.7,64.47) v1(15.59,66.37) v1(15.59,65.36) v1(15.59,64.47) v2(13.94,64.72)
+5V_USB2:
  vias: v1(8.99,33.73) v1(8.99,32.46) v1(16.61,36.91) v1(16.61,36.02) v1(17.88,37.29) v1(17.88,36.02) v2(19.15,36.91)
+5V_USB_KB:
  vias: v2(61.03,13.69)
+5VA_AUD: length 1.7
  TOP w0.203: v1(290.67,38.48) 289.93,37.74 U7.45
  vias: v2(290.09,40.21)
+5VALW: length 405.7
  TOP w0.254: PR1401.2 111.22,65.74 111.48,65.48 111.48,63.71 112.24,62.94 v1(113.89,62.94)
  TOP w0.305: PR3401.1 304.11,95.58 v1(304.36,95.33)
  TOP w0.356: v1(299.05,183.59) 298.67,183.98 PR1471.2 ; v1(165.83,189.94) 166.03,189.74 PR1597.2 ; v1(175.99,189.56) 176.12,189.44 PR1595.2 ; PU1608.1 300.49,88.18 300.65,88.34 PC190.2 300.65,89.56 301.14,90.05 v1(301.64,90.05) ; PR1631.2 187.04,189.72 v1(186.94,189.82)
  TOP w0.381: PR3588.2 297.91,171.78 v1(297.78,171.91) 297.78,172.42 298.34,172.98 PC191.2 299.44,172.98 PU1610.1 ; R2268.1 v1(290.55,170.95) 290.9,170.59 294.17,170.59 295.5,171.91 v1(296.01,171.91) R1014.1 ; v1(107.16,83.77) 107.16,84.66 107.73,85.23 PR405.1 ; R1010.1 210.66,151.77 v1(210.66,152.35) ; v1(270.73,204.55) 270.73,202.64 271.62,201.76 271.62,197.44 273.53,195.53 v1(273.53,193.12) ; v1(206.78,127.23) 206.24,127.23 205.71,126.7 204.24,126.7 R2265.1 ; PR3577.1 v1(296.9,87.07) ; R2260.1 v1(304.85,82.05) ; R810.1 v1(299.13,72.27)
  TOP w0.508: PR1509.1 176.88,182.58 v1(176.63,182.32) ; PR1502.1 164.69,181.56 v1(164.05,180.93) ; v1(203.93,154.59) 203.93,153.11 204.44,152.61 PR1251.1 ; v1(188.56,182.96) 187.88,183.65 PR1609.1
  IN03 w0.508: v1(209.29,180.04) 202.03,180.04 v1(199.36,182.71) ; v1(203.93,154.59) 204.52,154.59 204.95,155.02 204.95,156.16 204.44,156.67 204.44,159.72 v1(204.82,160.1) ; v1(211.55,189.56) 222.73,189.56 222.85,189.69
  IN05 w0.356: v1(134.21,189.31) 134.34,189.31 139.92,183.72 v1(150.34,183.72) v1(150.97,183.72)
  IN05 w0.508: v1(299.05,183.59) 298.55,183.09 298.55,180.27 v1(299.8,179.02)
  IN08 w0.356: v1(207.03,128.93) 207.36,129.26 207.36,144.99 210.66,148.29 v1(210.66,152.35) ; v1(206.78,127.23) 206.78,127.84
  IN08 w0.381: v1(207.03,128.93) 207.03,128.1 206.78,127.84 ; v1(215.87,116.16) 215.74,116.28 215.11,116.28 212.31,119.08 210.28,119.08 207.84,121.52 207.84,123.68 206.78,124.74 v1(206.78,127.23)
  IN08 w0.508: v1(199.36,182.71) 199.36,180.29 200.88,178.77 200.88,168.48 202.66,166.7 202.66,162.26 v1(204.82,160.1)
  IN10 w0.356: v1(116.81,39.2) 117.57,39.96 117.57,48.52 121.64,52.58 121.64,54.69 121.51,54.82 121.51,57.36 115.92,62.94 v1(113.89,62.94)
  IN10 w0.381: v1(187.17,193.25) 186.53,192.61 177.01,192.61 v1(176.37,193.25)
  IN10 w0.508: v1(129.31,158.52) 129.31,167.9
  BOTTOM w0.203: 131.67,155.88 131.85,155.7 PU1204.18
  BOTTOM w0.254: v1(59.02,42.37) 59.22,42.57 PU1301.3
  BOTTOM w0.33: PU1303.A3 152.81,198.69
  BOTTOM w0.356: PR1624.2 200.63,188.04 201.01,188.42 201.01,189.44 200.5,189.94 v1(200.38,189.94) 200.25,189.82 PR1625.1 ; PR1630.1 211.3,189.82 v1(211.55,189.56) 211.98,189.13 211.98,188.34 211.68,188.04 PR1633.2 ; PR909.2 v1(260.14,200.49) 260.14,200.92 259.94,201.12 259.94,203.03 259.23,203.74 PR910.1 ; PR1596.1 v1(176.37,193.25) ; 273.53,195.66 274.16,196.29 274.16,197.82 272.64,199.34 PR920.2 ; PR1598.1 165.6,192.08 165.6,192.94 v1(165.42,193.12) ; PR1020.1 222.52,203.74 223.36,202.9 223.36,200.74 v1(223.62,200.49) 223.62,199.77 PR1009.2 ; PU1609.1 216.24,109.13 PC192.2 ; v1(210.66,152.35) 207.74,152.35 207.23,152.86 207.23,154.38 204.57,157.05 204.57,159.85 v1(204.82,160.1) ; PR1628.1 v1(187.17,193.25) ; PC1280.1 PR1226.1
  BOTTOM w0.381: PR915.1 270.73,203.86 v1(270.73,204.55) ; v1(150.97,184.99) 150.97,194.08 153.32,196.42 153.64,196.42 154.66,197.44 154.66,198.2 154.21,198.64 PC1319.1 ; 131.67,155.88 PC1280.1 ; PR3442.1 218.73,87.77 219.55,86.95 220.06,86.95 221.33,85.68 221.33,83.26 219.04,80.98 218.03,80.98 214.73,77.68 214.73,67.26 210.66,63.2 210.66,49.99 v1(211.68,48.97) ; PR3582.1 216.05,111.66 216.25,111.46 PC192.2 ; PR3536.2 248.1,199.75 v1(248.1,200.39) 248.09,200.39 247.75,200.74 247.75,203.03 247.03,203.74 PR3534.1 ; PR1409.2 210.92,191.9 210.92,190.83 210.61,190.53 PR1630.1 ; PR1014.2 236.06,199.65 v1(236.06,200.26) 235.68,200.64 235.68,202.77 234.72,203.74 PR1023.1 ; PR1503.2 163.74,180.86 163.8,180.93 v1(164.05,180.93) ; PR1186.1 131.67,186.64 134.21,189.18 v1(134.21,189.31)
  BOTTOM w0.508: PR3582.1 215.62,113.11 215.87,113.36 v1(215.87,116.16) ; PR3539.2 v1(248.38,191.72) ; PR1226.1 130.12,157.66 129.31,158.47 v1(129.31,158.52) ; PR3526.1 290.15,181.75 297.07,181.75 v1(299.8,179.02) 301.59,177.22 301.59,173.69 301.09,173.18 299.05,173.18 v1(297.78,171.91) ; PR1002.1 223.81,196.49 224,196.29 v1(224,195.79) ; 152.81,198.69 153.91,198.69 PC1319.1 ; v1(236.19,195.66) 236.19,196.05 235.88,196.36 PR1021.1 ; PR3537.1 248.08,195.96 v1(248.38,195.66) ; PR1053.2 v1(223.87,191.72) ; PR904.2 v1(260.45,191.72) ; PR1022.2 v1(236.06,191.72) ; v1(260.57,195.66) 260.57,196.08 PR903.1
  vias: v1(14.07,42.5) v1(14.07,41.35) v1(14.07,40.08) v1(15.34,71.83) v1(15.34,70.56) v1(15.34,41.35) v1(15.34,40.08) v1(16.61,71.83) v1(16.61,70.56) v1(19.02,17.1) v1(19.02,15.32) v1(19.53,17.99) v1(19.53,16.21) v1(20.04,17.1) v1(20.04,15.32) v1(20.04,14.56) v1(20.04,13.67) v1(20.04,12.78) v1(20.04,11.89) v1(20.92,15.32) v1(20.92,14.56) v1(20.92,13.67) v1(20.92,12.78) v1(20.92,11.89) v1(41.58,71.4) v1(41.93,70.08) v1(41.97,71.91) v1(42.41,72.39) v1(42.39,70.59) v1(42.9,71.1) v1(54.07,73.36) v1(54.33,70.31) v1(54.96,71.83) v1(54.96,71.07) v1(54.96,70.31) v1(55.6,71.83) v1(55.6,71.07) v1(55.6,70.31) v1(56.48,12.65) v1(58.14,12.65) v1(100.05,86.31) v1(100.68,86.31) v1(117.57,189.44) v1(117.57,188.8) v1(118.71,43.13) v1(118.71,42.5) v1(118.71,41.86) v1(119.1,43.77) v1(119.6,44.28) v1(128.11,40.34) v1(128.11,39.7) v1(128.11,39.07) v1(128.75,40.34) v1(128.75,39.7) v1(128.75,39.07) v1(129,170.13) v1(129,169.37) v1(129,168.61) v1(129.76,170.13) v1(129.76,169.37) v1(129.76,168.61) v1(150.34,184.99) v1(224.12,42.88) v1(224.76,42.88) v1(225.39,42.88) v1(226.03,42.88) v1(226.66,42.88) v1(227.3,42.88) v1(271.88,50.12) v1(271.88,49.48) v1(272.64,50.12) v1(272.64,49.48) v1(274.16,193.12) v1(274.16,188.67) v1(274.8,188.67) v1(299.18,53.04) v1(299.18,51.9) v1(299.18,50.63) v1(299.18,49.61) v1(301.34,53.04) v1(301.34,51.9) v1(301.34,50.63) v1(302.36,53.04) v1(302.36,51.9) v1(302.36,50.63) v1(303.37,53.04) v1(303.37,51.9) v1(303.37,50.63) v2(20.42,10.24) v2(40.99,70.44) v2(273.4,49.36)
+5VALW_USB_CHG: length 5.5
  TOP w0.305: C600.1 25.81,40.91 v2(25.37,41.35) 24.48,42.24 24.48,43.77 24.15,44.1 R503.2
  vias: v1(23.85,38.43) v1(23.85,37.29) v1(24.86,38.43) v1(24.86,37.29)
+5VALWP: length 40.3
  TOP w0.203: 43.85,16.4 44.15,16.1 PU301.14
  TOP w0.356: 43.53,16.72 43.85,16.4
  TOP w0.381: PC322.1 32.38,5.52 35.15,2.75 37.31,2.75 40.1,5.54 40.1,6.18 41.88,7.95 PR302.1
  TOP w0.508: v1(43.53,17.1) 43.53,16.72
  BOTTOM w0.508: v1(25.12,8.72) 28.16,11.76 41.63,11.76 41.88,12.02 42.39,12.02 43.28,12.91 43.28,15.32 43.53,15.57 v1(43.53,17.1)
  vias: v2(27.53,12.65)
+5VD_AUD: length 4.6
  TOP w0.203: v1(289.53,39.68) 289.53,39.54 289.53,39.53 289.53,39.09 289.83,38.79 289.83,38.11 289.53,37.81 U7.46 ; v1(286.86,38.54) 286.86,38.31 287.53,37.64 U7.51
  vias: v2(286.94,39.96)
+5VLDO: length 83.1
  TOP w0.356: PR1414.2 57.45,9.78 57.07,10.16 v1(57.07,10.49)
  TOP w0.508: v1(42.13,19.13) 42.26,19.26 PR312.1
  IN03 w0.508: v1(42.13,19.13) 43.02,18.24 43.4,18.24 44.17,17.48 44.17,15.95 43.28,15.07 43.28,12.27 44.04,11.51 56.05,11.51 v1(57.07,10.49)
  BOTTOM w0.508: R326.1 49.25,4.65 50.9,6.3 55.15,6.3 56.87,8.02 56.87,10.29 v1(57.07,10.49) ; R376.1 R377.1 21.31,43.44
  BOTTOM w0.762: 21.31,43.44 v2(24.02,43.44) 24.43,43.44 26,41.86 27.02,41.86 28.8,40.08 28.8,38.81 30.2,37.42 36.55,37.42 42.13,31.83 v1(42.13,19.13)
+12V_SWF_BOOST: length 20.7
  TOP w0.254: PR609.1 272.69,70.87 273.02,71.2 274.5,71.2 275.31,70.39 275.31,65.1 275.69,64.72 275.69,63.58 276.96,62.31 278.86,62.31 279.06,62.11 279.06,59.85
  vias: v1(281.91,56.59) v1(281.91,55.96) v1(282.54,56.59) v1(282.54,55.96) v1(283.18,56.59) v1(283.18,55.96) v2(280.77,57.23)
+AVDD33_LAN: length 1.1
  TOP w0.203: U6.16 v1(43.28,62.49)
  vias: v2(39.42,64.14)
+AVDDH_LAN: length 17.2
  TOP w0.203: 45.69,59.01 45.69,59.39 45.56,59.52 U6.22
  TOP w0.508: v1(42.51,59.52) 42.51,59.21 44.24,57.48 45.38,57.48 45.77,57.86 C273.2 45.77,58.93 45.69,59.01
  IN05 w0.635: v1(42.69,65.21) 41.09,65.21 39.97,64.09 39.97,62.06 v1(42.51,59.52)
  BOTTOM w0.508: 43.53,64.65 R272.2
  BOTTOM w0.635: 43.53,64.65 43.25,64.65 v1(42.69,65.21)
+AVDDHREG_LAN: length 4.7
  TOP w0.203: v1(45.18,66.53) 45.31,66.53 45.56,66.28 U6.9
  BOTTOM w0.457: R272.1 C272.2 C271.1 45.94,66.12 45.53,66.53 v1(45.18,66.53)
+AVDDL_LAN: length 12.7
  TOP w0.203: U6.31 49.78,60.89 50.01,60.66 50.01,59.9 ; U6.6 46.76,66.05 v1(46.96,66.25) ; U6.13 v1(43.28,63.69) ; U6.19 v1(43.28,61.29)
  TOP w0.356: v1(53.69,59.9) v2(53,59.21) 52.37,58.58 C260.1 50.01,59.08 50.01,59.9
  BOTTOM w0.356: v1(43.28,61.29) 43.28,61.29 C263.2 C264.2
  BOTTOM w0.457: C262.2 43.39,63.58 v1(43.28,63.69) ; v1(46.96,66.25) 46.83,66.12 C261.2
+AVDDVCO_LAN: length 7.3
  TOP w0.203: U6.34 v1(50.77,62.09)
  BOTTOM w0.457: v1(50.77,62.09) 50.77,62.56 50.52,62.82 C265.1 C267.2 C266.1
  BOTTOM w0.508: L6.2 50.08,59.25 v2(50.08,60.02) C266.1
+DVDDL_LAN: length 3.1
  TOP w0.203: U6.37 50.35,63.29 50.52,63.45
  TOP w0.381: v1(50.77,63.71) 50.52,63.45
  BOTTOM w0.457: C259.2 50.77,64.29 v1(50.77,63.71) C257.2
  vias: v1(56.1,57.61) v1(56.74,57.61) v1(58.52,64.09) v1(58.52,63.45) v2(59.38,63.35)
+PVCC_AMP: length 7
  TOP w0.254: v1(269.78,34.31) 269.63,34.45 U8.7 ; v1(275.05,34.5) 275.09,34.45 U8.42 ; v1(275.05,33.73) 275.27,33.95 U8.41 ; U8.43 275.36,34.95 v1(275.05,35.26) ; U8.6 269.62,34.95 269.84,35.18 v1(269.84,35.51)
  vias: v2(271.98,40.21)
+V1.00DX:
  vias: v2(202.03,156.42)
+V1.0U_VCCST_VCCSFR:
  vias: v2(199.44,154.49)
+V3.3A_1.8A_VCCPGPPA: length 10.3
  TOP w0.508: v1(224.89,50.88) 224.31,50.88 R290.1
  IN03 w0.508: 230.78,52.33 229.61,52.33 228.39,51.11 227.12,51.11 226.77,51.46 225.47,51.46 v1(224.89,50.88)
  BOTTOM w0.254: v3(232.63,53.55) 232.83,53.35 U2.BA31
  BOTTOM w0.508: v1(224.89,50.88) 224.25,50.24 R290.1
+V3.3A_VCCPAZIO: length 8.1
  TOP w0.457: L38.2 241.19,48.59 241.4,48.8 241.4,48.82 242.21,49.63 242.21,49.66 242.23,49.69 242.23,50.78 C400.2 242.34,51.97 241.7,52.61 C405.2 241.35,52.78 241.35,53.72 241.14,53.93 v3(240.76,53.93)
  BOTTOM w0.254: v3(240.76,53.93) 240.86,53.93 241.3,53.49 U2.BA15
+V3.3A_VCCPGPPBCH: length 6
  TOP w0.457: v3(228.32,52.18) 228.62,52.48 C221.2
  IN03 w0.508: v3(228.32,52.18) 227.91,51.77 227.32,51.77 226.99,52.1 225.09,52.1 v1(224.89,51.9)
  BOTTOM w0.508: R210.1 224.63,51.64 v1(224.89,51.9)
+V3.3A_VCCPGPPD:
  vias: v2(224.91,52.71)
+V3.3A_VCCPGPPEF: length 1.4
  BOTTOM w0.254: U2.AJ41 228.57,58.93 v3(228.57,58.83) 228.57,58.34 U2.AL41
  vias: v2(229.46,59.26)
+V3.3A_VCCPGPPG: length 12.1
  TOP w0.356: C224.2 228.75,62.26 v3(228.95,62.06)
  IN10 w0.356: v1(220.64,63.2) 223.49,63.2 224.12,62.56 226.11,62.56 227.13,61.55 228.44,61.55 v3(228.95,62.06)
  BOTTOM w0.254: v3(228.95,62.06) 228.41,61.52 U2.AD41
  BOTTOM w0.457: R213.1 221.22,62.63 v1(220.64,63.2)
+V3.3A_VCCPSPI:
  vias: v2(226.41,47.5)
+V3.3S_VCCATS: length 13.4
  TOP w0.305: v3(242.67,61.12) 243.12,60.66 C222.1
  IN08 w0.356: v3(242.67,61.12) 242.67,61.29 243.05,61.67 246.48,61.67 248,63.2 251.43,63.2 v1(252.45,64.21)
  BOTTOM w0.254: U2.AD13 242.37,61.52 242.67,61.22 v3(242.67,61.12)
  BOTTOM w0.457: R219.2 v1(252.45,64.21)
+VBAT_EC: length 1.4
  TOP w0.254: R235.2 33.09,54.44 v2(33.24,54.28)
  BOTTOM w0.254: v2(33.24,54.28) 33.27,54.26 33.43,54.26 U5.J4
+VCC19P2_1P0: length 0.7
  BOTTOM w0.254: v3(239.49,67.14) 239.56,67.21 U2.N17
  vias: v2(242.13,68.84)
+VCC_RTC: length 216
  TOP w0.097: v2(71.72,22.18) 71.98,21.92 v1(71.98,21.54)
  TOP w0.508: R571.1 C640.1 ; C640.1 73.86,20.45 Q11.1 ; C640.1 72.56,20.45 71.98,21.03 v1(71.98,21.54) ; v1(202.41,49.23) 202.38,49.25 187.14,49.25 179.65,56.75 160.95,56.75 152.75,48.54 115.13,48.54 114.47,47.88 v2(113.76,47.88) v1(112.31,47.88)
  IN03 w0.508: v1(112.31,47.88) 111.65,48.55 109.78,48.55 107.92,46.69 106.65,46.69 106.05,46.09 106.05,44.28 104.7,42.92 92.13,42.92 90.82,44.23 84.12,44.23 83.54,43.64 78.54,43.64 77.95,44.23 70.28,44.23 69.95,43.89 v1(69.95,43.77)
  IN05 w0.508: v1(241.68,44.48) 240.46,43.26 237.08,43.26 233.52,46.82 224.38,46.82 222.6,48.59 218.66,48.59 216.89,46.82 216.38,46.82 215.36,47.83 213.33,47.83 212.95,48.21 209.14,48.21 208.12,49.23 v1(202.41,49.23)
  IN08 w0.508: v1(71.98,21.54) 71.98,22.43 71.6,22.81 71.6,39.58 69.95,41.23 v1(69.95,43.77)
+VCC_SWF:
  vias: v1(286.23,55.71) v1(286.23,54.82) v1(286.99,55.71) v1(286.99,54.82) v1(287.12,46.31) v1(287.12,45.29) v1(287.75,55.71) v2(288.39,44.48)
+VCCAAZPLL_1P0_L: length 6.5
  TOP w0.457: v3(239.62,56.85) 240,57.23 C398.2 C399.1 240.25,58.17 240.25,58.93 v2(240.63,59.31) 242.16,59.31 R226.1
  TOP w0.508: v1(256.64,55.07) 256.77,55.2 L39.2
  BOTTOM w0.254: v3(239.62,56.85) 239.41,57.06 U2.AN19
+VCCAMPHYPLL_1P0: length 0.6
  BOTTOM w0.254: v1(227.43,71.86) 227.4,71.88 U2.B43
  vias: v2(224.94,76.71) v3(225.39,73.1) v3(225.86,73.57)
+VCCAPLLEBB_1P0: length 1.5
  TOP w0.356: v3(234.54,64.85) 234.33,65.05 R218.1
  BOTTOM w0.254: U2.V28 v3(234.54,64.85)
+VCCAUSB_1P0_L: length 2.2
  TOP w0.356: R224.1 245.23,58.75 v3(245.59,58.75)
  BOTTOM w0.254: U2.AJ5 245.59,58.78 v3(245.59,58.75) 245.59,58.57 U2.AL5
+VCCDSW_1P0: length 4.5
  TOP w0.356: v3(233.65,53.67) 233.93,53.39 C212.1
  TOP w0.457: v1(255.11,58.88) 255.11,58.96 R205.1
  IN05 w0.102: 240.51,54.94 241.02,54.94 ; 239.36,55.2 240,55.2 ; 240.51,55.71 241.02,55.71
  BOTTOM w0.254: U2.BA29 233.92,53.67 v3(233.65,53.67)
+VCCDTS_1P0: length 11.5
  TOP w0.254: R217.2 250.46,61.04 248.94,61.04 248.2,61.78 246.27,61.78 245.94,61.45 v2(245.59,61.45) 244.22,61.45 244.09,61.57 241.8,61.57 241.4,61.17 v3(241.4,61.07)
  BOTTOM w0.254: U2.AD15 241.01,61.45 v3(241.4,61.07)
+VCCDUSB_1P0: length 14.4
  TOP w0.508: 239.67,61.9 239.77,61.8 241.24,61.8 241.5,62.06 245.82,62.06 246.07,62.31 247.75,62.31 248.2,62.77 v2(248.76,62.77) 248.94,62.94 251.62,62.94 R221.2 ; 239.67,61.9 239.67,62.34 239.82,62.49 v3(239.82,62.59) ; 239.67,61.9 C219.1
  BOTTOM w0.305: v3(239.82,62.59) 240.23,62.18 U2.AC17
+VCCF24_1P0_L: length 1
  BOTTOM w0.508: v3(251.56,74.22) 251.2,74.58 R189.2
  vias: v2(250.67,70.06) v3(248.13,68.53)
+VCCF100_1P0: length 1.2
  BOTTOM w0.254: v3(240.76,65.92) 240.76,65.87 240.64,65.99 U2.R17 ; v3(240.61,64.88) 240.61,64.82 240.3,64.52 U2.V17
  vias: v2(242.03,66.25)
+VCCF100OC_1P0: length 14.7
  TOP w0.305: R212.1 251.35,65.36 248.19,65.36 247.81,64.98 v2(246.76,64.98) 246.22,64.98 245.84,64.6 245.84,64.21 245.46,63.83 242.39,63.83 241.85,64.37 239.57,64.37 239.11,64.82 v3(239.11,64.85)
  BOTTOM w0.254: U2.U20 238.75,65.18 239.11,64.82 v3(239.11,64.85)
