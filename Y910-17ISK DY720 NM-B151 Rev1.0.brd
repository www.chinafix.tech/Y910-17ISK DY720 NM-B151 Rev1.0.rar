# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
1.2V_SN: length 1.5
  BOTTOM w0.508: PR403.2 117.23,89.23 PC412.1
1.05VP_BS: length 7.8
  TOP w0.254: 264.15,46.18 263.37,46.96 PU501.6
  TOP w0.508: 264.15,46.18 v2(264.15,45.78) 264.81,45.11 266.08,45.11 267,46.04 267,46.87 266.42,47.45 PR502.1
1.05VP_EN: length 5.3
  TOP w0.254: PU501.1 263.43,49.21 264.31,50.09 v1(264.61,50.09)
  BOTTOM w0.254: v2(265.04,53.42) PR505.2 PR507.1 PC511.1 265.04,50.52 v1(264.61,50.09)
1.05VP_FB: length 4.6
  TOP w0.254: PU501.4 263.82,47.86 264.18,47.5 v1(264.36,47.5)
  BOTTOM w0.254: PR508.2 265.68,48.11 PC515.2 PR511.2 264.66,47.2 v1(264.36,47.5)
1.05VP_ILIM: length 3
  TOP w0.254: PU501.3 263.72,48.31 263.82,48.42 v1(264.31,48.42)
  BOTTOM w0.356: v1(264.31,48.42) 264.21,48.52 PR501.1 263.44,48.47 PR503.2
1.05VP_LX:
  vias: v2(259.46,51.44)
1.8V_EN: length 2.7
  BOTTOM w0.254: PR3465.2 PC3541.1 123.94,131.68 123.86,131.76 123.86,132.12 PU1309.1
1.8V_MAIN_EN: length 278
  TOP w0.097: R2269.1 284.91,170.95 284.2,171.66 v2(284.2,174.07) 284.83,174.7 285.26,174.7 R2186.1 286.1,175.54 286.92,175.54 v1(287.37,175.09) ; v1(246.86,106.25) 247.49,106.89 R976.2
  IN03 w0.091: v1(216.81,119.45) 216.81,118.89 217.39,118.31 217.39,113.11 218.41,112.09 225.01,112.09 226.79,113.87 229.33,113.87 230.98,112.22 230.98,109.68 232.89,107.78 238.35,107.78 239.11,107.01 239.11,106.25 239.36,106 240.13,106 241.14,107.01 245.59,107.01 246.35,106.25 v1(246.86,106.25)
  IN05 w0.091: v1(297.5,197.53) 297.02,197.06 296.26,197.06 295.88,196.68 295.88,185.09 296.11,184.86 296.11,181.41 291.56,176.86 287.75,176.86 287.37,176.48 v1(287.37,175.09) 287.5,174.96 298.17,174.96 298.42,175.21 300.71,175.21 303.37,172.55 303.37,164.04 305.4,162 305.4,122.63 304.77,122 304.77,110.95 303.45,109.64 v1(303.45,109.4)
  IN08 w0.091: v1(216.81,119.45) 216.81,119.53 216.62,119.71 v1(210.54,119.71)
  IN10 w0.091: v1(246.86,106.25) 246.6,106 246.6,104.85 245.46,103.71 245.46,100.86 242.38,97.78 242.38,84.95 243.68,83.65 251.12,83.65 251.79,82.98 265.37,82.98 265.91,83.52 273.53,83.52 274.86,84.85 274.86,86.68 279.66,91.48 279.66,104.31 281.22,105.87 290.74,105.87 294.17,109.3 303.35,109.3 v1(303.45,109.4)
  BOTTOM w0.097: v1(210.54,119.71) 210.54,119.68 210.31,119.46 PR38.1 ; v1(297.5,197.53) PR30.2
1.8V_MAIN_EN_LS: length 159.3
  TOP w0.097: R1013.1 v1(291.31,174.2) ; D2020.1 297.81,64.56 298.04,64.34 299.94,64.34 v1(301.09,65.48) ; R2185.2 286.69,173.44 Q85.3 v1(288.12,173.44)
  IN05 w0.091: v1(288.12,173.44) 288.88,174.2 v1(291.31,174.2) 297.91,174.2 298.93,173.18 300.69,173.18 302.61,171.26 302.61,163.66 304.64,161.62 304.64,123.65 304.01,123.02 304.01,111.33 300.96,108.28 300.96,104.22 300.71,103.97 300.71,101.81 302.1,100.41 303.63,100.41 305.25,98.79 305.25,97.08 303.63,95.46 303.63,94.19 302.99,93.55 302.99,92.79 302.48,92.28 302.48,85.55 302.1,85.17 302.1,83.52 301.09,82.5 301.09,78.31 v1(305.79,73.61)
  IN08 w0.091: v1(301.09,65.48) 302.99,67.39 303.63,67.39 305.79,69.55 v1(305.79,73.61) ; v1(291.31,174.2) 291.56,174.2 298.67,181.31 300.83,181.31 v1(301.59,182.07)
  BOTTOM w0.097: PR804.2 297.93,183.52 PD801.2 299.94,182.78 PR803.1 ; PR801.1 PR803.1 ; PR803.1 299.99,182.53 300.45,182.07 v1(301.59,182.07)
1.8V_MAIN_EN_LS_N: length 4.2
  TOP w0.097: Q90.6 295.11,174.44 295.37,174.7 v2(296.26,174.7) 296.26,173.76 R1014.2 295.8,173.31 Q90.5
1.8V_MAIN_EN_N: length 3.3
  TOP w0.097: R2268.2 289.61,171.9 Q101.6 ; R2268.2 290.42,172.62 v2(290.42,172.8) ; R2268.2 289.2,171.4 Q101.5
1.8V_MAIN_EN_R: length 10.9
  TOP w0.097: v3(240.76,112.6) 243.25,112.6 244.14,111.71 244.95,111.71 245.71,110.95 246.35,110.95 v1(246.86,110.44) 247.49,109.81 R976.1
  BOTTOM w0.097: v1(246.86,110.44) 246.73,110.32 R975.2 247.92,109.76 v2(248,109.68)
  BOTTOM w0.1: v3(240.76,112.6) 240.79,112.63 G2.BE1
1.8VP_BS: length 1.8
  TOP w0.356: PR3462.1 123.8,135.39 v1(123.86,135.46)
  BOTTOM w0.254: v1(123.86,135.46) 123.86,135.31 123.48,134.93 PU1309.6
1.8VP_FB: length 3.8
  BOTTOM w0.254: PR3458.1 PC3528.2 PR3457.2 124.76,134.16 124.63,134.03 PU1309.4
1.8VP_ILIM: length 4.5
  BOTTOM w0.254: PU1309.3 124.47,133.58 124.73,133.32 124.73,131.92 125.16,131.49 PR3461.1 PR3463.2
1.8VP_LX: length 1.2
  TOP w0.356: PC3533.2 121.7,131.9 v1(122.21,131.39)
  vias: v2(121.2,130.63)
1.55V_PWR_EN: length 58.1
  TOP w0.097: v1(295.63,75.64) 294.36,75.64 294.26,75.55 D2012.1 294.15,74.78 R813.1 293.26,73.87 R809.1 292.53,73.82 291.82,73.1 291.82,70.06 v2(291.69,69.93) 291.46,69.71 D51.1 D2017.1
  IN05 w0.091: v1(305.15,75.77) 304.26,76.66 303.63,76.66 303.25,77.04 303.25,78.31 302.61,78.95 301.47,78.95 301.34,79.07 301.34,82.38 302.44,83.47 302.44,85.17 302.74,85.47 302.74,91.01 303.5,91.77 303.5,93.55 305.46,95.52 305.46,98.9 303.7,100.66 302.23,100.66 301.21,101.68 v1(301.21,103.46)
  BOTTOM w0.097: v1(305.15,75.77) 301.47,75.77 300.71,76.53 298.17,76.53 297.78,76.15 296.13,76.15 v1(295.63,75.64) ; PR3567.2 301.42,103.66 v1(301.21,103.46)
1.55V_PWR_EN_N: length 112.2
  TOP w0.097: Q105.4 299.31,169.96 v1(299.44,170.09) ; Q91.6 297.27,73.61 297.02,73.86 v1(297.02,73.99) 297.28,74.25 v2(297.66,74.25) 298.22,73.69 R810.2
  IN05 w0.091: v1(300.58,80.34) 300.58,84.15 302.1,85.68 302.1,92.41 302.61,92.92 302.61,93.81 303.37,94.57 303.37,95.71 304.77,97.11 304.77,98.5 303.5,99.77 301.72,99.77 300.32,101.17 300.32,104.22 300.71,104.6 300.71,108.41 303.75,111.46 303.75,123.4 304.39,124.03 304.39,161.37 302.23,163.53 302.23,168.99 301.13,170.09 v1(299.44,170.09)
  IN08 w0.091: v1(300.58,80.34) 298.93,78.69 297.4,78.69 296.51,77.8 296.51,75.39 297.02,74.88 v1(297.02,73.99)
2.5V_MEM_EN: length 3.8
  TOP w0.097: PR425.1 PC421.1 210.18,112.47 210.18,113.52 210.76,114.09 PU403.1
2.5V_MEM_PWRGD: length 2.7
  TOP w0.097: PR451.1 PR423.2 210.11,113.82 210.83,114.54 PU403.2
2.5VP_BS: length 2.1
  BOTTOM w0.457: PR428.1 211.32,116.63 v2(211.32,117.43) 211.07,117.68 v3(210.66,117.68)
2.5VP_FB: length 3.5
  TOP w0.254: v1(210.48,115.44) PU403.4
  BOTTOM w0.254: PR438.1 209.75,113.27 PC435.2 PR439.2 210.08,115.04 v1(210.48,115.44)
2.5VP_ILIM: length 2.5
  TOP w0.097: PU403.3 210.77,114.99 210.48,114.71 PR431.1 PR427.2
2.5VP_LX: length 2.5
  BOTTOM w0.508: PR418.1 211.7,111.1 PC424.2 212.2,112.44 v1(212.62,112.86)
3V5V_EN: length 13.2
  TOP w0.203: PU301.20 42.73,13.25 41.88,12.4 v2(41.88,12.02) 41.88,11 v1(42.01,10.87) ; PU301.6 46.45,12.89 46.45,12.65 46.78,12.32 47.57,12.32 PC317.1 PR314.1 PR313.2 v1(47.09,10.87)
  BOTTOM w0.254: v1(47.09,10.87) v1(42.01,10.87)
3VLDO_1.0VG: length 2
  BOTTOM w0.254: PU702.5 217.22,167.59 217.88,168.25 PC718.1
3VLDO_1.05VP: length 2.8
  TOP w0.305: PU501.5 263.61,47.41 264.21,46.82 264.76,46.82 265.21,47.26 PC512.1
3VLDO_1.8VP: length 1.8
  BOTTOM w0.254: PU1309.5 124.22,134.48 PC3532.1
3VLDO_2.5VP: length 1.8
  TOP w0.254: PU403.5 210.72,115.89 210.01,116.6 PC437.1
5VALW_PG: length 60.3
  TOP w0.097: v1(16.2,45.93) 16.33,46.05 R791.1 ; v1(47.16,12.81) 47.16,13.03 46.55,13.65 PU301.7
  IN05 w0.091: v1(47.16,12.81) 46.68,12.81 45.82,13.67 45.82,15.32 44.93,16.21 44.93,19.38 38.07,26.24 38.07,32.46 36.55,33.99 29.56,33.99 28.04,35.51 26.89,35.51 26.51,35.89 26.51,36.78 25.55,37.75 23.43,37.75 23.08,38.1 23.08,44.91 22.32,45.67 16.45,45.67 v1(16.2,45.93)
  BOTTOM w0.097: v1(47.16,12.81) 48.36,11.61 PR355.1
12V_SN: length 2.3
  BOTTOM w0.508: PR417.2 275.46,57.62 PC416.1 v2(275.46,59.69)
+0.6V_VTT: length 25.1
  TOP w0.254: JDIMM4.258 197.35,75.29 198.28,76.22 v1(198.28,76.28) ; v1(198.22,85.8) 197.45,85.8 197.15,86.11 JDIMM2.258
  TOP w0.305: PR1404.2 114.27,69.93 114.65,69.55 v1(114.65,68.91)
  IN10 w0.254: 114.65,69.68 115.54,70.56 v1(117.19,70.56)
  IN10 w0.305: 114.65,69.68 v1(114.65,68.91)
  BOTTOM w0.102: v1(198.28,76.28) 198.41,76.28
  BOTTOM w0.254: 199.49,67.77 199.05,67.33 JDIMM3.258
  BOTTOM w0.457: 199.49,67.77 204.19,67.77 205.07,68.66
  BOTTOM w0.508: 204.82,85.04 198.98,85.04 v1(198.22,85.8)
  vias: v1(117.95,70.56) v1(205.84,72.47) v1(205.84,70.95) v1(205.84,70.18) v1(205.84,69.42) v2(118.21,81.99)
+0.6VSP: length 0.9
  TOP w0.305: PU401.2 110.86,91.88
  vias: v2(116.4,93.93)
+1.0V_VCCSFR: length 21.6
  TOP w0.305: C946.2 185.47,150.23 v1(185.72,150.49)
  IN05 w0.508: 185.21,151 v1(185.72,150.49)
  IN05 w0.635: v1(182.85,165.69) 182.09,164.93 182.09,164.29 180.72,162.92 180.72,159.41 182.09,158.04 182.09,152.73 183.1,151.72 184.49,151.72 185.21,151
  BOTTOM w0.305: v1(185.72,150.49) 185.34,150.87 U1.H28 U1.J28
  BOTTOM w0.762: R54.1 v1(182.85,165.69)
+1.0V_VCCST: length 127.5
  TOP w0.356: v1(185.37,153.22) 185.37,152.96 185.59,152.73 C945.2 ; PR1234.2 PR1235.1 PC1157.2 115.16,194.52 v1(115.03,194.39)
  TOP w0.381: v1(196.23,159.49) 194.53,157.79 194.53,157.43 v2(192.21,155.11) 191.74,154.64 190.47,154.64 189.96,154.13 R14.2
  IN03 w0.356: v1(144.24,155.91) 144.24,159.97 145.64,161.37 v1(145.64,162.13)
  IN03 w0.508: v1(115.03,194.39) 114.81,194.17 114.81,190.16 115.41,189.56 115.41,176.48 118.84,173.05 129.13,173.05 140.05,162.13 v1(145.64,162.13) 166.72,162.13 168.88,159.97 181.78,159.97 182.16,160.35 182.16,163.73 v1(182.85,164.42)
  BOTTOM w0.203: v1(144.24,155.91) 143.35,155.02 143.35,150.88 143.99,150.24 144.5,150.24 R24.2 ; U1.H30 185.4,153.22 v1(185.37,153.22)
  BOTTOM w0.356: R7.1 145.13,162.64 v1(145.64,162.13) 146.15,162.64 R8.2 ; R25.2 144.5,156.16 v1(144.24,155.91)
+1.0V_VCCST_VCCSFR:
  vias: v1(198.09,157.81) v1(198.09,157.18)
+1.0V_VCCSTG: length 78.5
  TOP w0.097: v1(186.37,152.06) 186.38,152.07 v2(187.45,152.07)
  TOP w0.305: v1(186.37,152.06) 185.33,152.06 C947.2 C948.2 185.25,151.35 C944.2
  IN03 w0.254: v1(146.65,153.24) 145.89,154 145.89,158.83 148.05,160.99 165.58,160.99 167.61,158.96 181.07,158.96 181.96,158.07 181.96,152.86 182.98,151.84 185.26,151.84 185.48,152.06 v1(186.37,152.06)
  IN10 w0.305: v1(135.4,146) 134.72,146.69 134.72,148.54 134.97,148.8 142.59,148.8 146.65,152.86 v1(146.65,153.24)
  BOTTOM w0.254: U1.G30 186.17,152.46 186.37,152.26 v1(186.37,152.06) ; R11.2 v1(146.65,153.24)
  BOTTOM w0.305: U1.H29 185.4,151.67 185.78,152.06 v1(186.37,152.06)
  BOTTOM w0.508: R60.2 134.46,145.52 134.79,145.85 135.25,145.85 v1(135.4,146)
  vias: v1(197.7,159.35) v1(197.68,158.71)
+1.0V_VCCSTG_RC: length 214.1
  IN05 w0.091: v1(85.44,29.85) 85.01,29.42 80.74,29.42 80.52,29.64 74.43,29.64 71.54,26.75 64.49,26.75 62.94,28.29 57.72,28.29 56.72,29.29 55.84,29.29 50.52,34.62 50.52,38.94 v1(50.26,39.2)
  IN08 w0.091: v1(85.44,29.85) 85.13,30.16 85.13,35.06 82.39,37.8 82.39,52.4 80.61,54.18 80.61,61.42 80.36,61.67 80.36,65.1 80.61,65.36 80.61,66.68 79.91,67.39 78.84,67.39 77.2,69.03 77.2,76.92 77.58,77.3 77.58,81.45 78.2,82.07 78.2,88.98 78.61,89.39 79.75,89.39 80.47,90.11 80.47,95.06 81.12,95.71 83.59,95.71 97.3,109.43 101.32,109.43 103.6,111.71 103.6,113.87 110.21,120.48 110.21,124.92 111.6,126.32 114.27,126.32 v1(114.78,126.83)
  IN10 w0.091: v1(114.78,126.83) 114.27,127.33 114.27,127.97 114.52,128.22 131.29,128.22 133.95,130.89 133.95,132.29 139.29,137.62 139.29,140.34 v1(135.4,144.22)
  BOTTOM w0.097: U59.2 137.91,146.84 C248.2 137.84,145.82 136.24,144.22 v1(135.4,144.22) R60.1 ; v1(50.26,39.2) 50.59,39.2 R836.2
+1.0VALW: length 417.7
  TOP w0.305: R596.1 257.86,61.37 256.97,60.48 R205.2
  TOP w0.356: R596.1 257.86,62.21 258.57,62.92 259.41,62.92 259.94,63.44 259.94,67.52
  TOP w0.381: v1(51.53,8.97) 51.79,8.72 PR1403.2
  TOP w0.457: C601.2 v1(137.81,149.81)
  IN08 w0.305: v1(203.17,153.11) 200.76,155.53 200.76,165.69 199.61,166.83 199.61,172.11 198.09,173.64 198.09,182.96 199.4,184.28 199.4,189.9 195.95,193.36 195.95,193.67 195.74,193.88 192.37,193.88 191.71,194.54 190.37,194.54 189.61,193.78 184.65,193.78 v1(184.12,193.25)
  IN08 w0.508: v1(137.81,149.81) 138.02,149.81 139.42,148.42 139.42,142.83 141.26,140.99 141.26,134.76 143.73,132.29 143.73,113.62 136.88,106.76 121.89,106.76 113.13,98 113.13,94.82 114.78,93.17 114.78,78.44 114.02,77.68 112.24,77.68 110.27,75.71 110.27,69.49 106.14,65.36 106.14,63.83 101.95,59.64 101.95,57.83 103.7,56.09 111.6,56.09 114.14,53.55 117.19,53.55 117.88,52.86 v1(119.35,52.86)
  IN10 w0.305: v1(137.81,149.81) 138.02,149.81 138.6,149.23 141.62,149.23 142.08,149.69 142.08,162 140.3,163.78 140.3,170.64 140.69,171.02 148.43,171.02 151.1,173.69 151.1,176.1 151.99,176.99 151.99,179.78 153.26,181.05 153.26,191.47 154.4,192.61 156.43,192.61 158.31,194.49 164.79,194.49 166.21,195.91 169.77,195.91 171.9,193.78 183.84,193.78 184.12,193.5 v1(184.12,193.25)
  IN10 w0.381: v1(119.35,52.86) 119.35,52.45 114.9,48.01 114.9,42.5 106.9,34.5 106.9,27.64 105.76,26.5 99.54,26.5 94.84,21.8 91.03,21.8 90.01,22.81 79.85,22.81 79.47,23.19 77.31,23.19 76.93,22.81 76.93,16.72 75.92,15.7 62.33,15.7 58.14,11.51 52.42,11.51 51.53,10.62 v1(51.53,8.97)
  IN10 w1.016: 217.14,133.94 217.14,131.78 216.76,131.4
  IN10 w1.524: 212.57,131.02 211.55,132.03 211.55,134.06
  IN10 w2.54: 218.54,87.33 219.93,87.33 221.84,85.42 ; 215.11,130.38 215.11,124.92
  BOTTOM w0.305: v1(137.81,149.81) 138.15,149.81 138.56,149.4 U59.5
  vias: v1(207.87,156.8) v1(207.87,156.04) v1(223.49,81.05) v1(223.49,79.86) v1(224.25,81.05) v1(224.25,79.86) v2(261.72,70.56)
+1.0VALW_PCH: length 7.7
  TOP w0.508: L39.1 C2693.2 257.45,56.9 256.96,56.41 256.43,56.41 256,56.84 256,57.74 255.62,58.12 254.73,58.12 254.48,58.37 254.48,60.4
  vias: v1(253.79,66.78) v1(254.6,66.75) v2(254.6,74.25)
+1.0VG: length 6.8
  BOTTOM w0.254: 217.65,158.96 219.17,160.48 v2(219.17,161.12) PR717.1 PR719.2
+1.0VP: length 10.7
  BOTTOM w0.254: v1(264.21,57.76) 264.21,57.28 267.43,54.05 267.43,50.4 266.92,49.89 PR506.1 PR508.1
  vias: v2(259.43,57.94)
+1.2V_BST: length 3.8
  TOP w0.254: 113.13,89.36 113,89.49 PU401.18
  TOP w0.508: PR401.1 114.4,88.85 v2(114.31,88.94) 113.89,89.36 113.13,89.36
+1.2V_CPU_VDDQ: length 16.1
  BOTTOM w0.254: U1.AJ12 v1(168.54,137.69) U1.AL11 ; v1(178.89,133.74) 179.21,134.07 U1.T6 ; v1(163.05,137.69) 163.34,137.98 U1.AT12 163.64,138.11 164.29,138.11 U1.AR12 ; v1(171.28,136.42) U1.AG9 ; U1.AY6 160.95,134.07 v1(161.29,133.73) 161.63,134.07 U1.AW6 ; v1(173.09,138.3) U1.AE12 ; U1.AG5 171.2,133.71 171.21,133.71 171.29,133.71 v1(171.35,133.7) 171.41,133.7 171.69,133.42 U1.AF5 171.88,133.51 171.88,133.97 U1.AF6 ; U1.AP7 165.34,134.33 U1.AP6 U1.AR6 164.14,134.07 v1(163.82,133.74) ; U1.J6 185.1,133.97 184.46,133.97 U1.K6 184.13,134.3 183.75,134.3 U1.L6
  BOTTOM w0.305: U1.L12 183.8,138.15 184.3,138.15 U1.K12 184.77,137.67 v1(184.86,137.67) ; U1.R6 U1.T6 ; U1.W6 176.7,134.07 v1(176.37,133.74) 176.3,133.74 U1.AA6 ; U1.J6 185.27,134.07 v1(185.6,133.73) 185.5,133.73 185.2,133.43 185.2,133.42 U1.J5
  vias: v2(164.56,119.97) v2(181.07,120.22)
+1.2V_FB: length 4.4
  TOP w0.254: PR410.2 104.9,90.81 PR408.2 PC413.2 PR413.1 108.25,90.81 108.77,90.29 PU401.6
+1.2V_LG: length 5.3
  TOP w0.305: v1(111.09,86.69) 111.26,86.86 PU401.15
  BOTTOM w0.508: v1(111.09,86.69) 111.48,86.69 111.73,86.44 v2(113.51,86.44) 114.04,85.9 PQ401.5
+1.2V_TON: length 2
  TOP w0.254: PR412.2 108.17,88.85 108.41,89.09 PU401.9
+1.2V_UG: length 6.3
  TOP w0.305: 112.71,88.95 112.57,89.09 PU401.17
  BOTTOM w0.508: v1(113.63,88.47) v1(113,88.47) 111.98,88.47 111.73,88.22 v2(110.33,88.22) 109.7,88.22 108.76,87.28 PR402.2
+1.2V_UGR: length 4.1
  BOTTOM w0.508: PQ401.3 107.92,84.03 107.67,84.28 v2(107.67,86.19) 107.67,87.02 PR402.1
+1.2V_VDDQ: length 285.7
  TOP w0.254: JDIMM2.241 192.9,77.21 193.2,76.91 v1(193.71,76.91) ; JDIMM4.123 161.6,65.02 v1(162.02,64.6) ; JDIMM4.135 v1(164.6,64.6) ; v1(107.87,94.01) C426.1 109.51,94.58 U56.5 ; JDIMM4.54 144.35,76.11 v1(144.18,76.28) ; 173.45,64.62 173.6,64.77 JDIMM4.163 ; v1(144.18,88.98) 144.18,88.85 144.15,88.83 JDIMM2.54 ; JDIMM4.153 171.1,64.6 ; 155.16,89.61 154.65,89.1 JDIMM2.96 ; JDIMM4.96 154.85,76.67 155.05,76.86 v1(155.61,76.86) ; v1(178.09,76.91) 177.58,76.91 177.35,76.69 JDIMM4.178 ; v1(138.35,76.91) 138.72,76.91 138.9,77.1 JDIMM2.33 ; JDIMM4.159 172.6,64.6 ; JDIMM4.199 182.6,64.97 182.98,64.6 ; JDIMM4.75 149.6,64.82 v1(149.83,64.6) ; v1(161.01,64.6) 160.75,64.6 160.1,65.25 JDIMM4.117 ; JDIMM4.220 187.85,76.77 187.99,76.91 v1(188.5,76.91) ; JDIMM4.141 v1(166.1,64.6) ; v1(192.88,64.6) 193.1,64.81 JDIMM4.241 ; JDIMM4.12 133.85,75.86 v1(134.27,76.28) ; v1(186.6,89.61) 186.91,89.61 187.65,88.88 JDIMM2.220 ; JDIMM4.147 169.6,64.6 ; JDIMM2.12 133.65,89.12 v1(134.27,89.74) ; JDIMM4.111 158.6,64.86 v1(158.34,64.6) ; v1(148.38,76.91) 149,76.91 149.4,77.31 JDIMM2.75 ; v1(183.29,76.91) 182.79,76.91 182.4,77.3 JDIMM2.199 ; v1(176.44,89.61) 176.88,89.61 177.15,89.34 JDIMM2.178 ; JDIMM4.129 v1(163.1,64.6) ; PR1407.2 119.6,70.39
  TOP w0.305: JDIMM4.112 158.85,75.52 159.23,75.89 159.23,76.36 159.74,76.86 v1(160.18,76.86) 160.61,76.86 160.81,76.66 160.81,75.9 160.35,75.44 JDIMM4.118 ; v1(172.5,88.98) 172.65,88.83 JDIMM2.160 ; JDIMM2.123 161.4,77.88 161.02,77.5 v1(160.18,77.5) ; JDIMM4.142 166.35,75.92 v1(166.66,76.23) ; JDIMM2.159 172.4,77.65 v1(172.5,77.55) 173.13,77.55 173.4,77.82 JDIMM2.163 ; JDIMM4.154 171.35,75.9 170.97,76.28 v1(170.59,76.28) 170.21,76.28 169.85,75.92 JDIMM4.148 ; JDIMM2.153 170.9,77.86 v1(170.59,77.55) ; JDIMM2.142 166.15,88.73 166.41,88.98 v1(166.66,88.98) ; v1(162.72,77.5) 162.9,77.68 JDIMM2.129 ; JDIMM2.148 169.65,88.74 169.9,88.98 v1(170.59,88.98) 170.92,88.98 171.15,88.75 JDIMM2.154 ; v1(155.61,89.61) 155.16,89.61 ; JDIMM4.124 161.85,75.92 162.16,76.23 v1(162.72,76.23) 163.35,75.6 JDIMM4.130 ; v1(164.75,76.23) 164.85,76.13 JDIMM4.136 ; JDIMM2.130 163.15,88.55 v1(162.72,88.98) 161.89,88.98 161.65,88.74 JDIMM2.124 ; v1(138.78,64.6) 139.1,64.92 JDIMM4.33 ; v1(160.18,77.5) 158.9,77.5 158.4,77.99 JDIMM2.111 ; v1(160.18,77.5) 160.18,77.88 159.9,78.16 JDIMM2.117 ; JDIMM2.118 160.15,88.95 v1(160.18,88.98) ; JDIMM2.141 165.9,77.81 165.59,77.5 v1(164.75,77.5) 164.4,77.85 JDIMM2.135 ; v1(164.75,88.98) 164.65,88.88 JDIMM2.136 ; JDIMM2.147 169.4,78.01 168.89,77.5 v1(168.56,77.5) ; JDIMM4.160 172.85,75.44 v1(172.5,75.8) ; v1(157.77,89.61) 158.21,89.61 158.65,89.17 JDIMM2.112
  TOP w0.356: PC820.1 PR440.2
  TOP w0.381: v1(105.76,95.46) 105.63,95.46 105.05,94.87 PC820.1
  IN10 w0.381: v1(105.76,95.46) 105.89,95.46 107.33,94.01 v1(107.87,94.01) 108.55,94.69 110.97,94.69 115.67,99.39 v1(123.67,99.39)
  BOTTOM w0.178: JDIMM1.33 140.57,88.51 141.07,89.01 141.07,89.64
  BOTTOM w0.254: JDIMM3.178 179.05,64.99 178.66,64.6 ; JDIMM1.141 167.57,88.81 167.74,88.98 v1(168.56,88.98) ; JDIMM3.241 194.8,76.46 194.34,76.91 v1(193.71,76.91) ; 173.45,64.62 173.6,64.62 173.96,64.98 174.34,64.98 174.55,65.19 JDIMM3.160 ; v1(167.86,64.6) 168.05,64.78 JDIMM3.142 ; v1(183.29,76.91) 184.06,76.91 184.3,76.67 JDIMM3.199 ; v1(160.18,88.98) 160.07,88.87 JDIMM1.111 ; JDIMM1.135 166.07,88.71 166.34,88.98 v1(166.66,88.98) ; JDIMM1.159 174.07,88.62 173.58,89.11 172.63,89.11 v1(172.5,88.98) 172.57,88.91 JDIMM1.153 ; JDIMM3.148 171.55,65.04 171.1,64.6 ; v1(150.27,89.61) 150.85,89.61 151.07,89.39 JDIMM1.75 ; v1(170.59,88.98) 171.07,88.5 JDIMM1.147 ; JDIMM1.129 164.57,88.8 v1(164.75,88.98) ; JDIMM3.220 189.55,64.82 v1(189.33,64.6) ; v1(162.02,64.6) 162.02,65.02 162.05,65.04 JDIMM3.118 ; JDIMM1.241 194.57,88.85 194.28,89.14 194.28,89.87 ; v1(135.73,64.65) 135.55,64.83 JDIMM3.12 ; v1(145.85,64.6) 146.05,64.8 JDIMM3.54 ; JDIMM3.136 166.55,65.04 166.35,64.84 v1(166.1,64.6) ; v1(183.29,89.61) 183.74,89.61 184.07,89.28 JDIMM1.199 ; v1(178.09,76.91) 178.59,76.91 178.82,77.14 JDIMM1.178 ; JDIMM3.130 165.05,65.04 v1(164.6,64.6) ; v1(174.4,76.51) 174.38,76.48 174.1,76.48 173.9,76.28 173.9,75.7 174.3,75.29 JDIMM3.159 ; JDIMM1.123 163.07,88.63 v1(162.72,88.98) 161.77,88.98 161.57,88.78 JDIMM1.117 ; v1(161.01,64.6) 160.75,64.6 160.55,64.8 JDIMM3.112 ; v1(174.4,90.38) 174.47,90.38 175.07,89.77 JDIMM1.163 ; 172.6,64.6 173.05,65.04 JDIMM3.154 ; JDIMM3.33 140.8,75.95 141.13,76.28 141.13,76.66 140.88,76.91 v1(140.37,76.91) ; v1(146.21,77.55) 145.82,77.94 JDIMM1.54 ; v1(136.18,76.91) 135.67,76.91 135.32,77.26 JDIMM1.12 ; v1(150.27,76.91) 150.91,76.91 151.3,76.52 JDIMM3.75 ; v1(188.5,76.91) 189.14,76.91 189.32,77.1 JDIMM1.220 ; v1(156.31,64.6) 156.55,64.84 JDIMM3.96 ; JDIMM3.124 163.55,65.04 v1(163.1,64.6) ; JDIMM1.96 156.32,77.22 155.96,76.86 v1(155.61,76.86)
  BOTTOM w0.305: JDIMM1.112 160.32,77.64 v1(160.18,77.5) ; v1(170.59,77.55) 171.32,78.28 JDIMM1.148 ; v1(164.75,76.23) 164.8,76.18 JDIMM3.129 ; v1(174.4,76.51) 174.43,76.48 174.84,76.48 175.3,76.02 JDIMM3.163 ; JDIMM1.136 166.32,77.84 v1(166.66,77.5) ; JDIMM3.117 161.8,76 162.03,76.23 v1(162.72,76.23) 163.3,75.65 JDIMM3.123 ; v1(160.18,76.86) 160.61,76.86 160.81,76.66 160.81,75.9 160.3,75.38 JDIMM3.111 ; JDIMM1.142 167.82,78.24 v1(168.56,77.5) ; JDIMM3.135 166.3,75.87 v1(166.66,76.23) 167.47,76.23 167.8,75.9 JDIMM3.141 ; v1(170.59,76.28) 171.1,76.28 171.3,76.08 JDIMM3.147 ; JDIMM1.160 174.32,78.43 173.44,77.55 v1(172.5,77.55) 172.82,77.87 JDIMM1.154 ; v1(164.75,77.5) 164.82,77.57 JDIMM1.130 ; JDIMM3.153 172.8,75.5 v1(172.5,75.8) ; JDIMM1.118 161.82,77.82 162.14,77.5 v1(162.72,77.5) 163.05,77.5 163.32,77.77 JDIMM1.124
  BOTTOM w0.457: R84.2 161.77,62.94 ; R93.2 169.39,62.82 ; R89.2 165.96,90.25
  vias: v1(120.11,70.56) v1(120.49,68.02) v1(120.75,69.29) v1(121.13,70.56) v1(121.38,68.02) v1(122.02,70.56) v1(122.02,69.29) v1(122.27,68.02) v1(123.03,70.56) v1(123.16,69.29) v1(123.16,68.02) v1(123.92,70.56) v1(124.25,69.29) v1(124.25,68.02) v1(124.94,70.56) v1(125.03,69.3) v1(125.01,68.04) v1(125.8,69.32) v1(125.8,68.05) v1(126.61,69.32) v1(126.61,68.05) v1(126.66,70.26) v1(127.43,70.29) v1(127.38,69.35) v1(127.38,68.08) v1(132.11,89.74) v1(132.11,76.91) v1(136.18,89.61) v1(138.34,89.61) v1(139.8,63.71) v1(140.37,89.61) v1(141.32,63.53) v1(142.27,89.61) v1(142.27,76.91) v1(142.59,63.53) v1(144.37,63.53) v1(145.64,63.53) v1(146.21,89.61) v1(147.42,63.53) v1(148.37,89.61) v1(148.69,63.53) v1(150.46,63.53) v1(151.73,63.53) v1(152.18,89.61) v1(153.51,63.53) v1(154.78,63.53) v1(156.56,63.53) v1(157.83,63.53) v1(159.61,63.53) v1(160.88,63.53) v1(162.48,63.53) v1(162.72,89.61) v1(162.72,76.86) v1(163.75,63.53) v1(165.7,63.53) v1(166.66,89.61) v1(166.66,76.86) v1(166.97,63.53) v1(168.56,89.61) v1(168.56,76.86) v1(168.56,76.23) v1(170.59,89.61) v1(170.59,76.91) v1(171.8,63.53) v1(172.5,89.61) v1(173.07,63.53) v1(176.63,63.53) v1(177.9,63.53) v1(178.09,89.61) v1(179.74,89.61) v1(179.74,76.91) v1(179.67,63.53) v1(180.94,63.53) v1(181.39,89.61) v1(181.39,76.91) v1(182.21,63.53) v1(183.99,63.53) v1(184.94,89.61) v1(184.94,76.91) v1(185.26,63.53) v1(186.6,76.91) v1(187.04,63.53) v1(188.31,63.53) v1(188.5,89.61) v1(190.09,63.53) v1(190.15,89.61) v1(191.36,63.53) v1(191.8,89.61) v1(193.14,63.53) v1(193.71,89.61) v1(194.41,63.53) v1(195.3,63.53) v2(169.64,96.6)
+1.2VDDQ: length 33.8
  TOP w0.254: v1(109.44,91.85) 109.66,91.63 PU401.5 ; PR441.2 v1(103.22,91.77)
  TOP w0.305: 112.95,89.92 112.92,89.89 PU401.19
  IN03 w0.381: v1(109.44,91.85) 114.45,91.85 117.7,88.6 123.29,88.6 124.56,87.33 124.56,82.63 v1(122.65,80.72)
  IN10 w0.381: v1(103.22,91.77) 103.52,91.77 104.16,92.41 108.55,92.41 109.11,91.85 v1(109.44,91.85)
  vias: v1(113.13,90.5) v1(113.76,90.5) v2(113.38,89.97)
+1.05V_DGPU_PGOOD: length 229.8
  TOP w0.097: PR722.1 v1(219.93,165.18) ; D70.1 289.15,71.1 v1(289.15,70.98) 289.15,70.82 289.56,70.41 D51.2
  IN03 w0.091: v1(289.15,70.98) 292.29,70.98 292.58,70.69 292.58,69.42 292.96,69.04 295.12,69.04 295.75,69.68 295.75,73.36 294.99,74.12 294.99,81.35 295.76,82.12 v1(298.55,82.12)
  IN08 w0.091: v1(289.15,70.98) 288.64,71.48 288.64,72.34 287.88,73.1 284.45,73.1 283.05,71.71 280.26,71.71 279.5,70.95 279.5,68.66 279.12,68.28 276.97,68.28 276.33,68.92 276.33,70.83 276.96,71.45 276.96,74.9 276.21,75.64 274.8,75.64 273.91,74.76 273.78,74.76 272.26,73.23 265.4,73.23 263.49,75.14 259.18,75.14 258.92,75.39 253.46,75.39 251.63,73.56 250.74,73.56 249.52,72.34 244.44,72.34 244.32,72.22 241.14,72.22 240.89,72.47 238.48,72.47 232.76,78.18 221.97,78.18 221.71,78.44 216,78.44 212.66,81.77 212.66,93.84 211.56,94.94 211.56,101.95 213.22,103.62 216.68,103.62 217.92,104.86 217.92,107.12 217.7,107.34 217.7,111.15 216.12,112.73 216.12,115.65 216.38,115.9 216.38,117.61 217.66,118.89 220.38,118.89 220.57,119.08 220.57,120.86 220.82,121.11 221.2,121.11 222.22,122.13 222.22,122.51 221.86,122.86 216.91,122.86 211.96,127.82 211.96,146.21 212.56,146.8 212.56,151.08 212.06,151.57 212.06,155.15 213.2,156.29 217.77,156.29 218.92,157.43 218.92,164.16 v1(219.93,165.18)
+1.8V: length 238.6
  TOP w0.457: v1(290.67,24.65) R284.2
  IN03 w0.508: v1(272.51,25.86) 269.97,25.86 268.07,27.77 268.07,34.5 267.18,35.39 267.18,39.83 264.89,42.12 v1(264.89,42.75)
  IN05 w0.508: v1(116.56,41.1) 115.92,40.47 115.92,39.2 116.17,38.94 116.17,38.3 115.76,37.88 113.32,37.88 110.89,35.45 100.8,35.45 97.08,39.18 97.08,40.26 92.55,44.78 89.76,44.78 88.87,45.67 v1(86.33,45.67)
  IN08 w0.508: v1(264.89,42.75) 263.49,44.15 260.82,44.15 256.5,39.83 253.92,39.83 253.16,40.59 214.34,40.59 211.76,43.18 203.55,43.18 201.22,40.85 191.61,40.85 189.07,43.39 170.15,43.39 168.5,45.03 118.99,45.03 116.56,42.6 v1(116.56,41.1) ; v1(272.51,25.86) 274.29,24.08 288.51,24.08 289.08,24.65 v1(290.67,24.65)
  vias: v1(85.57,48.52) v1(86.08,58.25) v1(86.08,57.61) v1(86.2,48.52) v1(86.84,58.25) v1(86.84,57.61) v1(86.84,48.52) v1(87.6,48.52) v2(84.81,48.47)
+1.8V_AON: length 824.9
  TOP w0.254: R2152.1 242.11,108 v1(242.46,107.65) ; R990.1 244.32,105.46 244.8,105.95 245.81,105.95 245.86,105.9 ; R987.1 246.22,100.46 246.6,100.84 246.6,101.81 246.35,102.06 246.35,103.58 246.86,104.09 246.86,105.36 248,106.51 248,107.39 v1(248.25,107.65) 248.38,107.52 R986.1 249.07,107.09 249.27,106.89 250.97,106.89 252.19,108.11 R983.2 252.7,108.97 252.7,112.48 251.56,113.62 251.05,113.62 250.94,113.51 249,113.51 248.76,113.74 246.22,113.74 245.66,114.3 R1002.1 ; v1(66.77,81.99) 66.14,81.36 R993.1 ; 204.19,127.71 203.8,127.33 202.23,127.33 R995.1 ; 204.19,127.71 204.57,127.33 205.07,127.33 205.48,127.74 207.16,127.74 207.56,127.33 R2264.2 ; 204.19,127.71 204.19,128.22 204.69,128.73 205.46,128.73 205.76,128.43 207.92,128.43 209.27,127.08 212.69,127.08 215.49,124.29 219.3,124.29 219.55,124.03 219.55,122.89 ; R2150.1 R2154.1 239.29,107.34 239.67,106.96 v1(239.67,106.81) ; C1339.1 303.58,73.61 303.77,73.81 U62.5 ; 245.86,105.9 245.86,107.04 R980.1 ; 245.86,105.9 v1(245.86,105.9) ; R982.1 244.06,108.77 Q93.2 244.06,108.03 v1(244.32,107.78) ; U63.5 303.7,70.11 C1333.1 ; R1016.1 v1(68.04,75.64)
  TOP w0.305: R2183.1 276.37,73.16 275.94,72.72 272.51,72.72 270.99,74.25 270.99,77.68 272.38,79.07 v2(280.89,79.07) 284.58,79.07 285.47,78.18 289.53,78.18 290.04,78.69 290.04,80.47 290.7,81.13 298.9,81.13 v1(299.18,80.85)
  TOP w0.356: C1333.1 v1(303.7,68.61) ; R796.1 R999.1 248.38,107.78 v1(248.25,107.65) ; v1(218.49,117.21) 218.49,117.03 219.17,116.35 R962.1 ; C1339.1 v1(304.26,73.23) ; v1(300.83,196.04) 298.67,198.2 297.28,198.2 v1(296.64,197.56)
  IN03 w0.305: v1(248.25,107.65) 247.75,108.16 246.61,108.16 v1(246.57,108.19) ; v1(68.04,75.64) 68.68,76.28 70.96,76.28 73.63,78.95 84.68,78.95 85.44,79.71 92.93,79.71 96.36,76.28 97.76,76.28 99.66,74.37 114.4,74.37 114.9,74.88 202.15,74.88 202.66,74.37 215.49,74.37 v1(215.74,74.63)
  IN03 w0.356: v1(211.55,193.88) 210.05,195.38 v1(206.73,195.38) ; v1(299.18,80.85) 299.94,81.61 299.94,82.38 299.56,82.76 289.28,82.76 285.59,86.44 v1(280.13,86.44) ; v1(246.57,108.19) 244.73,108.19 v1(244.32,107.78) 244.19,107.65 v1(242.46,107.65) 241.14,107.65 240.3,106.81 v1(239.67,106.81) 239.67,107.09 238.6,108.16 233.01,108.16 231.36,109.81 231.36,112.47 229.46,114.38 226.54,114.38 224.63,112.47 218.92,112.47 218.54,112.86 218.54,113.62 218.03,114.13 218.03,115.9 218.49,116.36 v1(218.49,117.21)
  IN03 w0.508: v1(220.44,121.75) 219.68,121.75 219.17,121.24 219.17,118.7 218.49,118.02 v1(218.49,117.21)
  IN05 w0.356: v1(206.73,195.38) 206.73,194.93 208.38,193.28 208.38,192.1 210.8,189.68 210.8,173.82 209.14,172.16 209.14,168.61 208.38,167.85 208.38,165.43 207.74,164.8 207.74,160.1 207.11,159.46 207.11,152.86 207.68,152.29 209.2,152.29 211.48,150.01 v1(212.13,150.01)
  IN08 w0.356: v1(303.7,68.61) 304.26,69.17 v1(304.26,73.23) ; v1(212.13,150.01) 212,149.88 212,147.09 209.52,144.61 209.52,127.84 208.38,126.7 208.38,125.38 211.37,122.38 v1(220.44,122.38) ; v1(218.49,117.21) 218.49,117.31 217.85,116.68 217.85,114.07 218.54,113.39 218.54,112.6 219.43,111.71 219.43,103.71 217.52,101.81 214.14,101.81 213.81,101.48 213.81,100.18 213.02,99.39 213.02,97.09 213.46,96.66 213.46,95.58 214.98,94.06 214.98,91.9 215.62,91.27 215.62,84.66 220.06,80.22 v1(220.44,80.22) 221.08,80.22 222.98,82.12 225.52,82.12 227.93,79.71 239.49,79.71 240.76,78.44 247.24,78.44 247.75,77.93 251.81,77.93 252.57,78.69 256.89,78.69 258.8,76.79 269.97,76.79 271.37,75.39 272.51,75.39 274.04,76.91 276.8,76.91 278.1,75.62 278.1,69.68 v1(277.85,69.42) ; v1(66.77,81.99) 67.28,81.49 67.28,79.58 66.9,79.2 66.9,77.3 68.04,76.15 v1(68.04,75.64)
  IN10 w0.356: v1(281.66,183.59) 278.61,183.59 276.75,185.45 272.82,185.45 271.24,187.02 219.17,187.02 212.31,193.88 v1(211.55,193.88) ; v1(309.72,108.16) 310.28,107.6 310.28,98.56 309.29,97.56 309.29,94.11 309.85,93.55 309.85,83.14 v1(307.69,80.98)
  BOTTOM w0.254: v1(309.72,108.16) 309.47,108.41 PR3551.1 ; 227.93,122.76 227.93,125.23 R2256.1 ; 227.93,122.76 230.22,122.76 230.86,123.4 230.86,125.48 R2255.1 R2254.1 ; 227.93,122.76 222.73,122.76 ; R1000.1 R975.1 246.73,108.34 v1(246.57,108.19) ; v1(244.32,107.78) 244.32,107.54 245.86,106 v1(245.86,105.9) ; v1(300.83,196.04) 301.11,195.77 PR32.2 ; v1(218.49,117.21) 218.49,117.31 218.88,117.71 222.88,117.71 R2251.1 ; G2.BB14 242.99,122.27 243.25,122 v3(243.25,121.49) ; G2.BC14 v3(242.49,121.97) ; R977.1 R974.1 242.84,108.84 242.46,108.46 v1(242.46,107.65) ; v1(296.64,197.56) 297.28,196.93 297.92,196.93 PR27.2 ; v1(206.73,195.38) 206.39,195.71 R2271.1
  BOTTOM w0.3: G2.BA10 v3(243.29,119.17)
  BOTTOM w0.305: 305.4,79.71 305.02,80.09 301.85,80.09 300.83,81.11 299.44,81.11 v1(299.18,80.85) ; 305.4,79.71 306.42,79.71 v1(307.69,80.98) ; 305.4,79.71 305.4,78.06 306.55,76.91 306.55,75.52 v1(304.26,73.23)
  BOTTOM w0.356: 284.83,85.17 284.83,84.03 ; 284.83,85.17 284.83,86.19 284.58,86.44 U2021.3 ; 284.83,85.17 U2021.7 ; 284.83,84.03 284.96,83.9 U2021.8 ; 284.83,84.03 284.83,83.26 284.45,82.88 281.15,82.88 280.82,83.21 R944.2 ; v1(215.74,74.63) 215.74,76.03 218.23,78.51 218.23,79.53 218.92,80.22 v1(220.44,80.22) ; v1(277.85,69.42) 277.85,69.17 277.08,68.41 276.42,68.41 275.43,67.42 275.43,63.83 278.61,60.66 289.91,60.66 294.74,55.83 299.69,55.83 300.71,56.85 302.48,56.85 304.01,58.37 304.01,68.28 303.7,68.58 v1(303.7,68.61) ; v1(296.64,197.56) 295.93,197.56 291.1,192.74 PR3561.1 281.86,183.8 v1(281.66,183.59)
  BOTTOM w0.508: v1(280.13,86.44) 280.56,86.87 C1402.1 C1401.1 282.11,86.87 282.54,86.44 U2021.3
  vias: v1(221.08,122.38) v1(221.08,121.75) v1(221.71,122.38)
+1.8V_MAIN: length 180.7
  TOP w0.254: v1(217.43,119.33) 217.98,118.78 217.98,116.46 218.41,116.03 218.41,114.2 R963.2 ; R2267.2 288.59,169.45 v1(288.26,169.12)
  IN03 w0.356: v1(221.08,124.03) 219.43,124.03 218.03,122.63 218.03,120.35 217.43,119.75 v1(217.43,119.33)
  IN08 w0.356: v1(212.69,132.62) 212.69,145.88 213.33,146.51 v1(213.33,150.07)
  IN10 w0.356: v1(288.26,169.12) 288.77,169.62 288.77,171.4 290.29,172.93 290.29,176.74 286.99,180.04 286.99,181.05 285.72,182.32 283.38,182.32 282.75,182.96 278.23,182.96 276.5,184.69 272.69,184.69 270.99,186.39 214.35,186.39 213.2,185.25 213.2,183.21 211.68,181.69 211.68,176.15 213.25,174.58 217.14,174.58 222.22,169.5 222.22,155.4 221.2,154.38 220.06,154.38 219.3,155.15 213.58,155.15 213.2,154.77 213.2,150.19 v1(213.33,150.07)
  BOTTOM w0.203: v3(243.24,130.42) 242.99,130.67 G2.BB26 242.59,130.37 v3(242.49,130.37)
  BOTTOM w0.254: v3(242.49,133.77) G2.BC30 ; G2.BD30 v3(241.79,133.77) ; G2.BC26 v3(242.49,130.37) ; G2.BC29 242.19,132.77 v3(242.49,132.47) ; v3(241.79,131.67) G2.BD27 ; G2.BB27 243.14,131.62 v3(243.24,131.62) ; G2.BC32 v3(242.49,134.57) ; v3(242.49,131.67) G2.BC27 ; G2.BB32 243.13,134.62 v3(243.24,134.62)
  BOTTOM w0.3: G2.BB29 243.14,132.52 v3(243.24,132.52)
  BOTTOM w0.356: C677.1 v1(227.68,128.98) ; C676.1 v1(223.87,128.98)
  vias: v1(213.33,132.62) v1(214.09,132.62) v1(214.85,132.62) v1(215.49,132.62) v1(216.12,132.62) v1(221.71,124.03) v1(222.35,124.03) v2(221.97,123.5)
+1.8V_SW:
  vias: v1(132.43,125.68) v1(132.43,124.92) v1(133.07,127.21) v1(133.07,126.44) v1(133.07,125.68) v1(133.07,124.92) v1(133.7,125.05) v1(133.83,127.21) v1(133.83,126.44) v1(133.83,125.68) v1(206.34,123.65) v1(206.34,123.02) v1(206.98,123.65) v1(206.98,123.02) v2(132.18,126.44)
+1.8V_SW_PGOOD: length 50.7
  TOP w0.097: D2007.2 300.8,85.33 300.71,85.42 299.44,85.42 298.67,84.66 298.67,84.28 296.26,81.87 290.93,81.87 289.66,80.6 289.66,78.82 289.4,78.57 285.59,78.57 284.63,79.53 271.7,79.53 v2(270.61,78.44) 270.61,74.12 272.38,72.34 276.83,72.34 277.29,72.8 R2183.2 PC15.1 277.21,74.46 PU7.B2
+1.8VA_AUD: length 7.6
  TOP w0.203: C300.2 289,28.12 289.4,28.53 v1(289.4,28.65) 289.4,29.06 289.13,29.33 U7.24
  TOP w0.356: v2(290.37,25.96) 290.28,26.05 R284.1 289,26.2 C301.2 C300.2
  BOTTOM w0.457: C322.2 C323.1 289.53,28.78 v1(289.4,28.65)
+1.8VALW_PCH: length 4
  TOP w0.457: C547.2 221.24,48.72 220.89,49.08 v2(220.89,49.36) 220.89,49.97 221.16,50.24 R290.2
+1.8VP: length 9.7
  BOTTOM w0.254: PR3458.2 126.48,132.38 126.53,132.33 PR3459.1 127.73,131.61 127.73,127.71 126.33,126.32 126.33,124.41
  vias: v1(85.57,43.51) v1(86.33,43.51) v1(87.09,43.51) v1(120.05,123.64) v1(120.05,122.88) v1(120.05,122.25) v1(120.05,121.61) v1(120.75,123.65) v1(120.75,122.89) v1(120.75,122.25) v1(120.75,121.62) v2(85.31,41.99)
+1.55V_DGPU_PGOOD: length 29.1
  TOP w0.097: v1(298.55,74.76) 297.3,74.76 296.13,75.93 296.13,76.09 295.94,76.28 294.61,76.28 292.58,74.25 v2(291.94,74.25) 291.23,74.25 R1007.1
  IN08 w0.091: v1(301.59,85.8) 301.34,85.8 301.09,85.55 301.09,79.84 300.2,78.95 300.2,76.41 v1(298.55,74.76)
  BOTTOM w0.097: PR704.2 302.1,86.31 v1(301.59,85.8)
+1.55VG:
  vias: v1(281.27,101.25) v1(281.27,100.41) v1(281.27,99.65) v1(281.27,98.89) v1(281.27,98.12) v1(281.27,97.49) v1(281.27,96.73) v1(281.27,95.96) v1(281.96,101.25) v1(281.96,100.41) v1(281.96,99.65) v1(281.96,98.89) v1(281.96,98.12) v1(281.96,97.49) v1(281.96,96.73) v1(281.96,95.96) v1(282.67,101.25) v1(282.67,100.41) v1(282.67,99.65) v1(282.67,98.89) v1(282.67,98.12) v1(282.67,97.49) v1(282.67,96.73) v1(282.67,95.96) v1(283.03,95.33) v1(283.03,94.69) v1(283.03,93.93) v1(283.03,93.17) v1(283.03,92.41) v1(283.41,96.73) v1(283.41,96.09) v1(283.69,101.17) v1(283.69,100.54) v1(283.66,95.33) v1(283.66,94.69) v1(283.66,93.93) v1(283.66,93.17) v1(283.66,92.41) v1(284.04,96.73) v1(284.04,96.09) v1(284.32,101.17) v1(284.32,100.54) v1(285.08,101.17) v1(285.08,100.54) v1(285.21,102.31) v2(279.12,99.39)
+1.55VSG: length 663.4
  TOP w0.114: 268.57,167.14 268.89,167.14 ; 269.14,166.91 269.14,164.09 ; 277.97,165.56 278.61,165.56 ; 260.12,164.11 260.12,164.51 260.12,165.31 ; 277.14,164.21 277.14,164.51 ; 270.17,167.14 271.29,167.14 ; 252.12,164.21 252.12,164.51 ; 276.45,165.56 277.08,165.56 ; 276.89,164.76 276.57,164.76 ; 270.17,167.96 270.49,167.96
  TOP w0.127: 252.92,164.51 252.92,164.19 ; 252.92,165.79 252.92,166.11 ; 241.84,164.76 241.51,164.76 ; 252.1,177.31 252.1,176.99 252.09,176.97 ; 233.27,165.43 233.39,165.55 234.79,165.55 234.79,165.56 ; 252.12,174.5 252.12,175.8 ; 277.93,165.79 277.93,166.11 ; 234.07,168.51 234.07,168.19 ; 233.84,167.15 233.47,167.15 ; 241.51,165.55 241.84,165.55 ; 242.07,164.51 242.07,164.19 ; 259.55,166.36 259.87,166.36 ; 277.12,166.11 277.12,165.79 ; 261.15,165.55 261.47,165.55 ; 269.12,168.51 269.12,168.19 ; 234.87,166.91 234.87,166.59 ; 260.1,166.91 260.1,166.59 ; 251.55,175.95 251.87,175.95 ; 260.92,166.59 260.92,167.81 ; 242.07,166.11 242.07,165.79 ; 269.93,168.19 269.93,168.51 ; 251.87,177.54 251.55,177.54 ; 261.15,166.36 261.47,166.36 ; 268.56,167.96 268.89,167.96 ; 253.95,175.95 254.27,175.95 ; 251.87,164.76 251.55,164.76 ; 233.27,167.71 233.27,167.39 ; 278.16,164.76 278.49,164.76 ; 277.93,164.51 277.93,164.19 ; 251.55,176.74 251.87,176.74 ; 253.95,175.14 254.28,175.14 ; 242.88,164.51 242.88,164.19 ; 252.9,174.6 252.9,174.91 ; 243.11,164.75 243.44,164.75 ; 253.15,165.55 253.47,165.55 ; 253.15,164.75 253.47,164.75 ; 269.93,166.91 269.93,166.59 ; 234.64,166.34 233.38,166.34 233.27,166.45 ; 235.11,167.95 235.43,167.95 ; 242.88,165.79 242.88,166.11 ; 259.87,165.56 259.55,165.56 ; 260.92,165.31 260.92,164.08 ; 252.92,177.31 252.92,176.99 ; 243.11,165.55 243.44,165.55 ; 251.55,165.55 251.87,165.55 ; 235.11,168.74 235.44,168.74
  TOP w0.254: C2521.1 267.87,173.21 v3(267.93,173.15) ; C2570.1 291.62,140.11 v3(291.43,139.92) ; v3(270.33,171.55) 270.39,171.48 C2531.1 ; v3(291.3,148.94) 291.17,149.06 C2560.1 ; C2530.1 275.04,174.04 v3(275.13,173.95) ; v3(232.88,168.35) 232.66,168.56 C2453.1 ; v3(294.5,148.14) 294.45,148.19 C2557.1 ; R874.1 263.2,173.51 R2195.2 262.54,173.52 v3(262.11,173.95) ; v3(276.73,171.55) 275.88,171.55 C2529.1 ; v3(288.1,145.74) 288.15,145.69 C2545.1 ; v3(299.43,121.88) 299.12,122.19 C2603.1 ; v3(236.08,168.35) 236.12,168.39 C2467.1 ; C2519.1 280.27,177.15 v3(279.13,177.15) ; v3(258.91,168.35) 258.9,168.34 C2492.1 ; C2471.1 237,166.36 236.59,165.95 v3(236.08,165.95) ; C2469.1 236.9,176.37 v3(236.88,176.35) ; v3(293.03,120.28) 293.03,118.53 C2614.1 ; v3(258.11,176.35) 258.03,176.27 C2498.1 ; v3(288.23,139.92) 287.75,140.4 C2580.1 ; v3(244.32,167.15) 244.38,167.08 C2461.1 ; v3(232.88,175.55) 232.35,176.08 C2455.1 C2449.1 ; v3(299.43,135.89) 298.92,135.38 C2588.1 ; C2516.1 267.6,164.83 v3(267.93,165.15) ; v3(289.03,136.72) 289.03,135.89 C2589.1 ; C2615.1 291.43,114.53 v3(291.43,113.89) ; R2198.2 295.83,145.46 v3(296.1,145.74) ; C2533.1 279.19,173.88 v3(279.13,173.95) ; C2470.1 235.36,171.47 v3(235.28,171.55) ; v3(262.11,175.55) 262.24,175.42 C2488.1 ; v3(232.88,173.15) 233.53,172.49 R2197.2 ; C2468.1 240.05,173.97 v3(240.08,173.95) ; C2553.1 296.88,156.96 v3(296.9,156.94) ; v3(300.1,145.74) 300.24,145.6 C2537.1 ; v3(232.88,173.95) 232.26,173.34 C2454.1 C2448.1 ; C2571.1 297.07,127.68 C2569.1 ; v3(291.3,145.74) 291.77,145.27 C2562.1 ; v3(288.1,156.94) 288.09,156.95 C2551.1 ; C2499.1 258.89,165.97 v3(258.91,165.95) ; v3(255.06,174.35) 255.11,174.3 C2490.1 ; v3(296.9,145.74) 297.62,145.01 C2538.1 ; C2575.1 296.58,140.36 v3(297.03,139.92) ; C2482.1 262.85,176.41 v3(262.11,177.15) ; C2556.1 297.16,152.61 v3(297.3,152.76) ; C2511.1 279.46,167.33 v3(279.28,167.15) ; C2552.1 293.13,157.97 v3(292.1,156.94) ; v3(292.23,139.91) 292.75,140.44 R2203.2 ; v3(297.43,117.73) 297.28,117.59 C2612.1 ; C2586.1 297.08,132.77 v3(297.03,132.72) ; v3(294.62,113.09) 294.58,113.14 C2613.1 ; v3(291.43,136.72) C2587.1 ; v3(289.7,156.94) 289.92,157.15 C2558.1 ; v3(288.9,148.94) 288.95,148.99 C2550.1 ; C2491.1 259.63,171.47 v3(259.71,171.55) ; v3(279.33,165.55) 279.48,165.4 C2525.1 ; v3(294.63,137.52) 294.53,137.42 C2564.1 ; v3(298.63,139.92) 299.53,140.82 C2573.1 ; C2497.1 253.32,171.53 v3(253.31,171.55) ; C2505.1 254.14,165.92 v3(254.11,165.95) ; v3(262.11,169.15) 262.17,169.21 C2489.1 263.36,168.97 C2478.1
  TOP w0.356: C2659.1 243.39,97.04 v3(243.47,97.12)
  TOP w0.381: C2648.1 261.59,95.48 v3(261.63,95.52) ; v3(246.87,96.72) 246.92,96.67 C2675.1 ; C2660.1 242.55,88.32 242.96,88.72 v3(243.67,88.72) ; v3(273.03,94.32) 273.22,94.13 C2623.1 ; v3(265.83,88.72) 265.88,88.67 C2649.1 ; v3(253.27,92.72) 251.15,92.72 250.9,92.98 C2667.1 ; C2601.1 300.37,110.55 v3(300.23,110.69) ; C2676.1 247,94.45 v3(246.87,94.32) ; v3(254.87,93.52) 255.18,93.52 255.9,92.8 C2670.1 ; C2679.1 247.77,86.42 v3(247.67,86.32) ; v3(250.72,88.32) 250.57,88.47 C2666.1 ; C2658.1 255.52,87.12 v3(254.87,87.12) ; v3(273.03,89.52) 273.69,90.17 R2205.2 ; C2640.1 273.53,87.12 v3(273.03,87.12) ; C2645.1 v3(269.83,94.32) ; v3(269.83,96.72) 269.81,96.75 C2643.1 ; v3(254.87,95.92) 255.08,95.7 C2671.1 ; C2625.1 270.53,91.22 v3(270.63,91.12) ; v3(273.03,88.72) 273.98,88.72 C2638.1 ; v3(261.63,97.12) 261.42,97.33 C2642.1 ; v3(243.67,85.52) 242.69,85.52 C2661.1 ; v3(243.67,89.52) 243.4,89.79 R2204.2
  IN03 w0.381: v3(246.07,92.72) 246.07,91.12 v3(246.07,91.12) v3(246.07,90.32) ; v3(270.33,170.75) v3(270.33,171.55) v3(270.33,172.35) ; v3(252.51,169.95) v3(252.51,169.15) ; v3(252.51,169.15) v3(253.31,169.15) ; v3(252.51,169.15) v3(251.71,169.15) ; v3(265.83,88.72) v3(265.03,89.52) ; v3(264.23,93.52) v3(263.43,93.52) v3(263.43,94.32) ; v3(265.03,87.12) v3(264.23,87.12) v3(264.23,86.32) ; v3(267.93,169.15) v3(268.73,169.15) v3(269.53,169.15)
  IN10 w0.356: v1(276.45,85.68) 276.7,85.93 279.88,85.93 281.66,84.15 293.59,84.15 295.24,85.8 298.29,85.8 299.94,87.46 306.04,87.46 v1(308.71,84.79)
  IN10 w0.381: v3(259.71,169.95) 259.71,169.95 v3(259.71,170.75) v3(259.71,171.55) ; v3(295.3,148.14) 295.3,148.14 v3(294.5,148.14) v3(293.7,148.14) 293.7,148.14 v3(292.9,148.14) ; v3(295.42,113.08) 295.42,113.09 v3(294.62,113.09) v3(293.82,113.09) v3(293.03,113.09) ; v3(292.1,145.74) v3(292.1,146.54) v3(292.1,147.34) ; v3(241.68,169.15) 241.68,169.15 v3(242.48,169.15) v3(242.48,168.35) ; v3(276.73,169.15) v3(277.53,169.15) v3(277.53,168.35) ; v3(260.51,169.15) v3(261.31,169.15) v3(262.11,169.15) ; v3(270.63,91.12) v3(270.63,91.92) v3(270.63,92.72) ; v3(273.03,93.52) v3(272.23,93.52) v3(271.43,93.52) ; v3(270.63,90.32) v3(271.43,89.52) ; v3(292.23,131.12) v3(292.23,130.32) ; v3(291.43,112.29) 292.22,112.29 v3(292.23,112.29) v3(292.23,111.49) 292.23,110.69 v3(292.23,110.69) ; v3(276.73,166.75) v3(277.53,166.75)
  IN10 w0.4: v3(259.71,171.55) v3(259.71,172.35)
  BOTTOM w0.25: G2.K15 v3(264.99,123.27) 264.69,122.97 G2.L15 ; G2.K30 v3(264.99,133.77) 264.69,133.47 G2.L30 ; G2.L20 264.69,126.47 v3(264.99,126.17) G2.K20 ; G2.L21 264.69,127.17 v3(264.99,127.47) G2.K21 ; G2.K29 v3(264.99,132.47)
  BOTTOM w0.254: v3(245.27,94.32) 245.67,93.92 U2026.M3 v3(245.27,93.52) U2026.L2 ; v3(246.07,91.12) U2026.H3 ; v3(251.67,96.72) U2026.R10 ; U2025.G14 295.63,121.28 295.63,120.89 U2025.G13 ; v3(264.99,121.17) 265.29,120.87 G2.K12 ; U2026.F3 v3(246.07,89.52) U2026.G4 v3(246.07,90.32) ; v3(247.67,88.72) U2026.E5 ; v3(243.67,89.52) U2026.G1 v3(244.47,89.52) U2026.G2 ; PR3422.2 310.23,92.15 308.71,90.63 v1(308.71,84.79) ; v3(263.59,119.77) G2.M10
  BOTTOM w0.3: G2.K38 v3(264.99,138.77) ; G2.K17 v3(264.99,124.07) ; v3(262.74,141.52) 262.74,141.62 G2.P42 ; v3(257.34,141.52) 257.34,141.62 G2.AA42 ; G2.K41 v3(264.99,140.87) ; v3(258.54,141.52) 258.54,141.62 G2.Y42 ; G2.M43 263.66,142.34 v3(263.66,142.2) ; G2.R42 261.54,141.62 v3(261.54,141.52) ; v3(259.44,141.52) 259.44,141.62 G2.V42
  BOTTOM w0.305: U60.D12 263.84,95.52 v3(264.24,95.92) 264.24,95.91 U60.D11 v3(265.03,95.12) U60.E10 265.43,94.72 v3(265.03,94.32) ; U60.B12 v3(264.23,96.72) ; v3(296.23,128.72) 295.83,129.12 U2024.L14 295.63,129.32 295.63,129.72 U2024.L13 ; v3(297.02,112.29) 296.63,112.68 U2025.F3 v3(296.22,113.09) U2025.G4 295.43,113.08 v3(295.42,113.08) 295.03,112.69 U2025.H3 v3(294.62,113.09) ; 295.6,155.64 295.6,155.84 ; 295.6,155.84 295.6,156.44 U2023.G14 295.7,156.54 v3(296.1,156.94) ; 295.6,155.84 U2023.G13 ; C2665.1 255.03,89.68 v3(254.87,89.52) 254.47,89.92 U2026.G14 254.27,90.12 253.87,90.12 U2026.G13 ; U2024.B14 288.63,129.12 v3(288.23,128.72) 288.27,128.67 C2565.1 ; U48.D11 253.71,175.15 v3(253.31,175.55) U48.D12 ; U60.G11 v3(264.23,93.52) U60.F12 ; v3(242.48,169.15) U2022.G13 v3(242.47,169.95) U2022.H12 ; v3(289.03,118.69) 289.43,118.29 U2025.R10 ; v3(267.93,166.75) U55.D1 ; U2026.F14 254.47,89.12 v3(254.87,88.72) 255.24,88.35 256.01,88.35 ; U2025.L2 292.62,111.88 v3(292.23,111.49) ; v3(270.33,170.75) 269.93,170.35 U55.H3 v3(270.33,169.95) U55.G4 ; v3(254.11,168.35) U48.N10 v3(254.11,167.55) U48.P11 v3(253.31,166.75) U48.P12 ; v3(288.1,147.34) U2023.T3 ; U48.T14 v3(250.91,165.15) ; U2025.T14 288.63,121.49 v3(288.23,121.89) 287.92,122.2 287.92,123.74 C2606.1 ; U2024.M3 296.62,137.92 v3(296.23,138.31) 296.23,138.32 U2024.L2 ; v3(296.22,121.88) 295.83,121.49 U2025.G14 ; U2022.B14 244.32,165.55 v3(244.32,165.55) 244.56,165.3 245.92,165.3 C2466.1 ; U2023.P12 v3(289.7,154.54) U2023.P11 290.1,154.14 v3(290.5,153.74) U2023.N10 ; U2024.H12 293.03,130.32 v3(293.03,130.32) U2024.G13 v3(292.23,130.32) 291.83,130.72 U2024.F12 ; v3(264.23,91.12) U60.K12 U60.L13 ; v3(277.53,173.95) U55.M12 v3(277.53,173.15) U55.L13 ; v3(244.08,177.15) 243.67,176.75 U2022.T14 ; U2023.B14 299.7,156.54 v3(299.3,156.94) ; U55.F12 v3(277.53,168.35) ; U55.F12 277.13,168.75 v3(277.53,169.15) U55.G13 277.53,169.95 v3(277.53,169.95) U55.H12 ; U55.F12 v3(276.73,169.15) U55.G11 ; U48.K12 v3(252.51,169.95) U48.L13 ; U2024.P12 298.63,131.12 v3(298.63,131.12) U2024.P11 ; U2022.P14 v3(244.08,175.55) ; v3(271.13,173.95) U55.N5 ; v3(279.13,173.15) U55.L14 278.55,172.57 278.1,172.57 U55.L13 ; v3(279.13,173.15) 278.73,173.55 U55.M14 v3(279.13,173.95) 279.38,174.2 280.81,174.2 C2527.1 ; v3(279.13,173.15) 280.17,173.15 280.2,173.12 281.01,173.12 C2528.1 ; U2024.M14 296.63,129.12 v3(297.03,128.72) 297.17,128.58 C2567.1 ; U2022.M14 v3(244.08,173.95) 244.12,173.91 245.93,173.91 C2473.1 ; U2022.G11 241.28,169.55 v3(241.68,169.15) U2022.F12 v3(242.48,168.35) ; U2025.B12 299.82,119.88 v3(299.42,120.28) ; U48.L13 v3(251.71,169.15) U48.L14 v3(250.91,169.15) U48.M14 v3(250.91,168.35) ; U48.L13 v3(252.51,169.15) 252.91,168.75 U48.M12 v3(253.31,169.15) U48.L11 ; U2025.P1 v3(289.83,110.69) ; U2024.D1 290.23,139.52 v3(289.83,139.92) ; v3(291.3,145.74) 291.7,146.14 U2023.M1 ; U2022.M3 v3(234.48,173.15) U2022.L2 ; U2022.D3 v3(234.48,167.55) ; v3(292.1,145.74) 292.5,146.14 U2023.L1 ; U2025.P3 290.63,113.09 v3(290.63,113.09) ; v3(261.83,85.52) U60.T14 ; U2024.F12 291.43,130.32 v3(291.43,130.32) ; U2024.F12 291.83,130.72 v3(292.23,131.12) U2024.G11 ; U2024.P11 v3(298.63,131.92) U2024.R10 ; U2024.P11 v3(297.83,131.92) U2024.N10 v3(297.03,132.72) ; U2025.M14 291.83,121.49 v3(291.43,121.89) ; v3(273.03,89.52) U60.L1 v3(272.23,89.52) ; v3(299.43,132.72) U2024.R10 ; U2024.R10 v3(298.63,132.72) ; v3(267.93,168.35) U55.F1 v3(267.93,169.15) U55.G1 ; U2023.P1 290.1,146.14 v3(289.7,145.74) ; U2025.M1 291.83,111.08 v3(291.43,110.69) ; U2023.L13 292.5,155.74 v3(292.1,155.34) U2023.M12 v3(292.1,154.54) U2023.L11 ; U2023.L13 v3(292.9,155.34) 293.3,154.94 U2023.K12 ; U2023.L13 v3(292.1,156.14) 292.1,156.14 U2023.L14 v3(292.1,156.94) ; U48.F14 v3(250.91,173.95) ; v3(294.63,131.12) U2024.K12 295.03,130.72 U2024.L13 ; U2024.L11 v3(296.23,131.92) ; U60.B1 v3(273.03,97.52) ; U2024.E10 291.03,132.32 v3(290.63,131.92) U2024.D11 v3(289.83,131.12) U2024.D12 ; v3(262.11,168.35) U48.M1 261.31,169.15 v3(261.31,169.15) ; v3(291.3,147.34) 291.7,147.74 U2023.M3 v3(292.1,147.34) U2023.L2 292.1,146.54 v3(292.1,146.54) ; U2024.T14 299.83,129.12 v3(300.23,128.72) ; U2025.L11 292.23,119.49 v3(292.23,119.49) U2025.M12 292.23,120.28 v3(292.23,120.29) 292.23,120.29 U2025.L13 ; U2025.L13 292.63,120.68 v3(293.03,120.28) U2025.K12 ; U2025.L13 292.23,121.09 v3(292.23,121.09) 292.63,121.48 U2025.L14 292.23,121.88 v3(292.23,121.89) ; U2026.N10 v3(251.67,95.12) 251.67,95.12 U2026.P11 v3(252.47,95.92) ; v3(297.03,130.32) 296.63,130.72 U2024.M12 v3(296.23,130.32) U2024.L13 ; C2627.1 261.69,88.58 v3(261.83,88.72) U60.M14 v3(261.83,89.52) ; v3(299.42,114.69) 299.03,114.29 U2025.C5 ; U60.F12 v3(263.43,93.52) U60.G13 ; U60.F12 v3(263.43,94.32) ; v3(261.83,89.52) U60.L14 262.43,90.12 262.83,90.12 U60.L13 ; v3(261.83,89.52) 261.77,89.58 C2626.1 ; U55.E10 275.53,167.95 v3(275.93,167.55) U55.D11 276.33,167.15 v3(276.73,166.75) ; v3(270.63,91.12) U60.K3 v3(270.63,90.32) U60.L4 ; 272.49,178.84 272.49,176.92 v3(271.93,176.35) 271.93,176.35 U55.R5 ; v3(259.71,175.55) 260.11,175.15 U48.D3 ; v3(242.48,166.75) U2022.D12 v3(241.68,166.75) U2022.D11 v3(240.88,167.55) U2022.E10 ; U55.L13 U55.K12 v3(276.73,171.55) ; U55.C5 v3(271.13,165.95) ; U60.P1 v3(273.03,87.12) 273.97,86.19 274.42,86.19 ; v3(232.88,166.75) 233.28,167.15 U2022.D1 ; v3(259.71,170.75) U48.K3 v3(259.71,169.95) U48.L4 ; v3(268.73,169.15) U55.G2 v3(269.53,169.15) U55.F3 ; U48.P14 v3(250.91,166.75) ; v3(294.62,119.49) 295.02,119.88 U2025.H12 295.83,120.68 ; U2024.K3 v3(295.43,137.52) 295.43,137.52 U2024.L4 ; v3(288.9,153.74) U2023.R10 ; U48.F3 259.71,173.15 v3(259.71,173.15) U48.G4 v3(259.71,172.35) U48.H3 v3(259.71,171.55) ; U2025.G13 295.83,120.68 ; 295.83,120.68 295.83,120.68 v3(296.22,120.29) ; U2025.L1 292.63,111.08 v3(292.23,110.69) ; U60.L13 v3(263.43,89.52) U60.M12 v3(263.43,88.72) ; v3(252.51,173.15) U48.G13 ; U48.G13 252.01,172.65 251.41,172.65 U48.G14 v3(250.91,173.15) ; U48.G13 U48.H12 v3(253.31,171.55) ; U2024.B12 v3(288.23,130.32) ; U2024.D14 290.23,129.12 v3(289.83,128.72) 290.3,128.25 C2590.1 ; v3(260.51,168.35) U48.M3 v3(260.51,169.15) U48.L2 v3(261.31,169.15) ; v3(297.02,121.88) 296.63,121.49 U2025.F14 ; U48.T12 252.91,165.55 v3(252.51,165.15) ; U2025.M3 291.83,112.68 v3(291.43,112.29) ; v3(288.1,155.34) U2023.T12 ; v3(299.42,113.09) U2025.B3 ; U55.M3 v3(269.53,173.15) 269.53,173.15 U55.L2 v3(268.73,173.15) 268.33,172.75 U55.L1 v3(267.93,173.15) ; v3(262.11,165.15) U48.T1 ; U2024.G4 293.03,137.52 v3(293.03,137.52) 293.03,137.52 293.43,137.91 U2024.H3 v3(293.83,137.52) ; v3(265.03,96.72) U60.C10 ; U2025.T1 288.63,111.08 v3(288.23,110.68) ; U2022.C10 v3(240.88,165.95) ; U2022.B12 v3(242.48,165.15) ; v3(271.13,168.35) U55.E5 ; U2025.D14 298.22,121.48 v3(297.82,121.88) ; U48.N5 v3(258.91,168.35) ; U2025.P14 289.83,121.88 v3(289.83,121.89) 289.83,123.75 C2611.1 ; v3(262.11,169.15) U48.L1 261.71,169.55 v3(261.31,169.15) ; v3(288.23,112.29) 288.62,112.68 U2025.T3 ; U55.B3 v3(270.33,165.95) ; v3(275.93,165.95) U55.C10 ; U2025.P12 289.83,119.49 v3(289.83,119.49) U2025.P11 v3(290.63,118.69) 291.03,118.29 U2025.N10 ; v3(294.5,148.14) U2023.H3 295.3,148.14 v3(295.3,148.14) U2023.G4 296.1,148.14 v3(296.1,148.14) U2023.F3 ; v3(260.51,176.35) U48.B3 ; v3(263.43,92.72) U60.H12 ; U2023.G11 v3(296.1,154.54) U2023.F12 v3(296.1,155.34) ; v3(267.93,165.15) U55.B1 ; U55.T3 269.93,176.75 v3(270.33,177.15) ; U2025.T12 v3(288.23,120.29) ; v3(262.11,166.75) U48.P1
  BOTTOM w0.356: v3(250.91,173.95) 250.86,173.99 C2494.1 ; v3(242.48,173.95) U2022.M12 v3(242.48,173.15) ; v3(244.08,177.15) 245.5,178.58 C2451.1 ; v3(297.82,121.88) 297.8,121.9 297.8,123.68 C2608.1 ; U2024.G14 292.63,129.12 v3(292.23,128.72) ; C2655.1 253.43,84.62 v3(253.28,84.76) 253.18,84.76 252.25,83.84 C2652.1 ; C2630.1 272.04,83.04 272.04,83.91 v1(272.46,84.33) 273.15,83.65 273.15,82.95 C2636.1 ; C2566.1 296.16,128.66 v3(296.23,128.72) ; U2024.F14 291.83,129.12 v3(291.43,128.72) ; 264.57,83.65 264.89,83.96 264.89,84.03 265.27,84.41 v1(265.27,84.53) ; v3(241.68,171.55) 242.07,171.95 U2022.K12 U2022.L13 ; U2024.K3 v3(294.63,137.52) ; C2480.1 262.84,176.42 v3(262.11,177.15) ; v3(279.13,177.15) 279.75,177.77 279.75,178.96 279.81,179.02 ; C2458.1 241.08,178.58 240.89,178.39 v3(240.89,177.88) ; v3(267.93,173.15) 267.52,173.55 266.1,173.55 C2507.1 ; U2024.L1 295.83,139.51 v3(296.23,139.11) 296.22,139.11 U2024.L2 ; v3(250.91,165.15) 250.77,165.01 C2493.1 ; v3(244.32,167.15) 244.33,167.16 C2472.1 ; v3(299.42,114.69) 300.17,115.44 302.09,115.44 ; C2664.1 257.64,88.35 C2657.1 256.01,88.35 ; C2500.1 250.85,166.81 v3(250.91,166.75)
  BOTTOM w0.381: U2026.T14 v3(254.87,97.52) 257.37,97.52 257.75,97.14 C2662.1 ; U2026.L13 v3(254.07,93.52) U2026.L14 v3(254.87,93.52) ; U2026.L13 v3(253.27,92.72) 252.87,92.32 U2026.K12 ; U2026.L13 v3(253.27,93.52) U2026.M12 v3(252.47,93.52) U2026.L11 ; v3(272.23,93.52) U60.G2 v3(271.43,93.52) U60.F3 ; U2025.D11 298.62,119.48 v3(298.62,119.49) 298.23,119.88 U2025.D12 ; U2026.G11 v3(251.67,89.52) ; U60.P3 v3(270.63,87.12) ; v3(288.1,145.74) U2023.T1 ; v3(252.47,95.92) U2026.P12 252.87,95.52 v3(253.27,95.12) ; U2026.C10 250.87,86.32 v3(250.87,86.32) ; U2024.B1 v3(288.23,139.92) ; U2024.M1 296.63,139.52 v3(297.03,139.92) 297.35,140.24 297.35,141.79 C2585.1 ; v3(235.28,171.55) U2022.K3 v3(235.28,172.35) U2022.L4 ; U2022.B1 v3(232.88,165.15) ; v3(254.11,173.15) U48.G11 ; U2024.F3 v3(292.23,138.32) U2024.G2 v3(292.23,139.12) U2024.G1 292.62,139.52 v3(292.23,139.91) ; U55.P1 v3(267.93,175.55) v1(267.01,175.55) ; U55.P3 269.93,175.15 v3(270.33,175.55) ; v3(299.43,135.89) 299.03,136.29 U2024.R5 ; v3(275.13,175.55) U55.R10 v3(275.93,175.55) U55.P11 ; U55.P12 276.73,175.55 v3(276.73,175.55) U55.P11 ; v3(244.08,173.15) U2022.L14 243.47,172.55 243.08,172.55 U2022.L13 v3(242.48,173.15) ; U2022.B3 v3(235.28,165.95) ; C2604.1 296.26,108.84 296.26,110.65 v3(296.23,110.69) U2025.G1 296.22,111.48 v3(296.22,111.49) 295.83,111.88 U2025.G2 ; U2026.B12 v3(253.27,86.32) ; v3(289.03,136.72) U2024.C5 ; U2026.T3 v3(245.27,97.52) ; v3(298.63,128.72) 298.23,129.12 U2024.P14 ; v3(232.88,168.35) U2022.F1 v3(233.68,169.15) 234.07,169.55 U2022.G2 v3(234.48,169.15) 234.88,168.75 U2022.F3 ; v3(273.03,94.32) U60.F1 ; U2023.C5 v3(299.3,149.74) 300.06,150.49 301.96,150.49 ; U2026.B1 v3(243.67,85.52) ; U55.L11 v3(275.93,173.15) ; C2668.1 241.86,88.76 243.63,88.76 v3(243.67,88.72) U2026.F1 ; v3(269.83,94.32) U60.E5 ; U55.F14 v3(279.33,168.75) ; v3(299.3,152.91) 298.9,153.31 U2023.C10 ; v3(258.91,173.95) U48.E5 v3(258.11,173.95) ; U60.T12 v3(264.23,86.32) ; U55.P11 v3(275.93,174.75) U55.N10 v3(275.13,173.95) ; C2665.1 257.89,89.68 R910.1 ; v3(296.1,156.94) 295.94,157.1 C2548.1 295.96,158.87 R867.1 ; U2025.K3 293.43,112.69 v3(293.82,113.09) ; U48.G1 v3(262.11,173.15) 262.11,173.15 U48.F1 ; v3(289.03,131.92) 289.43,132.32 U2024.C10 ; v3(236.08,165.95) U2022.C5 ; v3(254.11,165.95) U48.R10 ; C2592.1 296.37,141.78 296.37,140.06 v3(296.23,139.92) U2024.L1 ; U2026.B3 v3(246.07,86.32) ; v3(296.22,119.49) 296.62,119.88 U2025.F12 ; U2024.T12 v3(299.43,131.12) ; U2023.D12 v3(298.5,154.54) U2023.D11 298.1,154.14 v3(297.7,153.74) U2023.E10 v3(297.3,152.76) ; U60.R10 v3(265.83,87.12) ; U60.R10 v3(265.03,87.12) ; U60.R10 v3(265.83,86.32) ; U55.G14 v3(279.33,169.55) ; v3(240.08,173.95) U2022.N10 v3(240.88,174.75) 240.88,174.75 U2022.P11 ; C2646.1 259.03,95.8 259.3,95.52 v3(261.63,95.52) U60.D14 ; U2022.P1 v3(232.88,175.55) 232.46,175.14 C2464.1 ; U2026.D11 v3(252.47,87.12) 252.47,87.12 U2026.D12 ; U48.B12 v3(252.51,176.35) ; R897.1 C2605.1 296.08,122.03 v3(296.22,121.88) ; U2026.P3 246.07,95.12 v3(246.07,95.12) ; U48.P3 v3(259.71,167.55) ; v3(236.08,173.95) U2022.N5 ; U2023.B12 v3(300.1,154.54) ; U60.P14 v3(261.83,87.12) ; U2023.L4 v3(292.9,148.14) ; U60.R5 v3(269.03,86.32) ; v3(270.63,92.72) U60.G4 ; v3(276.73,176.35) U55.T12 ; U2022.L1 v3(232.88,173.15) 232.67,173.36 C2463.1 C2476.1 ; v3(250.91,176.35) U48.B14 ; v3(235.28,175.55) U2022.P3 ; U2023.D14 v3(297.7,156.94) 297.68,156.96 297.68,158.8 C2549.1 ; U2026.M1 v3(243.47,93.92) ; U2022.G4 v3(235.28,169.95) U2022.H3 v3(235.28,170.75) ; U60.G14 v3(261.63,93.12) ; v3(271.43,95.12) U60.D3 ; v3(240.08,176.35) U2022.R10 ; U2022.R10 v3(240.88,175.55) 240.88,175.55 U2022.P11 ; U2022.R10 240.48,175.95 v3(240.08,175.55) ; U2025.F1 v3(297.03,110.69) ; U60.M3 v3(271.43,89.52) U60.L2 v3(272.23,89.52) ; U60.B14 v3(261.63,97.12) 260.11,97.12 C2629.1 ; U2024.P1 v3(298.63,139.92) ; U2022.P11 v3(241.68,175.55) 241.68,175.55 U2022.P12 ; U55.T1 v3(267.93,177.15) 267.52,177.55 ; U2026.R5 v3(246.87,96.72) ; U55.D12 v3(277.53,166.75) ; v3(298.5,148.14) U2023.D3 ; U2023.B3 v3(299.3,148.14) ; v3(271.43,85.52) U60.T3 ; v3(297.03,136.72) U2024.N5 ; U55.B14 v3(279.33,165.55) 279.54,165.34 280.97,165.34 C2509.1 ; U2025.E10 v3(297.43,117.73) ; U2026.K3 v3(246.07,92.72) U2026.L4 ; C2546.1 298.44,143.88 298.44,145.67 v3(298.5,145.74) 298.1,146.14 U2023.D1 ; C2563.1 289.69,158.79 289.69,156.95 v3(289.7,156.94) U2023.P14 ; C2503.1 263.04,173.51 262.61,173.95 v3(262.11,173.95) U48.F1 ; R2217.1 C2502.1 248.91,173.15 v3(250.91,173.15) ; v3(269.83,96.72) U60.C5 ; U2022.E5 v3(236.08,168.35) ; C2669.1 255.74,85.5 255.73,85.49 254.9,85.49 v3(254.87,85.52) U2026.B14 ; U2025.G11 v3(296.23,118.69) ; C2593.1 300.77,109.19 300.23,109.73 v3(300.23,110.69) U2025.B1 ; C2555.1 296.75,143.88 296.75,145.09 v3(296.1,145.74) 295.7,146.14 U2023.G1 U2023.G2 ; v3(253.27,88.72) 252.87,89.12 U2026.F12 v3(253.27,89.52) U2026.G13 U2026.H12 v3(252.47,91.12) ; U48.E10 v3(255.06,174.35) ; v3(297.02,114.69) U2025.E5 ; U2024.T1 299.83,139.52 v3(300.23,139.92) 299.56,140.58 299.56,141.88 C2577.1 ; v3(289.03,137.52) U2024.B3 ; U2022.T3 v3(234.48,177.15) ; U2023.B1 299.7,146.14 v3(300.1,145.74) 300.51,145.32 C2543.1 ; U2025.D3 298.23,112.69 v3(298.62,113.09) ; v3(300.23,138.32) 299.83,137.92 U2024.T3 ; v3(270.33,171.55) U55.K3 v3(270.33,172.35) U55.L4 ; v3(294.5,154.54) U2023.H12 294.9,154.94 295.6,155.64 ; C2651.1 248.42,85.56 v3(247.67,86.32) U2026.C5 ; U48.R5 v3(258.91,165.95) ; v3(273.03,89.52) 273.42,89.13 274.39,89.13 ; U2026.P14 v3(254.87,95.92) 256.77,95.92 C2663.1 ; v3(232.88,173.95) U2022.M1 ; v3(261.31,175.55) 261.71,175.15 U48.D1 v3(262.11,175.55) 262.24,175.42 C2501.1 ; U48.C5 v3(258.11,176.35) 257.53,176.93 ; U55.T14 v3(279.13,177.15) ; U2026.T1 243.47,97.12 v3(243.47,97.12) ; v3(261.31,177.15) 261.71,176.75 U48.B1 v3(262.11,177.15) ; U2024.D3 v3(290.63,138.32) ; U2022.L11 241.28,172.75 v3(240.88,173.15) ; U2023.F1 296.5,146.14 v3(296.9,145.74) ; C2607.1 298.09,109.48 298.6,109.99 298.6,110.65 v3(298.63,110.69) U2025.D1 ; U60.N5 v3(269.83,88.72) ; U2022.F14 v3(244.28,168.75) ; v3(252.47,96.72) U2026.T12 ; v3(293.7,148.14) U2023.K3 ; v3(230.22,176.76) 230.64,177.18 C2457.1 231.17,177.25 232.78,177.25 v3(232.88,177.15) U2022.T1 ; v3(236.88,176.35) U2022.R5 ; U60.P12 v3(264.23,87.12) U60.P11 v3(265.03,87.92) U60.N10 v3(265.83,88.72) ; v3(273.03,93.52) U60.G1 ; U2025.R5 v3(289.03,113.88) ; U2023.N5 v3(291.3,148.94) ; C2554.1 287.79,158.79 287.79,157.25 v3(288.1,156.94) U2023.T14 ; v3(243.55,93.33) 243.75,93.12 U2026.L1 v3(244.47,93.52) ; v3(265.03,89.52) U60.L11 ; U48.F1 v3(261.31,173.15) U48.G2 ; U2024.E5 v3(291.43,136.72) ; U2026.N5 v3(246.87,94.32) ; v3(288.9,148.94) 289.3,149.34 U2023.R5 ; C2508.1 281.01,167.42 279.55,167.42 v3(279.28,167.15) U55.D14 ; v3(290.5,148.14) U2023.P3 ; U2026.D1 244.07,87.52 v3(243.67,87.12) ; U2022.G14 v3(244.28,169.55) ; U2026.E10 v3(250.72,88.32) ; v3(260.51,165.95) U48.T3 ; U48.D14 v3(250.91,174.75) ; U2026.M14 v3(254.87,94.32) ; v3(293.03,113.09) U2025.L4 ; v3(255.49,178.01) v3(255.49,177.37) 255.49,176.93 v3(254.91,176.35) U48.C10 ; v3(291.3,156.94) U2023.M14 ; U2025.C10 v3(299.43,117.88) ; v3(296.9,149.74) U2023.E5 ; v3(273.03,85.52) U60.T1 ; U55.M1 v3(267.93,173.95) ; U2024.P3 v3(298.63,137.52) ; v3(273.03,95.92) U60.D1 ; U2022.D14 v3(244.32,167.15) ; U55.P14 v3(279.13,175.55) ; U2025.B14 v3(299.43,121.88) ; v3(246.07,87.12) U2026.D3 ; U2026.P1 v3(243.47,95.52) ; U48.F12 v3(252.51,173.95) ; U2022.G1 v3(232.88,169.15) ; U2026.D14 v3(254.87,87.12) ; v3(270.63,96.72) U60.B3 ; U2022.T12 v3(241.68,176.35) ; U2023.F14 296.5,156.54 v3(296.9,156.94) ; U2024.F1 v3(291.43,139.92) ; U55.B12 v3(277.53,165.15) ; 273.6,88.15 v3(273.03,88.72) U60.M1 ; v3(261.63,93.92) U60.F14 ; U55.D3 v3(269.53,167.55) ; v3(291.43,113.89) U2025.N5 ; v3(270.63,91.92) U60.H3
  BOTTOM w0.457: 301.96,150.49 302.07,150.38 C2539.1 303.69,150.38 v1(303.75,150.45)
  vias: v1(238.72,177.89) v1(240,177.88) v1(264.64,175.34) v1(264.76,166.58) v1(264.76,165.94) v1(265.27,175.72) v1(265.27,169.5) v1(265.27,168.86) v1(270.94,178.54) v1(271.57,178.54) v1(272.26,110.32) v1(272.26,109.55) v1(272.77,105.87) v1(272.77,105.11) v1(275.25,89.11) v1(275.69,86.44) v1(275.69,85.68) v1(275.69,84.92) v1(276.45,87.2) v1(276.45,86.44) v1(277.34,101.04) v1(277.34,100.28) v1(277.34,99.39) v1(277.34,98.63) v1(277.34,96.35) v1(277.34,95.58) v1(277.34,94.82) v1(277.34,94.06) v1(277.34,92.54) v1(277.34,91.77) v1(278.23,101.04) v1(278.23,100.28) v1(278.23,99.39) v1(278.23,98.63) v1(278.23,96.35) v1(278.23,95.58) v1(278.23,94.82) v1(278.23,94.06) v1(278.23,92.54) v1(278.23,91.77) v1(279.75,181.05) v1(279.75,180.17) v1(301.09,117.81) v1(301.67,113.74) v1(301.85,157.18) v1(301.96,145.76) v1(301.98,139.02) v1(301.98,133.43) v1(302.1,132.03) v1(302.1,117.94) v1(302.61,139.02) v1(302.61,133.43) v1(302.74,145.75) v1(302.74,132.03) v1(302.99,157.18) v1(303.25,114.76) v1(303.25,114) v1(303.75,149.69) v2(230.22,171.66) v3(248.04,141.52) v3(248.09,142.27) v3(248.89,175.59) v3(248.89,142.27) v3(250.14,141.52) v3(250.19,142.27) v3(250.99,142.27) v3(251.04,141.52) v3(251.04,120.52) v3(250.99,119.77) v3(252.24,141.52) v3(252.24,120.52) v3(252.29,142.27) v3(252.29,119.77) v3(253.09,142.27) v3(253.14,141.52) v3(253.14,120.52) v3(253.09,119.77) v3(254.39,142.27) v3(254.39,119.77) v3(255.19,142.27) v3(255.24,141.52) v3(255.24,120.52) v3(255.19,119.77) v3(256.38,178.01) v3(256.44,141.52) v3(256.44,120.52) v3(256.49,142.27) v3(256.49,119.77) v3(257.29,142.27) v3(257.34,120.52) v3(257.29,119.77) v3(258.54,120.52) v3(258.59,142.27) v3(258.59,119.77) v3(259.18,84.66) v3(259.39,142.27) v3(259.39,119.77) v3(259.68,84.15) v3(260.64,120.52) v3(260.69,142.27) v3(260.69,119.77) v3(261.49,142.27) v3(261.54,120.52) v3(261.49,119.77) v3(262.74,120.52) v3(262.79,142.27) v3(262.79,119.77) v3(264.14,121.92) v3(264.24,140.02) v3(264.24,137.92) v3(264.24,135.82) v3(264.24,134.62) v3(264.24,131.62) v3(264.18,130.57) v3(264.24,128.32) v3(264.24,125.32) v3(264.99,140.07) v3(264.99,137.97) v3(264.99,136.67) v3(264.99,135.87) v3(264.99,134.57) v3(264.99,131.67) v3(264.99,130.37) v3(264.99,129.57) v3(264.99,128.27) v3(264.99,125.37) v3(264.99,121.97) v3(265.53,177.12) v3(265.91,84.53) v3(266.92,177.24) v3(285.34,109.55) v3(286.23,109.55) v3(294.99,108.66) v3(295.63,108.66) v3(299.99,108.66) v3(301.09,127.84)
