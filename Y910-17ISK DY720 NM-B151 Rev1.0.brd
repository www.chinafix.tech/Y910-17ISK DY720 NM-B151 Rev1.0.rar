# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP: 298.42,169.5 298.42,167.21 298.55,167.08 300.45,167.08 300.58,167.21 300.58,169.24 300.2,169.62 298.55,169.62
GND on TOP: 117.7,91.52 117.57,91.65 117.57,93.93 116.81,94.69 111.48,94.69 110.21,95.96 110.21,100.41 113.25,103.46 118.97,103.46 119.98,102.44 119.98,91.9 119.6,91.52
GND on TOP: 207.61,157.81 207.3,158.12 207.16,158.12 207.04,158.25 206.62,158.25 206.37,158.5 206.37,159.36 206.47,159.46 208,159.46 208.25,159.21 208.25,157.94 208.12,157.81
GND on TOP: 253.7,124.4 253.74,124.36 253.74,123.85 253.51,123.63 253.51,122.3 253.59,122.23 253.59,121.8 253.49,121.69 253.05,121.69 252.85,121.49 252.85,120.93 252.78,120.86 252.5,120.86 252.39,120.96 252.39,122.18 252.6,122.38 252.6,123.47 252.55,123.52 252.55,124.08 252.06,124.57 252.06,124.92 252.22,125.07 252.22,125.84 252.09,125.96 252.09,126.37 252.24,126.52 252.24,127.18 252.09,127.33 252.09,127.69 252.24,127.84 252.24,128.48 251.96,128.76 251.96,129.7 252.08,129.81 252.23,129.81 252.24,129.82 252.42,129.82 252.55,129.7 252.55,128.73 253.08,128.2 255.14,128.2 255.39,127.94 255.39,124.92 255.52,124.79 255.52,122.43 255.7,122.25 256.2,122.25 256.36,122.41 256.36,123.35 256.51,123.5 256.66,123.5 256.84,123.32 256.84,121.85 256.81,121.82 255.54,121.82 255.32,121.59 255.32,120.93 255.21,120.83 254.88,120.83 254.81,120.91 254.81,122.46 254.93,122.58 254.93,124.84 254.76,125.02 253.79,125.02 253.7,124.93
GND on TOP: 213.1,190.68 212.44,191.34 212.44,196.55 211.68,197.31 211.68,203.15 210.92,203.91 210.92,205.69 211.17,205.95 267.3,205.95 267.43,205.82 267.43,204.3 267.3,204.17 265.27,204.17 265.02,204.42 265.02,205.06 264.89,205.18 263.24,205.18 263.11,205.06 263.11,201.63 263.88,200.87 270.86,200.87 271.11,200.61 271.11,197.21 271.77,196.55 271.77,191.24 271.22,190.68 ; 4 cut-outs
GND on TOP: 74.52,50.27 74.21,50.57 74.21,52.07 74.11,52.18 74.01,52.18 74.01,52.15 72.99,52.15 72.87,52.02 72.87,51.21 72.36,50.7 70.07,50.7 69.95,50.83 69.95,52.28 73.2,55.53 74.85,55.53 75.58,54.79 77.97,54.79 78.2,54.56 78.2,52.91 78.35,52.76 80.87,52.76 81,52.63 81,51.46 81.07,51.39 82.39,51.39 82.65,51.64 86.96,51.64 87.47,51.13 87.47,49.48 87.22,49.23 84.55,49.23 83.66,48.34 80.39,48.34 80.33,48.39 80.33,48.7 80.44,48.8 80.44,50.04 80.21,50.27
GND on TOP: 237.21,160.23 237.46,159.97 237.46,158.45 237.21,158.19 235.05,158.19 234.41,158.83 233.78,158.83 233.65,158.96 233.65,162.89 233.9,163.15 235.81,163.15 237.21,161.75
GND on TOP: 145,151.97 145.51,151.46 145.51,147.91 144.11,146.51 139.92,146.51 138.53,147.91 138.53,151.72 138.78,151.97
GND on TOP: 248.25,121.69 248.18,121.77 248.18,122.25 247.82,122.61 247.82,123.24 247.7,123.37 247.7,124.67 247.97,124.95 248.23,124.95 248.33,124.84 248.33,122.51 248.56,122.28 249.12,122.28 249.19,122.36 249.19,123.42 249.32,123.55 249.32,124.39 249.19,124.51 249.19,124.84 249.09,124.95 249.09,125.81 249.22,125.94 249.22,126.44 249.12,126.55 249.12,127.16 249.19,127.23 249.19,127.79 249.12,127.87 249.12,128.68 249.19,128.76 249.19,129.72 249.32,129.85 249.6,129.85 249.7,129.75 249.7,128.65 249.63,128.58 249.63,127.79 249.73,127.69 249.73,127.21 249.65,127.13 249.65,126.37 249.78,126.24 249.78,125.89 249.65,125.76 249.65,125.07 249.75,124.97 249.75,122.41 249.91,122.25 250.51,122.25 250.57,122.3 250.57,122.96 250.67,123.07 250.67,123.5 250.92,123.75 250.92,124.41 250.64,124.69 250.64,128.5 250.57,128.58 250.57,129.72 250.26,130.03 250.26,130.58 250.62,130.94 250.62,131.04 250.79,131.22 251.02,131.22 251.12,131.12 251.12,124.74 251.33,124.54 251.33,123.73 251.23,123.63 251.23,122.74 251.25,122.71 251.25,121.85 251.1,121.69
GND on TOP: 289.15,112.47 290.8,112.47 291.05,112.22 291.05,110.44 290.8,110.19 290.8,109.3 290.67,109.17 288.89,109.17 288.77,109.3 288.77,112.09
GND on TOP: 280,175.85 281.4,175.85 282.16,175.09 282.16,174.83 281.78,174.45 278.99,174.45 278.86,174.58 278.86,174.96 278.99,175.09 279.62,175.09 279.88,175.34 279.88,175.72
GND on TOP: 62.71,63.71 62.71,61.04 62.83,60.91 63.34,60.91 64.36,59.9 65.37,59.9 65.76,60.28 67.28,60.28 67.53,60.53 67.53,62.06 67.79,62.31 67.79,62.94 67.53,63.2 67.53,64.21 67.41,64.34 67.15,64.34 66.64,63.83 66.14,63.83 66.01,63.96 66.01,64.21 65.88,64.34 63.85,64.34 63.34,63.83 62.83,63.83
GND on TOP: 300.96,120.73 303.25,120.73 303.37,120.6 303.37,120.09 303.12,119.84 301.47,119.84 301.34,119.71 301.34,119.33 301.21,119.21 300.83,119.21 300.71,119.33 300.71,120.48
GND on TOP: 229.2,175.21 231.87,175.21 232.13,174.96 233.01,174.96 233.14,174.83 233.14,174.45 233.01,174.32 232.25,174.32 231.87,173.94 229.08,173.94 228.95,174.07 228.95,174.96
GND on TOP: 301.59,155.4 303.12,155.4 303.37,155.15 303.37,154.89 302.74,154.26 300.83,154.26 300.71,154.38 300.71,154.64 300.83,154.77 301.21,154.77 301.47,155.02 301.47,155.27
GND on TOP: 288.61,58.37 288.87,58.63 290.67,58.63 290.93,58.37 290.93,54.69 290.57,54.33 288.59,54.33 288.41,54.51 288.41,55.07 288.61,55.27
GND on TOP: 300.83,107.52 300.83,104.6 301.09,104.35 302.48,104.35 302.74,104.6 302.74,107.27 302.36,107.65 300.96,107.65
GND on TOP: 223.11,182.96 224.89,182.96 225.9,181.94 225.9,178.51 224.76,177.37 224.76,176.36 224.51,176.1 222.22,176.1 221.97,176.36 221.97,178.26 222.22,178.51 222.22,182.07
GND on TOP: 267.3,57.1 266.03,55.83 265.4,55.83 265.27,55.96 265.27,56.98 265.65,57.36 265.65,64.54 265.96,64.85 267.05,64.85 267.3,64.6
GND on TOP: 65.88,10.87 65.88,10.24 65.63,9.99 64.36,9.99 64.23,10.11 64.23,20.78 66.14,20.78 66.26,20.65 66.26,19.76 66.77,19.26 68.42,19.26 68.57,19.1 68.57,15.22 68.42,15.07 66.64,15.07 66.52,14.94 66.52,11.51
GND on TOP: 118.33,134.57 120.11,134.57 120.62,134.06 120.62,131.65 120.37,131.4 118.46,131.4 118.08,131.78 118.08,134.32
GND on TOP: 211.55,102.06 212.95,102.06 213.2,101.81 213.2,100.54 212.95,100.28 211.93,100.28 211.55,100.66
GND on TOP: 300.58,142.7 302.48,142.7 302.74,142.45 302.74,141.3 302.48,141.05 301.47,141.05 301.34,140.92 301.34,139.91 301.09,139.65 300.71,139.65 300.58,139.78 300.58,140.67 300.32,140.92 300.32,142.45
GND on TOP: 281.4,81.87 278.73,81.87 278.23,82.38 278.23,89.11 278.73,89.61 281.4,89.61 281.78,89.23 281.78,82.25
GND on TOP: 117.83,27.77 117.44,28.15 117.44,38.18 122.65,43.39 125.45,43.39 127.48,41.35 127.48,39.45 128.62,38.31 158.34,38.31 158.72,38.69 158.72,40.72 158.08,41.35 149.83,41.35 149.32,41.86 149.32,47.07 149.7,47.45 164.69,47.45 172.56,39.58 181.45,39.58 182.15,40.28 182.15,45.99 182.47,46.31 191.74,46.31 192.76,45.29 211.3,45.29 211.3,37.54 123.41,37.54 122.65,36.78 122.65,28.02 122.4,27.77
GND on TOP: 196.31,93.17 196.18,93.3 196.18,98.25 196.31,98.38 196.31,113.74 194.28,115.78 188.06,115.78 188.06,119.08 191.87,122.89 194.79,122.89 196.31,124.41 201.14,124.41 203.42,122.13 203.42,119.33 203.49,119.27 203.49,118.38 204.13,117.73 204.77,117.73 205.58,116.92 205.58,106.12 205.46,106 201.52,106 200.5,104.98 200.5,98.63 200.65,98.48 200.65,97.72 199.82,96.88 199.82,93.4 199.59,93.17
GND on TOP: 272,178.01 274.04,178.01 274.16,178.13 275.81,178.13 276.19,177.75 276.19,176.1 276.07,175.97 275.05,175.97 274.04,176.99 271.88,176.99 271.75,177.12 271.75,177.75
GND on TOP: 300.71,145.88 300.71,145.49 301.09,145.11 301.09,144.22 301.47,143.84 302.74,143.84 302.99,144.1 302.99,144.99 302.86,145.11 302.1,145.11 301.21,146 300.83,146
GND on TOP: 235.3,143.46 237.97,143.46 238.35,143.08 238.35,142.7 238.6,142.45 240,142.45 240.63,141.81 240.63,140.41 240.38,140.16 239.75,140.16 238.35,141.56 236.19,141.56 235.3,142.45
GND on TOP: 188.11,128.81 189,128.81 189,128.32 189.28,128.04 189.28,127.33 189.2,127.26 187.12,127.26 186.05,128.32 185.57,128.32 185.39,128.5 185.39,128.81 185.82,129.24 186.15,129.24 186.25,129.34 186.25,130.18 186.35,130.28 186.89,130.28 187.09,130.08 187.09,128.68 187.22,128.55 187.9,128.55 188.11,128.76
GND on TOP: 128.04,56.65 128.04,60.18 128.72,60.86 132.23,60.86 132.48,60.61 132.48,56.09 128.62,56.09 128.61,56.07
GND on TOP: 261.84,137.04 261.79,136.99 261.79,133.43 261.97,133.25 261.97,132.41 261.72,132.16 261.72,131.02 261.97,130.76 262.99,130.76 263.24,131.02 263.24,131.52 263.11,131.65 263.11,132.29 262.86,132.54 262.86,136.22 263.37,136.73 263.37,137.62 262.99,138 262.99,140.03 262.73,140.29 262.3,140.29 262.27,140.26 262.27,139.98 261.84,139.55
GND on TOP: 226.84,74.63 229.03,74.63 229.28,74.37 230.04,74.37 230.3,74.12 230.3,73.36 230.07,73.13 227.91,73.13 227.78,73.26 227.45,73.26 226.71,73.99 226.71,74.5
GND on TOP: 208.63,170.41 208.63,175.21 209.65,175.21 210.03,174.83 210.03,168.74 209.9,168.61 208.88,168.61 208.87,168.62 208.67,168.62 208.45,168.84 208.45,170.23
GND on TOP: 27.53,37.8 29.18,37.8 29.43,38.05 29.43,40.34 28.93,40.85 27.15,40.85 26.96,40.66 26.96,38.62 26.39,38.05 26.39,37.54 26.51,37.42 27.15,37.42
GND on TOP: 146.02,201.98 146.02,199.8 139.5,193.28 132.98,199.8 132.98,201.98 130.4,201.98 130.4,202.99 133.5,202.99 133.85,202.85 133.99,202.5 133.99,199.8 139.5,194.29 145.01,199.8 145.01,202.5 145.15,202.85 145.5,202.99 149.13,202.99 149.3,202.82 149.3,202.21 149.06,201.98
GND on TOP: 236.57,128.73 236.95,128.73 237.21,128.48 237.21,128.1 237.33,127.97 237.71,127.97 237.84,127.84 237.84,127.59 237.71,127.46 236.32,127.46 235.81,127.97 233.4,127.97 233.27,128.1 233.27,128.35 233.4,128.48 233.78,128.48 233.9,128.35 236.19,128.35
GND on TOP: 216.89,126.44 220.31,126.44 220.57,126.19 220.57,124.79 220.44,124.67 216.89,124.67 216.76,124.79 216.76,126.32
GND on TOP: 67.03,93.3 69.18,93.3 69.31,93.17 69.31,88.47 69.57,88.22 69.57,86.95 69.44,86.82 67.03,86.82 66.77,87.07 66.77,93.04
GND on TOP: 252.27,130.79 251.66,131.4 251.56,131.4 251.48,131.47 251.48,131.96 251.94,132.41 251.94,137.29 251.86,137.37 251.86,138.76 251.94,138.84 251.94,140.14 252.06,140.26 255.21,140.26 255.42,140.06 255.42,132.31 255.16,132.06 255.16,131.52 255.01,131.37 254.1,131.37 253.99,131.47 253.99,132.57 253.11,133.46 252.67,133.46 252.52,133.3 252.52,130.92 252.39,130.79 ; 1 cut-out
GND on TOP: 261.72,84.92 262.22,84.92 262.48,84.66 262.86,84.66 263.11,84.92 263.62,84.92 263.75,84.79 263.75,83.26 263.62,83.14 261.59,83.14 261.46,83.26 261.46,84.66
GND on TOP: 264,121.36 263.37,120.73 263.11,120.73 262.99,120.86 262.35,120.86 262.22,120.98 262.22,122.25 261.97,122.51 261.97,123.52 262.22,123.78 262.22,124.29 261.97,124.54 261.97,124.79 262.22,125.05 263.11,125.05 263.24,124.92 263.24,122.13
GND on TOP: 291.84,46.84 291.84,44.3 291.56,44.02 289.91,44.02 289.53,44.4 289.53,46.43 290.04,46.94 291.74,46.94
GND on TOP: 300.07,136.1 300.45,136.1 300.83,135.72 300.83,134.57 300.71,134.45 299.82,134.45 299.69,134.57 299.69,135.46 300.07,135.84
GND on TOP: 296.77,37.93 296.51,37.67 294.1,37.67 293.97,37.8 293.97,38.81 294,38.84 294,39.35 294.1,39.45 294.86,39.45 294.99,39.32 296.64,39.32 296.77,39.2
GND on TOP: 295.5,104.22 296.26,103.46 296.26,93.3 294.74,91.77 292.58,91.77 292.45,91.9 292.45,92.41 292.32,92.54 291.94,92.54 291.05,93.42 288.13,93.42 287.75,93.81 287.75,97.49 288.39,98.12 288.39,104.85 288.77,105.24 292.07,105.24 292.32,105.49 292.58,105.49 292.83,105.74 292.83,106.76 292.58,107.01 292.58,107.65 292.83,107.9 295.24,107.9 295.5,107.65
GND on TOP: 223.62,47.96 223.62,49.46 223.9,49.74 224.51,49.74 225.39,50.63 225.39,50.88 225.65,51.13 226.79,51.13 226.92,51.01 226.92,49.99 224.89,47.96
GND on TOP: 107.54,52.91 106.78,53.67 106.78,64.72 106.9,64.85 107.79,64.85 108.05,64.6 108.05,62.31 108.43,61.93 111.35,61.93 111.86,61.42 111.86,60.02 112.75,59.13 114.78,59.13 115.29,59.64 115.29,63.96 114.78,64.47 114.78,70.44 113.89,71.33 108.94,71.33 108.17,70.56 108.17,67.9 107.92,67.64 107.28,67.64 107.03,67.9 107.03,77.17 107.41,77.55 107.92,77.55 108.25,77.88 109.65,77.88 109.9,78.13 109.9,85.12 110.21,85.42 110.84,85.42 110.97,85.55 112.24,85.55 112.36,85.68 115.29,85.68 115.54,85.93 115.54,88.09 116.56,88.09 116.56,69.68 117.7,68.53 117.7,68.28 117.57,68.15 116.56,68.15 116.56,63.83 117.19,63.2 119.48,63.2 119.6,63.07 119.6,55.83 119.48,55.71 117.44,55.71 117.19,55.45 117.19,54.31 116.81,53.93 111.98,53.93 110.97,52.91
GND on TOP: 15.21,33.61 15.21,31.45 20.42,31.45 20.67,31.7 22.19,31.7 22.58,32.08 22.58,35.26 22.45,35.39 20.54,35.39 20.42,35.26 20.42,34.37 20.04,33.99 15.59,33.99
GND on TOP: 265.91,172.55 267.69,172.55 267.94,172.29 267.94,171.91 267.81,171.78 267.56,171.78 267.3,172.04 265.91,172.04 265.78,172.16 265.78,172.42
GND on TOP: 131.91,138.9 131.91,137.15 131.93,137.13 131.93,136.85 132.18,136.6 135.35,136.6 135.73,136.99 135.73,142.45 132.43,145.75 127.1,145.75 123.16,141.81 123.16,139.91 123.29,139.78 127.1,139.78 127.6,139.27 131.54,139.27
GND on TOP: 212.19,99.77 212.19,97.87 212.57,97.49 214.85,97.49 215.11,97.74 215.11,99.65 214.73,100.03 212.44,100.03
GND on TOP: 249.78,84.79 250.92,84.79 251.18,84.53 251.18,83.14 251.05,83.01 249.65,83.01 249.52,83.14 249.52,84.53
GND on TOP: 210.15,50.24 209.9,50.5 209.9,53.93 208.38,55.45 191.1,55.45 189.83,56.72 189.83,60.79 190.68,61.64 205.8,61.64 207.61,63.45 207.61,83.52 206.09,85.04 206.09,89.23 209.14,92.28 210.92,92.28 211.68,93.04 211.68,96.85 212.06,97.23 214.22,97.23 214.47,96.98 214.47,95.89 217.22,93.15 217.22,83.95 220.25,80.92 220.25,68.98 220.44,68.79 220.44,63.83 218.92,62.31 218.92,58.63 214.6,54.31 212.44,54.31 211.81,53.67 211.81,50.37 211.68,50.24
GND on TOP: 261.97,178.26 264.13,178.26 264.26,178.39 264.26,178.77 264.38,178.9 264.64,178.9 265.27,178.26 268.07,178.26 268.19,178.13 268.19,177.75 268.07,177.63 265.91,177.63 265.78,177.5 265.4,177.5 264.89,176.99 264,176.99 263.75,177.24 263.75,177.5 262.1,177.5 261.84,177.75 261.84,178.13
GND on TOP: 14.32,20.27 18.13,20.27 18.38,20.02 18.38,18.11 18.26,17.99 17.5,17.99 16.86,18.62 14.19,18.62 14.07,18.75 14.07,20.02
GND on TOP, BOTTOM, IN03, IN05, IN08: 109.95,205.95 132.56,205.95 133.95,204.55 133.95,202.64 133.57,202.26 130.91,202.26 130.78,202.39 120.49,202.39 116.81,198.71 114.14,198.71 113.38,197.95 113.38,183.09 115.03,181.44 115.03,171.4 114.4,170.77 109.82,170.77 109.57,171.02 109.57,205.57
GND on BOTTOM: 262.69,122.14 262.69,122.42 262.59,122.52 262.59,122.79 262.71,122.92 262.71,123.79 262.61,123.89 262.61,124.22 262.71,124.32 262.71,125.14 262.54,125.32 262.54,125.52 262.69,125.67 262.69,126.59 262.56,126.72 262.56,126.92 262.71,127.07 262.71,127.24 262.56,127.39 262.56,127.64 262.69,127.77 262.69,139.87 262.56,139.99 262.44,139.99 262.01,139.57 262.01,138.57 262.19,138.39 262.19,137.67 261.99,137.47 261.99,137.12 262.16,136.94 262.16,136.24 262.01,136.09 262.01,135.72 262.14,135.59 262.14,134.87 261.94,134.67 261.94,134.42 262.16,134.19 262.16,133.42 261.94,133.19 261.94,133.04 262.09,132.89 262.09,132.64 261.96,132.52 261.96,132.32 262.11,132.17 262.11,131.29 261.99,131.17 261.99,130.92 262.16,130.74 262.16,129.92 261.96,129.72 261.96,129.49 262.11,129.34 262.11,129.17 261.94,128.99 261.94,128.77 262.16,128.54 262.16,127.87 261.96,127.67 261.96,127.37 262.24,127.09 262.24,126.52 261.96,126.24 261.96,125.99 262.16,125.79 262.16,125.07 261.96,124.87 261.96,124.59 262.14,124.42 262.14,123.64 261.96,123.47 261.96,123.22 262.11,123.07 262.11,122.89 261.96,122.74 261.96,122.47 262.39,122.04 262.59,122.04
GND on BOTTOM: 285.97,36.66 290.04,36.66 290.67,36.02 290.67,31.45 290.55,31.32 286.1,31.32 285.34,30.56 284.96,30.56 284.83,30.69 284.83,35.51
GND on BOTTOM: 286.71,43.36 286.3,42.95 284.22,42.95 283.89,43.29 283.89,44.38 284.12,44.61 286.53,44.61 286.71,44.43
GND on BOTTOM: 109.57,85.68 109.57,79.2 109.95,78.82 110.33,78.82 111.86,77.3 111.86,75.01 115.54,71.33 116.3,71.33 116.43,71.45 116.43,71.58 115.92,72.09 115.92,73.23 115.29,73.87 115.29,79.96 114.65,80.6 113.63,80.6 113.13,81.11 113.13,85.68 112.87,85.93 111.86,85.93 111.6,85.68 110.84,85.68 110.59,85.93 109.82,85.93
GND on BOTTOM: 242.67,103.2 242.41,102.95 241.52,102.95 241.14,103.33 241.14,105.24 241.02,105.36 241.02,107.27 241.14,107.39 241.65,107.39 242.67,106.38
GND on BOTTOM: 212.19,125.43 212.06,125.3 210.15,125.3 210.03,125.17 209.14,125.17 209.01,125.3 209.01,127.21 209.27,127.46 211.68,127.46 212.19,126.95
GND on BOTTOM: 207.61,68.66 207.61,83.9 207.74,84.03 208.77,84.03 209.02,83.77 209.02,68.55 208.88,68.41 207.87,68.41
GND on BOTTOM: 27.93,68.58 28.14,68.79 28.59,68.79 28.7,68.69 28.7,68.25 28.39,67.95 28.39,67.59 28.06,67.26 25.75,67.26 25.48,67.53 25.47,67.52 25.06,67.52 24.86,67.72 24.86,68.43 25.01,68.58
GND on BOTTOM: 237.89,72.32 238.37,72.32 238.78,71.91 239.97,71.91 240.35,72.29 240.66,72.29 241.07,71.89 241.83,71.89 242.16,71.56 242.41,71.56 242.95,72.09 243.96,72.09 244.11,71.94 244.11,71.58 243.66,71.12 243,71.12 242.62,70.74 241.29,70.74 241.07,70.51 239.59,70.51 239.21,70.13 238.18,70.13 237.87,70.44 237.87,72.29
GND on BOTTOM: outline of 118 points within 227.65,53.78 251.25,70.62 ; 2 cut-outs
GND on BOTTOM: 200.76,191.98 205.71,191.98 205.96,192.23 205.96,193.63 205.71,193.88 201.01,193.88 200.63,193.5 200.63,192.1
GND on BOTTOM: 226.28,52.02 227.43,52.02 227.55,51.9 227.55,51.77 227.43,51.64 227.17,51.64 226.92,51.39 226.92,50.37 226.28,49.74 226.28,49.1 226.16,48.97 225.27,48.97 224.63,48.34 224.63,48.09 224.51,47.96 223.24,47.96 223.11,48.09 223.11,49.48 223.24,49.61 224.25,49.61 225.24,50.6 225.27,50.6 225.27,51.01
GND on BOTTOM: 259.89,122.14 259.89,122.42 259.79,122.52 259.79,122.79 259.91,122.92 259.91,123.79 259.81,123.89 259.81,124.22 259.91,124.32 259.91,125.14 259.74,125.32 259.74,125.52 259.89,125.67 259.89,126.59 259.76,126.72 259.76,126.92 259.91,127.07 259.91,127.24 259.76,127.39 259.76,127.64 259.89,127.77 259.89,139.87 259.76,139.99 259.64,139.99 259.21,139.57 259.21,138.57 259.39,138.39 259.39,137.67 259.19,137.47 259.19,137.12 259.36,136.94 259.36,136.24 259.21,136.09 259.21,135.72 259.34,135.59 259.34,134.87 259.14,134.67 259.14,134.42 259.36,134.19 259.36,133.42 259.14,133.19 259.14,133.04 259.29,132.89 259.29,132.64 259.16,132.52 259.16,132.32 259.31,132.17 259.31,131.29 259.19,131.17 259.19,130.92 259.36,130.74 259.36,129.92 259.16,129.72 259.16,129.49 259.31,129.34 259.31,129.17 259.14,128.99 259.14,128.77 259.44,128.47 259.44,125.14 259.16,124.87 259.16,124.59 259.34,124.42 259.34,123.64 259.16,123.47 259.16,123.22 259.31,123.07 259.31,122.89 259.16,122.74 259.16,122.47 259.59,122.04 259.79,122.04
GND on BOTTOM: 269.59,33.1 270.61,34.12 270.61,38.05 271.24,38.69 273.78,38.69 274.04,38.43 274.04,34.24 275.56,32.72 277.21,32.72 277.59,33.1 277.59,40.47 276.07,41.99 269.46,41.99 268.32,43.13 268.32,46.69 270.1,48.47 273.4,48.47 273.65,48.72 276.07,48.72 276.58,48.21 276.58,46.94 280.13,43.39 280.13,30.69 280,30.56 279.75,30.56 278.61,29.42 275.18,29.42 275.18,27.89 274.92,27.64 274.67,27.64 273.78,26.75 273.78,26.37 273.53,26.11 269.97,26.11 269.59,26.5
GND on BOTTOM: 201.01,112.47 201.01,114 201.26,114.25 202.92,114.25 203.04,114.13 203.04,112.22 202.92,112.09 201.39,112.09
GND on BOTTOM: 33.5,26.24 34.84,27.59 34.84,36.22 34.41,36.66 23.39,36.66 22.75,36.02 20.42,36.02 20.16,35.77 20.16,31.7 20.92,30.94 22.19,30.94 22.45,30.69 22.45,27.26 23.46,26.24
GND on BOTTOM: 94.46,79.71 94.46,78.57 94.58,78.44 96.62,78.44 96.87,78.69 96.87,79.84 96.74,79.96 94.71,79.96
GND on BOTTOM: 209.77,202.77 209.77,199.34 209.27,198.83 207.87,198.83 207.23,199.47 207.23,200.87 206.6,201.5 204.95,201.5 204.57,201.88 204.57,203.53 204.82,203.79 207.23,203.79 208.12,202.9 209.65,202.9
GND on BOTTOM: 274.29,182.96 276.7,182.96 276.96,182.71 276.96,178.64 276.58,178.26 275.05,178.26 274.8,178.51 274.8,180.29 274.54,180.55 273.4,180.55 273.27,180.67 273.27,181.94
GND on BOTTOM: 192.17,198.25 192.37,198.45 192.37,199.93 192.45,200 194.15,200 194.2,199.95 194.2,198.61 194.36,198.45 194.79,198.45 194.91,198.58 194.91,199.95 194.96,200 196.69,200 196.72,199.98 196.72,198.1 196.44,197.82 196.44,196.29 196.06,195.91 192.37,195.91 192.17,196.12
GND on BOTTOM: 195.68,61.67 195.68,63.33 196.06,63.71 196.31,63.71 196.44,63.58 196.44,60.53 196.69,60.28 197.71,60.28 198.09,60.66 201.39,60.66 201.77,60.28 201.77,56.21 201.52,55.96 196.57,55.96 196.18,56.34 196.18,58.12 194.66,59.64 194.6,59.58 190.66,59.58 190.6,59.64 135.35,59.64 135.35,56.85 134.4,55.9 128.56,55.9 127.99,56.47 127.99,60.66 129,61.67
GND on BOTTOM: 219.17,90.88 218.92,91.14 218.92,94.06 219.3,94.44 224.25,94.44 224.76,93.93 226.03,93.93 226.28,93.68 226.28,93.17 226.41,93.04 227.55,93.04 227.68,93.17 227.68,95.84 227.62,95.9 226.6,95.9 226.16,96.35 226.16,98.5 226.41,98.76 232.38,98.76 232.51,98.63 232.51,96.73 232.13,96.35 231.49,96.35 231.24,96.09 231.24,95.33 230.93,95.2 231.24,95.08 231.62,94.69 238.35,94.69 238.48,94.57 238.48,93.93 238.73,93.68 239.62,93.68 239.75,93.55 239.75,91.65 238.98,90.88
GND on BOTTOM: 274.8,91.01 276.07,91.01 276.32,90.76 276.32,89.87 276.19,89.74 274.8,89.74 274.54,90 274.54,90.76
GND on BOTTOM: 248.25,182.71 249.91,182.71 250.16,182.45 250.16,178.77 249.78,178.39 246.98,178.39 246.48,178.9 246.48,180.93
GND on BOTTOM: 245.46,72.6 245.46,72.47 245.63,72.3 246.01,72.3 246.22,72.09 247.11,72.09 247.43,71.77 247.63,71.77 247.9,71.5 248.13,71.5 248.19,71.57 248.19,71.7 248.25,71.76 248.25,71.83 249.27,72.85 249.27,73.87 249.14,73.99 246.86,73.99
GND on BOTTOM: 223.49,86.06 227.05,86.06 227.3,85.8 227.3,84.53 227.05,84.28 223.49,84.28 223.36,84.41 223.36,85.93
GND on BOTTOM: 66.26,16.97 66.14,17.1 66.14,18.75 65.88,19 59.79,19 59.53,19.26 59.53,22.94 59.91,23.32 65.5,23.32 65.88,22.94 65.88,20.02 66.64,19.26 68.42,19.26 68.68,19 68.68,17.86 67.79,16.97
GND on BOTTOM: 257.09,122.14 257.09,122.42 256.99,122.52 256.99,122.79 257.11,122.92 257.11,123.79 257.01,123.89 257.01,124.22 257.11,124.32 257.11,125.14 256.94,125.32 256.94,125.52 257.09,125.67 257.09,126.59 256.96,126.72 256.96,126.92 257.11,127.07 257.11,127.24 256.96,127.39 256.96,127.64 257.09,127.77 257.09,139.87 256.96,139.99 256.84,139.99 256.41,139.57 256.41,138.57 256.59,138.39 256.59,137.67 256.39,137.47 256.39,137.12 256.56,136.94 256.56,136.24 256.41,136.09 256.41,135.72 256.54,135.59 256.54,134.87 256.34,134.67 256.34,134.42 256.56,134.19 256.56,133.42 256.34,133.19 256.34,133.04 256.49,132.89 256.49,132.64 256.36,132.52 256.36,132.32 256.51,132.17 256.51,131.29 256.39,131.17 256.39,130.92 256.56,130.74 256.56,129.92 256.36,129.72 256.36,129.49 256.51,129.34 256.51,129.17 256.34,128.99 256.34,128.77 256.56,128.54 256.56,127.87 256.36,127.67 256.36,127.37 256.64,127.09 256.64,126.52 256.36,126.24 256.36,125.99 256.56,125.79 256.56,125.07 256.36,124.87 256.36,124.59 256.54,124.42 256.54,123.64 256.36,123.47 256.36,123.22 256.51,123.07 256.51,122.89 256.36,122.74 256.36,122.47 256.79,122.04 256.99,122.04
GND on BOTTOM: 216.63,121.75 216.89,121.49 216.89,120.09 216.76,119.97 214.09,119.97 213.96,119.84 213.96,118.32 213.84,118.19 213.33,118.19 212.19,119.33 210.79,119.33 210.15,119.97 209.39,119.97 209.27,120.09 209.27,120.73 209.14,120.86 209.01,120.86 208.76,121.11 208.76,122.13 209.52,122.13 209.9,121.75
GND on BOTTOM: 85.69,76.53 86.46,76.53 86.58,76.41 86.58,74.63 86.46,74.5 85.69,74.5 85.57,74.63 85.57,76.41
GND on BOTTOM: 66.39,42.75 64.74,42.75 64.49,43.01 63.47,43.01 63.34,43.13 63.34,44.53 63.72,44.91 66.26,44.91 66.52,44.66 66.52,42.88
GND on BOTTOM: 210.28,168.61 210.03,168.35 208,168.35 207.74,168.61 207.74,171.15 207.87,171.28 208.05,171.28 208.28,171.51 208.28,175.72 208.4,175.83 208.83,175.83 208.86,175.87 209.86,175.87 210.28,175.44
GND on BOTTOM: 308.45,107.14 308.45,99.27 308.71,99.01 310.1,99.01 310.36,99.27 310.36,107.27 309.98,107.65 308.96,107.65
GND on BOTTOM: 196.31,194.01 197.07,194.01 197.33,193.75 198.22,193.75 198.22,192.74 197.96,192.48 196.44,192.48 196.31,192.61
GND on BOTTOM: 290.55,186.01 290.55,182.58 293.97,182.58 293.97,186.01
GND on BOTTOM: 36.42,80.98 37.18,80.98 37.31,81.11 37.31,81.82 36.42,82.38 35.4,82.38 35.15,82.12 35.15,81.74 35.28,81.61 35.78,81.61
GND on BOTTOM: 246.24,122.09 246.24,139.87 246.34,139.97 246.51,139.97 246.91,139.57 246.91,139.32 246.81,139.22 246.81,138.97 246.94,138.84 246.94,138.59 246.71,138.37 246.71,137.59 246.84,137.47 246.84,137.12 246.66,136.94 246.66,136.29 246.89,136.07 246.89,135.74 246.61,135.47 246.61,134.97 246.91,134.67 246.91,134.37 246.64,134.09 246.64,133.57 246.89,133.32 246.89,132.24 246.74,132.09 246.74,131.32 246.94,131.12 246.94,130.92 246.71,130.69 246.71,129.94 246.91,129.74 246.91,128.82 246.74,128.64 246.74,127.79 246.91,127.62 246.91,127.37 246.79,127.24 246.79,126.39 246.91,126.27 246.91,125.99 246.76,125.84 246.76,125.02 246.91,124.87 246.91,124.59 246.59,124.27 246.59,123.87 246.74,123.72 246.74,123.62 246.89,123.47 246.89,123.14 246.76,123.02 246.76,122.87 246.89,122.74 246.89,122.49 246.71,122.32 246.71,122.17 246.59,122.04 246.29,122.04
GND on BOTTOM: 247.64,122.09 247.64,139.87 247.74,139.97 247.91,139.97 248.31,139.57 248.31,139.32 248.21,139.22 248.21,138.97 248.34,138.84 248.34,138.59 248.11,138.37 248.11,137.59 248.24,137.47 248.24,137.12 248.06,136.94 248.06,136.29 248.29,136.07 248.29,135.74 248.01,135.47 248.01,134.97 248.31,134.67 248.31,134.37 248.04,134.09 248.04,133.57 248.29,133.32 248.29,132.24 248.14,132.09 248.14,131.32 248.34,131.12 248.34,130.92 248.11,130.69 248.11,129.94 248.31,129.74 248.31,128.82 248.14,128.64 248.14,127.79 248.31,127.62 248.31,127.37 248.19,127.24 248.19,126.39 248.31,126.27 248.31,125.99 248.16,125.84 248.16,125.02 248.31,124.87 248.31,124.59 248.29,124.57 248.29,123.14 248.16,123.02 248.16,122.87 248.29,122.74 248.29,122.49 248.11,122.32 248.11,122.17 247.99,122.04 247.69,122.04
GND on BOTTOM: 154.27,171.15 154.27,168.99 156.18,167.08 156.18,166.58 155.93,166.32 145.26,166.32 142.34,169.24 142.34,171.02 143.73,172.42 153,172.42
GND on BOTTOM: 243.81,86.06 244.83,87.07 244.83,88.22 244.44,88.6 243.94,88.6 243.68,88.34 242.54,88.34 242.29,88.09 241.65,88.09 241.4,87.84 241.4,86.31 241.65,86.06
GND on BOTTOM: 274.8,109.05 276.45,109.05 277.85,107.65 277.85,102.95 277.46,102.57 275.05,102.57 274.8,102.82
GND on BOTTOM: outline of 132 points within 210.92,197.44 269.59,205.95
GND on BOTTOM: 128.92,151.95 133.73,151.95 133.83,152.05 133.83,153.93 133.75,154 129.41,154 128.77,154.64 128.37,154.64 127.73,154 126.59,154 126.46,153.88 126.46,151.46 126.84,151.08 128.49,151.08 128.65,151.24 128.65,151.67
GND on BOTTOM: 277.97,167.97 277.97,162.39 280.89,159.46 280.89,155.78 281.78,154.89 287.12,154.89 287.88,155.65 293.59,155.65 293.59,159.97 293.34,160.23 284.7,160.23 281.4,163.53 281.4,170.39 281.02,170.77 277.85,170.77 277.59,170.51 277.59,168.35
GND on BOTTOM: 132.1,139.88 131.95,139.73 131.95,136.96 132.2,136.71 138.5,136.71 139.16,137.37 139.16,139.65 138.93,139.88
GND on BOTTOM: 46.58,91.01 46.58,90.58 46.5,90.5 46.17,90.5 46.07,90.61 46.07,90.71 45.84,90.94 45,90.94 44.55,91.39 40.48,91.39 40.36,91.52 40.36,93.04 40.61,93.3 44.17,93.3 46.2,91.27 46.32,91.27
GND on BOTTOM: 64.74,14.94 66.39,14.94 66.52,14.81 66.52,11 65.5,9.99 64.36,9.99 64.1,10.24 64.1,11.26 63.6,11.76 63.6,12.53 64.61,13.54 64.61,14.81
GND on BOTTOM: 33.12,53.17 33.88,53.17 34.01,53.29 34.01,53.42 34.13,53.55 34.39,53.55 34.51,53.42 34.51,51.9 34.39,51.77 34.13,51.77 34.01,51.9 34.01,52.02 33.88,52.15 33.12,52.15 32.99,52.28 32.99,53.04
GND on BOTTOM: outline of 185 points within 235.17,110.44 273.15,152.86 ; 3 cut-outs
GND on BOTTOM: 272.51,85.3 272.77,85.3 273.02,85.04 273.65,85.04 273.78,85.17 274.8,85.17 274.92,85.04 274.92,84.79 275.81,83.9 276.7,83.9 276.96,83.65 276.96,83.01 276.32,82.38 274.29,82.38 274.04,82.63 274.04,83.9 273.4,84.53 272.77,84.53 272.38,84.92 272.38,85.17
GND on BOTTOM: outline of 190 points within 130.4,184.08 197.84,205.57
GND on BOTTOM: 159.1,185.75 162.53,185.75 162.66,185.88 164.43,185.88 164.56,186.01 164.56,188.45 164.59,188.47 164.56,188.5 159.74,188.5 159.36,188.88 157.43,188.88 156.71,188.16 155.83,188.16 154.95,187.28 154.95,187.28 154.8,187.13 154.8,186.24 154.91,186.13 156.18,186.13 156.43,185.88 156.43,185.6 156.56,185.47 158.82,185.47
GND on BOTTOM: 297.15,37.33 297.1,37.29 294.11,37.29 293.85,37.54 293.85,38.69 294.28,39.12 296.95,39.12 297.15,38.92
GND on BOTTOM: 250.44,122.09 250.44,139.87 250.54,139.97 250.71,139.97 251.11,139.57 251.11,139.32 251.01,139.22 251.01,138.97 251.14,138.84 251.14,138.59 250.91,138.37 250.91,137.59 251.04,137.47 251.04,137.12 250.86,136.94 250.86,136.29 251.09,136.07 251.09,135.74 250.81,135.47 250.81,134.97 251.11,134.67 251.11,134.37 250.84,134.09 250.84,133.57 251.09,133.32 251.09,132.24 250.94,132.09 250.94,131.32 251.14,131.12 251.14,130.92 250.91,130.69 250.91,129.94 251.11,129.74 251.11,128.82 250.94,128.64 250.94,127.79 251.11,127.62 251.11,127.37 250.99,127.24 250.99,126.39 251.11,126.27 251.11,125.99 250.96,125.84 250.96,125.02 251.11,124.87 251.11,124.59 250.93,124.41 250.93,123.78 250.9,123.75 250.94,123.72 250.94,123.62 251.09,123.47 251.09,123.14 250.96,123.02 250.96,122.87 251.09,122.74 251.09,122.49 250.91,122.32 250.91,122.17 250.79,122.04 250.49,122.04
GND on BOTTOM: 252.84,122.47 252.84,122.69 253.01,122.87 253.01,123.09 252.84,123.27 252.84,123.44 252.99,123.59 252.99,124.39 252.86,124.52 252.86,124.89 253.24,125.27 253.51,125.27 253.59,125.19 253.59,124.92 253.51,124.84 253.51,124.59 253.59,124.52 253.59,124.22 253.49,124.12 253.49,123.89 253.61,123.77 253.61,123.54 253.51,123.44 253.51,123.17 253.59,123.09 253.59,122.84 253.46,122.72 253.46,122.52 253.64,122.34 253.64,122.17 253.54,122.07 253.24,122.07
GND on BOTTOM: 202.41,185.75 205.84,185.75 205.96,185.88 207.74,185.88 207.87,186.01 207.87,188.34 207.72,188.5 203.03,188.5 202.27,189.26 201.47,189.26 201.34,189.13 201.34,188.22 200.72,187.6 200.72,186.35 200.82,186.25 201.91,186.25
GND on BOTTOM: 223.24,182.83 225.27,182.83 226.03,182.07 226.03,179.66 226.28,179.4 226.28,176.74 225.78,176.23 221.97,176.23 221.71,176.48 221.71,179.91 222.47,180.67 222.47,182.07
GND on BOTTOM: 261.29,122.14 261.29,122.42 261.19,122.52 261.19,122.79 261.31,122.92 261.31,123.79 261.21,123.89 261.21,124.22 261.31,124.32 261.31,125.14 261.14,125.32 261.14,125.52 261.29,125.67 261.29,126.59 261.16,126.72 261.16,126.92 261.31,127.07 261.31,127.24 261.16,127.39 261.16,127.64 261.29,127.77 261.29,139.87 261.16,139.99 261.04,139.99 260.61,139.57 260.61,138.57 260.79,138.39 260.79,137.67 260.59,137.47 260.59,137.12 260.76,136.94 260.76,136.24 260.61,136.09 260.61,135.72 260.74,135.59 260.74,134.87 260.54,134.67 260.54,134.42 260.76,134.19 260.76,133.42 260.54,133.19 260.54,133.04 260.69,132.89 260.69,132.64 260.56,132.52 260.56,132.32 260.71,132.17 260.71,131.29 260.59,131.17 260.59,130.92 260.76,130.74 260.76,129.92 260.56,129.72 260.56,129.49 260.71,129.34 260.71,129.17 260.54,128.99 260.54,128.77 260.84,128.47 260.84,125.14 260.56,124.87 260.56,124.59 260.74,124.42 260.74,123.64 260.56,123.47 260.56,123.22 260.71,123.07 260.71,122.89 260.56,122.74 260.56,122.47 260.99,122.04 261.19,122.04
GND on BOTTOM: 289.28,45.67 289.28,50.5 289.78,51.01 291.69,51.01 292.2,50.5 292.2,49.1 292.45,48.85 295.88,48.85 296.13,49.1 296.13,50.75 296.51,51.13 298.04,51.13 298.42,50.75 298.42,48.09 298.17,47.83 294.23,47.83 292.07,45.67
GND on BOTTOM: 128.24,195.02 128.75,194.52 128.75,192.61 129,192.36 129.26,192.36 129.38,192.23 129.38,190.96 129.26,190.83 129.26,188.67 129.13,188.55 128.11,188.55 127.73,188.93 123.77,188.93 123.77,189.03 123.29,189.51 123.29,192.1 123.41,192.23 123.41,194.64 123.79,195.02
GND on BOTTOM: 208.63,158.96 209.14,159.46 212.06,159.46 212.44,159.08 212.44,158.45 212.31,158.32 211.3,158.32 211.17,158.19 211.17,153.37 210.79,152.99 209.14,152.99 208.63,153.5
GND on BOTTOM: 230.35,70.97 231.77,70.97 231.97,70.77 236.44,70.77 236.85,71.17 236.85,71.66 236.33,72.18 235.74,72.18 235.58,72.01 230.8,72.01 230.7,72.11 230.12,72.11 230.07,72.06 230.07,71.68 230.3,71.45 230.3,71.02
GND on BOTTOM: 300.3,108.41 301.21,108.41 301.59,108.03 302.48,108.03 302.74,108.28 302.74,109.81 304.39,111.46 304.39,157.05 301.72,159.72 296.64,159.72 296.64,159.08 295.63,158.07 295.63,144.99 294.99,144.35 294.99,140.67 295.63,140.03 295.63,133.56 295.24,133.18 294.36,133.18 293.59,132.41 288.26,132.41 287.24,131.4 287.24,129.24 286.48,128.48 286.48,120.35 287.5,119.33 287.5,119.08 288.39,118.19 295.5,118.19 295.63,118.06 295.63,114 296.01,113.62 296.01,109.81 296.51,109.3 296.51,109.17 297.4,108.28 298.55,108.28 298.93,107.9 299.79,107.9
GND on BOTTOM: 162.4,175.97 164.05,175.97 164.31,175.72 164.31,175.09 164.18,174.96 164.18,173.18 164.56,172.8 164.56,168.48 164.43,168.35 162.4,168.35 161.77,168.99 161.77,174.45 161.89,174.58 161.89,175.47
GND on BOTTOM: 235.3,182.83 236.95,182.83 237.97,181.82 237.97,180.67 237.71,180.42 237.21,180.42 237.08,180.29 237.08,178.77 236.7,178.39 234.54,178.39 234.16,178.77 234.16,181.69
GND on BOTTOM: 261.46,182.71 263.37,182.71 264,182.07 264,178.64 263.75,178.39 260.7,178.39 260.45,178.64 260.45,181.69
GND on BOTTOM: 103.73,63.83 103.98,63.58 106.78,63.58 107.28,64.09 107.28,65.61 106.65,66.25 105.25,66.25 105.13,66.37 105.13,66.63 104.87,66.88 103.98,66.88 103.73,66.63
GND on BOTTOM: 291.82,71.71 294.86,71.71 295.24,71.33 302.99,71.33 303.5,70.82 303.5,58.63 302.1,57.23 300.71,57.23 299.94,56.47 295.63,56.47 295.12,56.98 295.12,64.09 294.86,64.34 291.94,64.34 291.43,63.83 291.05,63.83 290.8,64.09 290.8,69.29 291.69,70.18 291.69,71.58
GND on BOTTOM: 244.84,123.9 244.84,139.87 244.94,139.97 245.11,139.97 245.51,139.57 245.51,139.32 245.41,139.22 245.41,138.97 245.54,138.84 245.54,138.59 245.31,138.37 245.31,137.59 245.44,137.47 245.44,137.12 245.26,136.94 245.26,136.29 245.49,136.07 245.49,135.74 245.21,135.47 245.21,134.97 245.51,134.67 245.51,134.37 245.24,134.09 245.24,133.57 245.49,133.32 245.49,132.24 245.34,132.09 245.34,131.32 245.54,131.12 245.54,130.92 245.31,130.69 245.31,129.94 245.51,129.74 245.51,128.82 245.34,128.64 245.34,127.79 245.51,127.62 245.51,127.37 245.39,127.24 245.39,126.39 245.51,126.27 245.51,125.99 245.36,125.84 245.36,125.02 245.51,124.87 245.51,124.59 245.33,124.41 245.33,123.72 245.34,123.72 245.34,123.62 245.49,123.47 245.49,123.14 245.36,123.02 245.36,122.87 245.21,122.71 245.21,122.13 245.12,122.04 244.78,122.04 244.7,122.13 244.7,123.77
GND on BOTTOM: 277.34,179.53 278.86,179.53 279.12,179.28 279.12,178.39 279.37,178.13 279.37,177.75 278.99,177.37 277.59,177.37 277.21,177.75 277.21,179.4
GND on BOTTOM: 98.39,11.38 98.9,11.89 98.9,13.92 99.28,14.3 104.49,14.3 105.13,13.67 105.13,5.29 104.62,4.78 103.35,4.78 102.33,3.76 99.28,3.76 96.64,6.4 96.64,11.1 96.92,11.38
GND on BOTTOM: 234.92,85.93 237.97,85.93 238.73,86.69 238.73,89.61 238.86,89.74 240.51,89.74 240.89,89.36 240.89,84.92 240.13,84.15 234.67,84.15 234.41,84.41 234.41,85.42
GND on BOTTOM: 255.62,64.34 256.64,64.34 256.76,64.21 256.76,61.29 256.79,61.27 256.79,60.99 256.64,60.84 254.91,60.84 254.65,61.09 254.65,63.66 254.96,63.96 255.24,63.96
GND on BOTTOM: 98.52,92.54 98.52,96.6 100.55,98.63 101.95,98.63 103.22,97.36 103.22,95.2 100.55,92.54
GND on BOTTOM: 113.89,93.04 113.38,93.55 113.38,100.66 114.52,101.81 124.3,101.81 124.94,101.17 124.94,93.17 124.81,93.04
GND on BOTTOM: 127.99,140.41 127.73,140.16 126.59,140.16 126.33,140.41 126.33,145.62 126.59,145.88 127.48,145.88 127.6,145.75 127.6,144.1 127.99,143.72
GND on BOTTOM: 281.02,68.53 281.15,68.41 281.15,66.88 280.89,66.63 276.58,66.63 276.32,66.88 276.32,68.41 276.45,68.53
GND on BOTTOM: outline of 84 points within 257.74,122.04 258.51,139.99
GND on BOTTOM: 249.04,122.09 249.04,139.87 249.14,139.97 249.31,139.97 249.71,139.57 249.71,139.32 249.61,139.22 249.61,138.97 249.74,138.84 249.74,138.59 249.51,138.37 249.51,137.59 249.64,137.47 249.64,137.12 249.46,136.94 249.46,136.29 249.69,136.07 249.69,135.74 249.41,135.47 249.41,134.97 249.71,134.67 249.71,134.37 249.44,134.09 249.44,133.57 249.69,133.32 249.69,132.24 249.54,132.09 249.54,131.32 249.74,131.12 249.74,130.92 249.51,130.69 249.51,129.94 249.71,129.74 249.71,128.82 249.54,128.64 249.54,127.79 249.71,127.62 249.71,127.37 249.59,127.24 249.59,126.39 249.71,126.27 249.71,125.99 249.56,125.84 249.56,125.02 249.71,124.87 249.71,124.59 249.39,124.27 249.39,123.87 249.54,123.72 249.54,123.62 249.69,123.47 249.69,123.14 249.56,123.02 249.56,122.87 249.69,122.74 249.69,122.49 249.51,122.32 249.51,122.17 249.39,122.04 249.09,122.04
GND on BOTTOM: 224.12,109.3 224.25,109.17 224.25,108.92 225.01,108.16 231.11,108.16 231.87,108.92 232.63,108.92 232.89,109.17 239.75,109.17 239.87,109.3 239.87,109.88 239.85,109.91 239.85,110.6 239.62,110.82 232.89,110.82 229.84,113.87 226.41,113.87 224.25,111.71 218.79,111.71 217.52,110.44 217.01,110.44 216.76,110.19 216.76,108.92 216.89,108.79 218.28,108.79 218.79,109.3
GND on BOTTOM: 255.69,122.14 255.69,122.42 255.59,122.52 255.59,122.79 255.71,122.92 255.71,123.79 255.61,123.89 255.61,124.22 255.71,124.32 255.71,125.14 255.54,125.32 255.54,125.52 255.69,125.67 255.69,126.59 255.56,126.72 255.56,126.92 255.71,127.07 255.71,127.24 255.56,127.39 255.56,127.64 255.69,127.77 255.69,139.87 255.56,139.99 255.44,139.99 255.01,139.57 255.01,138.57 255.19,138.39 255.19,137.67 254.99,137.47 254.99,137.12 255.16,136.94 255.16,136.24 255.01,136.09 255.01,135.72 255.14,135.59 255.14,134.87 254.94,134.67 254.94,134.42 255.16,134.19 255.16,133.42 254.94,133.19 254.94,133.04 255.09,132.89 255.09,132.64 254.96,132.52 254.96,132.32 255.11,132.17 255.11,131.29 254.99,131.17 254.99,130.92 255.16,130.74 255.16,129.92 254.96,129.72 254.96,129.49 255.11,129.34 255.11,129.17 254.94,128.99 254.94,128.77 255.16,128.54 255.16,127.87 254.96,127.67 254.96,127.37 255.24,127.09 255.24,126.52 254.96,126.24 254.96,125.99 255.16,125.79 255.16,125.07 254.96,124.87 254.96,124.59 255.14,124.42 255.14,123.64 254.96,123.47 254.96,123.22 255.11,123.07 255.11,122.89 254.96,122.74 254.96,122.47 255.39,122.04 255.59,122.04
GND on BOTTOM: 202.28,98.33 202.28,94.06 201.52,93.3 198.04,93.3 197.94,93.4 197.94,95.25 197.59,95.6 197.59,98.01 197.58,98.02 197.58,98.43 197.73,98.58 202.03,98.58
GND on BOTTOM: 251.84,122.09 251.84,139.87 251.94,139.97 252.11,139.97 252.51,139.57 252.51,139.32 252.41,139.22 252.41,138.97 252.54,138.84 252.54,138.59 252.31,138.37 252.31,137.59 252.44,137.47 252.44,137.12 252.26,136.94 252.26,136.29 252.49,136.07 252.49,135.74 252.21,135.47 252.21,134.97 252.51,134.67 252.51,134.37 252.24,134.09 252.24,133.57 252.49,133.32 252.49,132.24 252.34,132.09 252.34,131.32 252.54,131.12 252.54,130.92 252.31,130.69 252.31,129.94 252.51,129.74 252.51,128.82 252.34,128.64 252.34,127.79 252.51,127.62 252.51,127.37 252.39,127.24 252.39,126.39 252.51,126.27 252.51,125.99 252.36,125.84 252.36,125.02 252.51,124.87 252.51,124.59 252.19,124.27 252.19,122.17 252.06,122.04 251.89,122.04
GND on BOTTOM: 234.26,68.63 238.48,68.63 238.75,68.91 240,68.91 240.33,69.24 240.33,69.78 240.15,69.96 234.28,69.96 234.03,69.7 234.03,68.86
GND on BOTTOM: 134.97,91.52 135.1,91.39 145.13,91.39 145.26,91.27 147.8,91.27 147.92,91.39 149.19,91.39 149.32,91.27 151.1,91.27 151.23,91.39 172.05,91.39 172.44,91.77 175.23,91.77 175.74,91.27 194.66,91.27 194.79,91.14 194.79,90.25 194.66,90.12 194.66,89.11 195.17,88.6 195.55,88.6 195.8,88.85 195.8,89.61 195.42,90 195.42,92.03 195.55,92.15 195.55,93.12 194.86,93.81 137.89,93.81 135.73,95.96 135.73,97.74 135.22,98.25 130.02,98.25 129.13,97.36 129.13,91.9 129.51,91.52
GND on BOTTOM: 188.7,156.33 188.4,156.63 188.4,157.81 188.83,158.24 191.73,158.24 192.11,157.87 192.11,157.18 190.84,155.91 189.83,155.91 189.71,156.04 189.71,156.29 189.66,156.33
GND on BOTTOM: 106.78,75.26 105,75.26 105,79.58 104.87,79.71 104.87,82.76 105,82.88 106.65,82.88 106.78,83.01 106.78,86.69 106.4,87.07 105.38,87.07 105.13,86.82 102.33,86.82 101.7,86.19 101.7,77.04 102.84,75.9 102.84,69.29 103.47,68.66 105,68.66 105.25,68.91 106.65,68.91 106.78,69.04 106.78,69.17 106.65,69.29 105.13,69.29 105,69.42 105,70.18 105.13,70.31 106.65,70.31 106.78,70.44 106.78,70.69 106.65,70.82 105.25,70.82 105.13,70.95 105.13,71.83 106.65,71.83 106.78,71.96 106.78,72.22 105.25,72.22 105.13,72.34 105.13,73.36 106.65,73.36 106.78,73.49 106.78,73.74 105.25,73.74 105.13,73.87 105.13,74.76 105.25,74.88 106.78,74.88
GND on BOTTOM: 12.03,43.51 12.03,41.74 11.91,41.61 10.64,41.61 10.51,41.74 10.51,43.39 10.76,43.64 11.91,43.64
GND on BOTTOM: 48.16,81.35 47.8,81.71 47.8,82.32 46.25,83.87 46.25,88.07 46.5,88.31 46.5,88.42 46.63,88.55 46.73,88.55 46.93,88.75 46.93,89.53 48.16,90.75 55.34,90.75 55.34,91.14 55.72,91.52 56.48,91.52 56.74,91.27 56.74,91.14 56.1,90.5 55.58,90.5 55.32,90.24 55.32,89.11 55.6,88.83 55.6,81.61 55.62,81.59 55.62,81.41 55.57,81.36 54.91,81.36 54.4,81.87 54.15,81.87 53.94,81.66 53.62,81.66 53.31,81.35 ; 2 cut-outs
GND on BOTTOM: 218.28,133.3 220.31,133.3 220.57,133.05 220.57,131.78 220.44,131.65 218.41,131.65 218.16,131.91 218.16,133.18
GND on BOTTOM: 253.86,125.73 253.86,128.49 253.19,129.17 253.19,129.44 253.24,129.49 253.24,129.82 252.79,130.27 252.79,130.37 253.91,131.49 253.91,132.19 254.01,132.29 254.19,132.29 254.29,132.19 254.29,131.27 253.59,130.57 253.59,129.84 253.46,129.72 253.46,129.49 254.29,128.67 254.29,127.29 254.61,126.97 254.61,126.74 254.31,126.44 254.31,125.72 254.23,125.63 253.96,125.63
GND on BOTTOM: 270.73,13.03 275.31,13.03 275.31,8.46 270.73,8.46
GND on BOTTOM: 217.01,125.94 220.57,125.94 220.82,126.19 221.2,126.19 221.46,125.94 221.46,124.79 221.2,124.54 217.01,124.54 216.89,124.67 216.89,125.81
GND on BOTTOM: 198.09,175.72 199.36,175.72 199.87,175.21 199.87,171.91 200.76,171.02 200.76,166.58 201.26,166.07 201.26,161.88 200.76,161.37 199.99,161.37 197.2,164.16 197.2,174.83
GND on BOTTOM: 63.09,40.08 63.09,37.93 63.47,37.54 65.12,37.54 65.25,37.67 65.25,38.94 65.12,39.07 64.1,39.07 63.85,39.32 63.85,40.08 63.72,40.21 63.22,40.21
GND on BOTTOM: 291.43,85.3 295.5,85.3 295.63,85.17 295.63,83.65 295.5,83.52 294.99,83.52 294.61,83.9 293.09,83.9 292.96,84.03 290.04,84.03 289.91,84.15 289.91,84.66 290.04,84.79 291.05,84.79 291.18,84.92 291.18,85.04
GND on BOTTOM: 93.7,99.39 93.7,97.74 97.63,97.74 97.63,99.39
GND on BOTTOM: 43.66,15.19 43.66,12.65 45.94,12.65 45.94,15.19
GND on BOTTOM: 174.47,176.36 174.47,173.31 174.98,172.8 174.98,170.01 175.1,169.88 176.63,169.88 176.88,170.13 176.88,172.55 176.25,173.18 176.25,176.1 175.86,176.48 174.59,176.48
GND on BOTTOM: 68.93,76.28 70.96,76.28 71.09,76.15 71.09,75.01 70.96,74.88 69.06,74.88 68.8,75.14 68.8,76.15
GND on BOTTOM: 299.56,31.7 299.56,29.67 300.02,29.21 302,29.21 302.23,28.98 302.23,20.78 302.61,20.4 310.87,20.4 311.37,20.91 311.37,61.93 310.99,62.31 308.33,62.31 307.82,61.8 307.82,52.53 306.8,51.51 306.8,41.48 307.94,40.34 307.94,39.07 307.56,38.69 307.56,38.43 307.94,38.05 307.94,33.48 306.17,31.7 301.85,31.7 301.72,31.83 299.69,31.83
GND on BOTTOM: 260.19,68.91 262.61,68.91 262.73,68.79 262.73,67.52 260.07,67.52 259.94,67.64 259.94,68.66
GND on BOTTOM: 290.29,80.98 295.24,80.98 295.37,81.11 297.78,81.11 298.04,80.85 298.04,76.66 295.37,76.66 293.09,78.95 290.8,78.95 289.91,79.84 289.91,80.6
GND on BOTTOM: 83.92,11 83.92,8.08 86.71,8.08 86.71,11
GND on BOTTOM: 94.2,64.85 94.58,64.85 94.65,64.79 98.84,64.79 102.08,61.55 106.78,61.55 106.9,61.42 106.9,58.5 106.78,58.37 100.93,58.37 98.01,61.29 94.08,61.29 93.95,61.42 93.57,61.42 93.57,64.21
GND on BOTTOM: 218.92,154.26 218.92,157.69 219.3,158.07 221.46,158.07 221.71,157.81 221.71,154.38 221.33,154 219.17,154
GND on BOTTOM: 273.81,61.04 271.72,61.04 271.27,61.5 271.27,62.79 271.55,63.07 273.98,63.07 274.09,62.97 274.09,61.32
GND on BOTTOM: 186.53,175.59 186.53,168.74 186.91,168.35 188.56,168.35 189.2,168.99 189.2,175.09 188.44,175.85 186.79,175.85
GND on BOTTOM: 279.24,176.61 279.88,176.61 280.26,176.99 280.26,177.63 280.51,177.88 281.66,177.88 281.91,177.63 281.91,175.97 282.04,175.85 282.04,174.96 281.78,174.7 279.37,174.7 278.86,174.2 278.61,174.2 278.35,174.45 278.35,175.85 278.1,176.1 278.1,176.48 278.35,176.74 279.12,176.74
GND on BOTTOM: 263.88,26.11 265.15,26.11 265.53,26.5 265.53,27.89 265.4,28.02 263.75,28.02 263.62,27.89 263.62,26.37
GND on BOTTOM: 257.78,73.87 257.53,73.61 253.84,73.61 253.46,73.99 253.46,76.41 253.72,76.66 257.53,76.66 257.78,76.41
GND on BOTTOM: 110.33,171.78 114.02,171.78 114.65,171.15 114.65,168.48 113.63,167.47 109.95,167.47 109.57,167.85 109.57,171.02
GND on BOTTOM: 267.05,36.4 267.05,33.99 267.3,33.73 267.3,32.97 266.92,32.59 266.92,31.58 266.67,31.32 265.27,31.32 265.15,31.45 263.75,31.45 263.04,32.16 263.04,36.2 263.75,36.91 266.54,36.91
GND on BOTTOM: 288.51,55.83 289.53,54.82 289.53,53.8 289.02,53.29 288.51,53.29 288.39,53.17 288.39,52.78 288.64,52.53 290.29,52.53 290.8,53.04 290.8,56.09 290.55,56.34 288.77,56.34 288.51,56.09
GND on BOTTOM: 262.48,83.01 254.48,83.01 254.41,83.07 251.62,83.07 251.56,83.01 247.49,83.01 245.59,84.92 245.59,85.3 246.1,85.8 246.1,89.11 247.11,90.12 250.67,90.12 251.05,90.5 251.05,97.62 251.94,98.5 265.02,98.5 265.65,97.87 265.65,92.92 264,91.27 264,90.25 265.27,90.25 265.4,90.12 270.99,90.12 271.88,89.23 271.88,84.53 271.37,84.03 271.37,82.88 271.11,82.63 268.57,82.63 268.32,82.88 264.13,82.88 263.75,82.5 262.99,82.5
GND on BOTTOM: 284.58,54.18 284.7,54.05 284.7,47.58 284.32,47.2 280.26,47.2 280.13,47.32 280.13,50.5 280.12,50.51 280.12,53.81 280.49,54.18
GND on BOTTOM: 44.8,60.4 44.8,64.6 44.93,64.72 49.5,64.72 49.63,64.6 49.63,64.34 49.25,63.96 49.25,60.02 49.12,59.9 45.44,59.9 45.05,60.28 44.93,60.28
GND on BOTTOM: 32.1,73.87 32.1,75.14 32.23,75.26 32.23,75.64 31.59,76.28 31.59,76.91 31.72,77.04 31.85,77.04 32.61,76.28 33.37,76.28 33.62,76.03 34.77,76.03 35.15,76.41 35.53,76.41 35.66,76.28 35.66,76.15 35.3,75.8 35.2,75.8 35.1,75.7 34.82,75.7 34.64,75.52 34.64,75.39 34.77,75.26 35.4,75.26 35.53,75.14 35.53,74.12 35.4,73.99 33.37,73.99 33.12,73.74 32.23,73.74
GND on BOTTOM: 302.48,104.35 302.36,104.22 300.71,104.22 300.58,104.35 300.58,107.52 300.71,107.65 302.23,107.65 302.48,107.39
GND on BOTTOM: 291.94,100.28 291.56,99.9 290.8,99.9 290.42,100.28 286.61,100.28 286.35,100.03 286.35,97.62 286.86,97.11 291.43,97.11 291.94,96.6 291.94,91.52 292.32,91.14 295.37,91.14 295.75,91.52 295.75,107.65 295.63,107.78 292.45,107.78 291.94,107.27
GND on BOTTOM: 219.43,151.84 220.44,151.84 220.57,151.72 220.57,150.83 220.44,150.7 219.43,150.7 219.3,150.83 219.3,151.72
GND on BOTTOM: 247.37,51.77 247.37,52.91 247.87,53.42 248.89,53.42 249.02,53.29 249.02,52.15 248.51,51.64 247.49,51.64
GND on BOTTOM: outline of 90 points within 230.09,163.91 276.45,180.29
GND on GND02, GND04, GND09, GND11: outline of 291 points within 0.51,0.51 311.49,205.99 ; 1 cut-out
GND on IN03: 5.18,84.89 7.84,84.89 8.07,84.66 12.49,84.66 12.49,84.66 14.13,84.66 15.32,83.47 15.32,76.99 11.97,73.63 2.98,73.63 1.9,74.7 1.9,79.81 1.9,79.81 1.9,82.25 2.64,82.99 3.89,82.99 3.9,82.98 3.91,82.99 4.03,82.99 4.66,83.61 4.66,84.37
GND on IN03: 1.62,166.7 2.76,167.85 3.78,167.85 4.03,168.1 4.03,174.2 4.67,174.83 18.26,174.83 18.77,174.32 18.77,163.15 17.11,161.5 17.11,150.7 15.59,149.18 14.19,149.18 12.03,147.02 10.13,147.02 8.99,145.88 8.99,143.34 11.78,140.54 11.78,126.7 10.64,125.56 10.64,123.9 10.13,123.4 1.62,123.4 1.11,123.9 1.11,139.78 3.14,141.81 3.14,147.65 1.62,149.18
GND on IN03: 288.39,107.52 295.75,107.52 296.01,107.27 296.01,101.68 295.5,101.17 290.8,101.17 290.55,100.92 290.55,100.28 290.8,100.03 291.69,100.03 291.94,100.28 294.99,100.28 295.75,99.52 295.75,92.79 295.37,92.41 287.37,92.41 286.48,93.3 286.48,105.62
GND on IN03: 269.46,199.85 269.46,194.77 268.7,194.01 262.86,194.01 261.59,195.28 261.59,200.23 261.46,200.36 259.81,200.36 259.56,200.1 259.56,196.8 259.05,196.29 249.91,196.29 249.52,196.68 249.52,200.23 249.4,200.36 247.75,200.36 247.62,200.23 247.62,196.68 247.24,196.29 237.84,196.29 237.46,196.68 237.46,200.1 237.33,200.23 235.68,200.23 235.55,200.1 235.55,196.8 235.05,196.29 225.52,196.29 225.01,196.8 225.01,200.36 224.89,200.49 222.73,200.49 222.35,200.1 222.35,195.66 222.09,195.41 215.87,195.41 212.69,198.58 212.69,200.23 212.82,200.36 221.84,200.36 222.09,200.61 268.7,200.61
GND on IN03: 219.04,89.87 217.77,91.14 217.77,100.54 218.41,101.17 239.49,101.17 240.13,100.54 240.13,92.28 237.71,89.87
GND on IN05: 187.07,188.67 187.98,189.59 190.09,189.59 190.8,188.88 196.51,188.88 197.61,187.79 202.36,187.79 202.64,187.51 208.6,187.51 209.37,186.74 209.37,184.41 208.81,183.85 208.81,179.43 207.28,177.91 168.5,177.91 166.87,179.53 155.67,179.53 155.48,179.72 153.19,179.72 151.86,181.05 151.86,188.17 152.37,188.67
GND on IN05: 218.54,117.43 222.09,117.43 222.22,117.3 222.22,113.49 221.71,112.98 217.65,112.98 217.39,113.24 217.39,116.28
GND on VCC06: outline of 254 points within 1.02,5.82 310.98,205.48 ; 2 cut-outs
GND on VCC07: 207.97,86.57 205.46,89.08 205.46,92.64 204.54,93.55 196.92,93.55 196.31,94.16 196.31,103.31 192.35,107.27 118.08,107.27 118.08,110.46 125.32,117.7 125.32,159.36 131.52,165.56 160.26,165.56 169.13,156.69 169.13,156.57 169.26,156.44 169.26,155.22 169.77,154.71 169.77,152.41 169.26,151.9 169.26,142.88 169.01,142.63 169.01,139.22 169.26,138.97 169.26,138.79 169.77,138.28 169.77,138 170.02,137.75 184.86,137.75 185.52,138.4 185.52,139.91 204.46,139.91 204.95,139.42 204.95,114.66 205.6,114 231.26,114 231.63,113.63 231.63,110.3 234.41,107.52 241.4,107.52 241.78,107.14 241.78,88.96 241.29,88.47 212.46,88.47 210.56,86.57
GND on VCC07: outline of 198 points within 1.02,15.52 137.51,205.48
GND on VCC07: outline of 143 points within 166.85,5.82 310.98,205.48
GND on IN08: 239.49,87.33 236.7,90.12 221.08,90.12 219.68,91.52 219.68,94.69 219.93,94.95 219.93,97.49 220.95,98.5 239.62,98.5 240.63,97.49 240.63,87.96 240,87.33
