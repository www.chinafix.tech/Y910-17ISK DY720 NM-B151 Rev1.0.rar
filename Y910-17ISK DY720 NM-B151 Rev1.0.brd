# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_DPE_TX1_DN: length 189.9
  IN05 w0.102: v3(239.79,123.27) 239.39,122.87 235.66,122.87 235.26,123.27 231.34,123.27 231.19,123.12 227.96,123.12 227.3,123.78 224.91,123.78 224.17,124.51 220.92,124.51 220.57,124.16 204.95,124.16 203.8,123.02 203.8,120.42 200,116.62 193.31,116.62 185.05,108.37 126.42,108.37 125.19,107.14 119.73,107.14 115.29,102.7 101.67,102.7 97,98.02 97,97.11 94.48,94.59 94.48,86.59 92.93,85.04 92.93,83.54 85.57,76.17 85.57,75.01 83.17,72.61 82.92,72.61 v3(82.69,72.39)
  BOTTOM w0.097: v3(239.79,123.27) 240.09,122.97 G2.BF15 ; v3(82.69,72.39) 82.43,72.65 81.76,72.65 C481.1
GPU_DPE_TX1_DP: length 189.8
  IN05 w0.102: v3(82.69,73.19) 82.64,73.19 82.55,73.1 82.55,73.02 82.7,72.87 82.81,72.87 82.81,72.86 83.06,72.86 85.31,75.12 85.31,76.28 92.68,83.65 92.68,85.15 94.23,86.7 94.23,94.7 96.74,97.21 96.74,98.12 101.57,102.95 115.18,102.95 119.62,107.39 125.09,107.39 126.31,108.62 184.95,108.62 193.2,116.88 199.9,116.88 203.55,120.53 203.55,123.12 204.84,124.41 220.46,124.41 220.82,124.77 224.28,124.77 225.01,124.03 227.4,124.03 228.06,123.37 231.08,123.37 231.24,123.52 235.36,123.52 235.76,123.12 238.62,123.12 238.71,123.21 238.71,123.4 238.83,123.51 238.99,123.51 239.09,123.41 v3(239.09,123.27)
  BOTTOM w0.097: v3(82.69,73.19) 82.43,72.92 81.76,72.92 C477.1 ; G2.BG15 239.39,122.97 v3(239.09,123.27)
GPU_DPE_TX2_DN: length 190.1
  IN05 w0.102: v3(82.69,70.61) 82.65,70.65 82.65,70.85 82.76,70.96 83.3,70.96 83.66,71.33 83.66,71.6 89.5,77.44 89.5,78.71 93.82,83.03 93.82,84.66 95.73,86.57 95.73,94.46 97.89,96.62 97.89,97.64 102.06,101.81 116.17,101.81 120.37,106 125.32,106 126.82,107.5 185.41,107.5 193.66,115.76 200.39,115.76 206.83,122.2 207.51,122.2 208.56,123.25 220.21,123.25 220.31,123.14 224.15,123.14 224.4,122.89 226.43,122.89 227.07,122.25 230.83,122.25 230.98,122.1 236.1,122.1 236.35,122.36 240.56,122.36 240.67,122.25 240.67,122.09 240.55,121.97 v3(240.39,121.97)
  BOTTOM w0.097: v3(240.39,121.97) G2.BF14 ; C484.1 81.76,70.87 82.43,70.87 v3(82.69,70.61)
GPU_DPE_TX2_DP: length 190.1
  IN05 w0.102: v3(241.09,121.97) 240.92,122.13 240.92,122.35 240.67,122.61 236.25,122.61 235.99,122.36 231.09,122.36 230.94,122.51 227.17,122.51 226.54,123.14 224.51,123.14 224.25,123.4 220.42,123.4 220.31,123.5 208.45,123.5 207.41,122.46 206.73,122.46 200.28,116.01 193.56,116.01 185.3,107.76 126.72,107.76 125.21,106.25 120.26,106.25 116.07,102.06 101.95,102.06 97.63,97.74 97.63,96.73 95.47,94.57 95.47,86.67 93.57,84.77 93.57,83.14 89.25,78.82 89.25,77.55 83.41,71.71 83.41,71.43 83.19,71.22 82.88,71.22 82.69,71.41 v3(82.69,71.41)
  BOTTOM w0.097: v3(82.69,71.41) 82.43,71.15 81.76,71.15 C478.1 ; v3(241.09,121.97) G2.BE14
GPU_DPE_TX3_DN: length 190.9
  IN05 w0.102: v3(82.69,68.83) 83.01,69.15 84.08,69.15 84.55,69.62 84.55,71.22 90.39,77.06 90.39,78.18 95.6,83.39 95.6,84.92 96.62,85.93 96.62,94.06 98.78,96.22 98.78,97.26 102.44,100.92 117.19,100.92 121.38,105.11 125.83,105.11 127.35,106.63 185.77,106.63 194.03,114.89 200.74,114.89 207.11,121.26 208.1,121.26 209.22,122.38 218.79,122.38 220.19,120.98 221.58,120.98 222.47,121.87 225.78,121.87 225.9,121.75 225.9,121.24 226.41,120.73 227.43,120.73 228.06,121.36 230.07,121.36 230.22,121.52 236.5,121.52 236.81,121.83 237.59,121.83 237.98,121.45 238.57,121.45 v3(239.09,121.97)
  BOTTOM w0.097: v3(239.09,121.97) 239.09,122.05 239.3,122.27 G2.BG14 ; C482.1 81.76,69.09 82.43,69.09 v3(82.69,68.83)
GPU_DPE_TX3_DP: length 190.9
  IN05 w0.102: v3(82.69,69.63) 82.61,69.72 82.61,69.87 82.71,69.98 82.99,69.98 83.11,69.86 83.11,69.55 83.26,69.4 83.97,69.4 84.3,69.73 84.3,71.33 90.14,77.17 90.14,78.29 95.35,83.5 95.35,85.02 96.36,86.04 96.36,94.17 98.52,96.32 98.52,97.36 102.33,101.17 117.08,101.17 121.28,105.36 125.72,105.36 127.24,106.89 185.66,106.89 193.92,115.14 200.63,115.14 207.01,121.52 208,121.52 209.11,122.63 218.9,122.63 220.29,121.24 221.48,121.24 222.37,122.13 225.88,122.13 226.16,121.85 226.16,121.34 226.52,120.98 227.32,120.98 227.96,121.62 229.96,121.62 230.11,121.77 236.39,121.77 236.71,122.09 237.7,122.09 238.08,121.7 238.37,121.7 238.44,121.76 v3(238.44,121.89)
  BOTTOM w0.097: v3(82.69,69.63) 82.43,69.37 81.76,69.37 C483.1 ; G2.BH14 238.44,122.02 v3(238.44,121.89)
GPU_DPF_AUX_DN: length 213
  TOP w0.097: R927.1 235.55,119.15 v3(235.48,119.08)
  IN05 w0.102: v3(235.48,119.08) 235.39,118.99 235.39,118.53 234.03,117.17 234.03,115.27 231.62,112.86 231.62,109.58 229.72,107.67 222.12,107.67 221.89,107.9 217.65,107.9 215.36,105.62 213.71,105.62 213.33,105.24 209.92,105.24 209.03,106.12 194.64,106.12 188.42,99.9 135.99,99.9 125.95,89.87 125.95,81.32 122.94,78.3 105.52,78.3 105.2,78.62 103.52,78.62 97.76,72.85 95.6,72.85 93.31,70.56 93.31,67.28 88.09,62.06 73.83,62.06 70.07,65.81 70.07,67.82 69.23,68.66 65.9,68.66 65.56,69 65.56,69.36 v1(65.37,69.55)
  BOTTOM w0.097: v1(65.37,69.55) C582.1 ; v3(235.48,119.08) 235.22,118.82 235.22,118.66 235.44,118.44 235.89,118.44 235.99,118.54 235.99,118.71 235.93,118.77 G2.BM9
GPU_DPF_AUX_DP: length 213
  TOP w0.097: v3(234.84,119.08) 234.84,119.54 R926.1
  IN05 w0.102: v3(234.84,119.08) 234.96,119.08 235.13,118.91 235.13,118.64 233.78,117.28 233.78,115.37 231.36,112.96 231.36,109.68 229.61,107.93 222.22,107.93 221.99,108.16 217.54,108.16 215.26,105.87 213.6,105.87 213.22,105.49 210.03,105.49 209.14,106.38 194.53,106.38 188.31,100.16 135.88,100.16 125.7,89.97 125.7,81.42 122.83,78.56 105.62,78.56 105.31,78.87 103.42,78.87 97.65,73.1 95.49,73.1 93.06,70.67 93.06,67.39 87.98,62.31 73.93,62.31 70.33,65.91 70.33,67.93 69.34,68.91 66.01,68.91 65.82,69.1 65.82,69.67 65.93,69.78 66.15,69.78 66.26,69.67 v1(66.26,69.55)
  BOTTOM w0.097: v3(234.84,119.08) 234.93,118.99 234.93,118.56 235.32,118.17 235.78,118.17 G2.BM8 ; v1(66.26,69.55) C583.1
GPU_DPF_HPD: length 227.7
  TOP w0.097: R991.1 244.52,99.9 v2(242.92,99.9) 241.9,99.9 241.47,99.47 241.47,92.79 240.63,91.95 240.63,86.82 v1(240.13,86.31)
  IN05 w0.091: v1(240.13,86.31) 238.63,87.81 214.47,87.81 213.56,88.73 213.56,90.02 211.17,92.41 208.12,92.41 205.58,94.95 177.64,94.95 176.53,93.84 138.69,93.84 135.22,90.38 135.22,87.71 134.46,86.95 129.38,86.95 128.62,86.19 128.62,80.15 123.99,75.52 109.95,75.52 108.68,74.25 105.5,74.25 104.86,73.6 103.97,73.6 97.77,67.4 97.77,65.62 97.12,64.98 96.25,64.98 94.88,63.6 94.88,62.57 94.46,62.15 94.46,61.55 92.24,59.33 76.11,59.33 74.65,57.86 74.65,57.23 v1(74.14,56.72)
  BOTTOM w0.097: U2014.9 64.38,57.76 64.06,57.44 63.81,57.44 63.47,57.1 R942.1 64.15,56.42 64.36,56.21 64.36,54.84 64.89,54.31 67.53,54.31 68.04,53.8 69.69,53.8 72.61,56.72 v1(74.14,56.72)
GPU_DPF_HPD_R: length 16.7
  TOP w0.097: v1(242.41,111.84) 243.05,111.84 244.95,109.93 244.95,106.53 244.29,105.87 243.94,105.87 243.81,105.74 243.81,105.11 243.34,104.64 v2(243.34,104.47) 244.27,104.47 R990.2 244.58,104.39 Q76.3
  IN10 w0.091: v3(241.79,115.67) 242.92,114.53 242.92,112.35 v1(242.41,111.84)
  BOTTOM w0.097: v3(241.79,115.67) G2.BD5
GPU_DPF_TX0_DN: length 204
  IN05 w0.102: v3(232.25,120.48) 231.85,120.07 230.96,120.07 230.73,119.84 229.94,119.84 228.93,118.82 226.54,118.82 226.28,118.57 219.55,118.57 218.23,119.89 212.39,119.89 212.12,120.16 209.71,120.16 208.48,118.93 207.26,118.93 206.65,118.32 206.65,117.2 202.43,112.98 194.91,112.98 186.68,104.75 128.64,104.75 127.22,103.33 122.52,103.33 118.33,99.14 107.11,99.14 105.13,97.15 105.13,94.82 101.95,91.65 101.95,91.41 101.55,91.01 98.9,91.01 98.52,90.63 98.52,80.98 97.12,79.58 94.58,79.58 92.17,77.17 92.17,76.3 88.92,73.05 88.92,69 87.08,67.16 79.12,67.16 78.96,67.01 78.96,64.85 78.37,64.26 75.36,64.26 v1(75.15,64.05)
  BOTTOM w0.097: C487.1 72.13,64.29 74.91,64.29 v1(75.15,64.05) ; G2.BK14 236.95,121.93 236.4,121.93 236.15,121.69 235.56,121.69 235.25,122 232.76,122 232.25,121.49 v3(232.25,120.48)
GPU_DPF_TX0_DP: length 204
  IN05 w0.102: v3(231.62,120.48) 231.46,120.32 230.85,120.32 230.62,120.09 229.84,120.09 228.82,119.08 226.43,119.08 226.18,118.82 219.66,118.82 218.34,120.15 212.49,120.15 212.22,120.42 209.61,120.42 208.37,119.18 207.15,119.18 206.39,118.42 206.39,117.31 202.32,113.24 194.81,113.24 186.57,105 128.53,105 127.12,103.58 122.42,103.58 118.23,99.39 107,99.39 104.87,97.26 104.87,94.93 101.7,91.75 101.7,91.52 101.44,91.27 98.8,91.27 98.27,90.74 98.27,81.08 97.02,79.84 94.48,79.84 91.92,77.27 91.92,76.41 88.67,73.16 88.67,69.1 86.98,67.42 79.01,67.42 78.71,67.11 78.71,64.96 78.27,64.51 75.66,64.51 75.59,64.59 75.59,65.07 75.47,65.19 75.24,65.19 75.15,65.1 v1(75.15,64.89)
  BOTTOM w0.097: G2.BL14 236.49,122.36 236.32,122.36 236.25,122.29 236.25,122.17 236.04,121.96 235.68,121.96 235.36,122.27 232.65,122.27 231.98,121.61 231.98,120.74 231.71,120.48 v3(231.62,120.48) ; v1(75.15,64.89) 74.83,64.56 72.09,64.56 C488.1
GPU_DPF_TX1_DN: length 201.7
  IN05 w0.102: v1(80.11,65.57) 80.31,65.78 81.14,65.78 81.66,66.3 87.44,66.3 89.81,68.67 89.81,72.65 93.06,75.9 93.06,76.66 94.33,77.93 96.72,77.93 99.41,80.62 99.41,88.98 100.55,90.12 103.2,90.12 103.98,90.91 103.98,91.8 110.06,97.87 118.38,97.87 122.95,102.43 127.76,102.43 129.16,103.83 187.06,103.83 194.93,111.7 202.68,111.7 208,117.02 208,117.43 208.63,118.06 209.63,118.06 210.42,118.85 215.87,118.85 217.03,117.68 225.52,117.68 225.65,117.55 229.1,117.55 230.75,119.21 231.03,119.21 231.34,119.51 232.29,119.51 232.61,119.83 233.78,119.83 234.28,120.33 v3(234.28,120.48)
  BOTTOM w0.097: v3(234.28,120.48) 234.19,120.48 233.92,120.74 233.92,121.06 234.06,121.19 234.47,121.19 234.55,121.11 234.55,120.91 234.64,120.83 234.76,120.83 234.84,120.91 234.84,121.11 234.93,121.19 235.05,121.19 235.13,121.11 235.13,120.91 235.22,120.83 235.34,120.83 235.42,120.91 235.42,121.11 235.51,121.19 236.11,121.19 236.43,120.87 G2.BL12 ; C489.1 72.11,62.36 76.48,62.36 78.84,64.72 78.84,65.61 79.08,65.86 79.82,65.86 v1(80.11,65.57)
GPU_DPF_TX1_DP: length 201.7
  IN05 w0.102: v3(233.65,120.48) 233.76,120.48 233.85,120.38 233.85,120.26 233.67,120.08 232.51,120.08 232.19,119.76 231.23,119.76 230.93,119.46 230.65,119.46 228.99,117.81 225.75,117.81 225.63,117.94 217.14,117.94 215.97,119.1 210.31,119.1 209.52,118.32 208.52,118.32 207.74,117.53 207.74,117.13 202.57,111.96 194.82,111.96 186.95,104.08 129.05,104.08 127.65,102.69 122.84,102.69 118.28,98.12 109.95,98.12 103.73,91.9 103.73,91.01 103.09,90.38 100.45,90.38 99.16,89.09 99.16,80.72 96.62,78.18 94.22,78.18 92.81,76.77 92.81,76 89.55,72.75 89.55,68.77 87.33,66.55 81.55,66.55 81.04,66.03 80.13,66.03 80.02,66.15 80.02,66.33 v1(80.11,66.41)
  BOTTOM w0.097: G2.BK12 237.06,120.87 236.73,121.19 236.49,121.19 236.22,121.47 233.95,121.47 233.65,121.17 v3(233.65,120.48) ; C485.1 72.11,62.64 76.37,62.64 78.56,64.83 78.56,65.73 78.97,66.13 79.82,66.13 v1(80.11,66.41)
GPU_DPF_TX2_DN: length 202.7
  IN05 w0.102: v1(81,64.18) 81.14,64.32 81.93,64.32 82.41,63.83 87.42,63.83 91.56,67.98 91.56,71.73 95.22,75.39 96.87,75.39 103.73,82.25 103.73,83.52 106.83,86.62 106.83,90.17 107.67,91.01 112.62,91.01 117.06,95.46 118.79,95.46 124,100.66 128.49,100.66 129.89,102.06 187.89,102.06 195.64,109.81 203.55,109.81 207.74,114 208.48,114 209.52,115.04 209.52,115.54 209.88,115.9 211.06,115.9 211.19,115.78 215.26,115.78 215.73,115.3 215.73,112.74 216.89,111.59 217.39,111.59 218.61,110.37 221.73,110.37 226.48,115.12 229.17,115.12 231.61,117.55 233.01,117.55 233.78,118.32 233.78,119.13 234.13,119.48 235.63,119.48 236.13,119.98 236.13,120.39 v3(236.24,120.5)
  BOTTOM w0.097: G2.BM11 235.89,120.22 236.16,120.5 v3(236.24,120.5) ; C492.1 72.11,60.59 76.35,60.59 80.22,64.46 80.71,64.46 v1(81,64.18)
GPU_DPF_TX2_DP: length 202.7
  IN05 w0.102: v1(81,65.02) 81,64.82 81.24,64.58 82.03,64.58 82.52,64.09 87.31,64.09 91.31,68.08 91.31,71.84 95.11,75.64 96.76,75.64 103.47,82.35 103.47,83.62 106.57,86.72 106.57,90.28 107.56,91.27 112.51,91.27 116.96,95.71 118.68,95.71 123.89,100.92 128.39,100.92 129.78,102.31 187.78,102.31 195.53,110.06 203.44,110.06 207.64,114.25 208.38,114.25 209.27,115.14 209.27,115.65 209.77,116.16 211.17,116.16 211.3,116.03 215.36,116.03 215.99,115.41 215.99,112.84 216.99,111.84 217.5,111.84 218.72,110.62 221.63,110.62 226.38,115.37 229.06,115.37 231.5,117.81 232.91,117.81 233.52,118.42 233.52,119.23 234.02,119.73 235.52,119.73 235.87,120.09 235.87,120.3 235.68,120.5 v3(235.53,120.5)
  BOTTOM w0.097: G2.BM12 235.89,120.86 v3(235.53,120.5) ; v1(81,65.02) 80.71,64.73 80.11,64.73 76.24,60.86 v1(74.17,60.86) 72.11,60.86 C486.1
GPU_DPF_TX3_DN: length 205.1
  IN05 w0.102: v1(82.93,64.81) 83.15,65.03 87.39,65.03 90.7,68.33 90.7,72.27 93.95,75.52 93.95,76.28 94.46,76.79 97,76.79 101.82,81.61 101.82,83.52 102.46,84.15 102.46,88.09 104.87,90.5 104.87,90.88 106.33,92.35 107.73,92.35 108.43,93.04 110.2,93.04 111.6,94.45 111.6,95.31 112.89,96.6 118.61,96.6 123.57,101.55 128.12,101.55 129.52,102.95 187.42,102.95 195.3,110.82 203.04,110.82 209.01,116.79 213.12,116.79 213.25,116.67 216.35,116.67 216.76,116.26 216.76,113.13 217.41,112.47 222.62,112.47 226.15,116.01 228.8,116.01 231.13,118.34 232.38,118.34 232.73,118.7 232.73,118.92 v3(232.89,119.08)
  BOTTOM w0.097: v1(82.93,64.81) 82.65,65.09 82.47,65.09 82.27,64.88 82.27,63.12 77.96,58.81 72.11,58.81 C490.1 ; v3(232.89,119.08) 232.81,119.16 232.81,119.42 232.97,119.59 236.27,119.59 236.52,119.84 236.77,119.84 237.1,120.17 G2.BK11
GPU_DPF_TX3_DP: length 205.1
  IN05 w0.102: v1(82.93,65.65) 82.86,65.59 82.86,65.41 82.99,65.28 87.29,65.28 90.44,68.44 90.44,72.37 93.7,75.62 93.7,76.39 94.35,77.04 96.89,77.04 101.57,81.72 101.57,83.62 102.2,84.26 102.2,88.2 104.62,90.61 104.62,90.99 106.23,92.6 107.62,92.6 108.32,93.3 110.09,93.3 111.35,94.56 111.35,95.41 112.79,96.85 118.51,96.85 123.46,101.81 128.02,101.81 129.42,103.2 187.32,103.2 195.19,111.08 202.94,111.08 208.91,117.05 213.23,117.05 213.35,116.92 216.46,116.92 217.01,116.36 217.01,113.24 217.52,112.73 222.51,112.73 226.05,116.26 228.69,116.26 231.03,118.6 232.28,118.6 232.48,118.8 232.48,119 232.4,119.08 v3(232.25,119.08)
  BOTTOM w0.097: v1(82.93,65.65) 82.65,65.37 82.36,65.37 81.99,65 81.99,63.23 77.84,59.08 72.11,59.08 C491.1 ; G2.BL11 236.46,120.17 236.16,119.86 235.54,119.86 235.42,119.98 235.16,119.98 235.03,119.86 234.77,119.86 234.65,119.98 234.38,119.98 234.26,119.86 232.86,119.86 232.53,119.54 232.53,119.22 232.39,119.08 v3(232.25,119.08)
GPU_DRON: length 93.7
  TOP w0.254: v1(288.64,186.52) 288.64,186.19 289.2,185.63 PU1605.12
  IN08 w0.254: v1(222.6,202.26) 223.24,202.26 224.25,201.25 226.41,201.25 227.93,202.77 231.36,202.77 232,202.14 v1(235.02,202.14) 236.16,200.99 237.84,200.99 239.62,202.77 244.44,202.77 245.21,202.01 246.6,202.01 v1(246.98,202.39) 248.25,201.12 250.54,201.12 252.19,202.77 257.14,202.77 257.91,202.01 259.05,202.01 v1(259.3,202.26) 259.94,202.26 261.02,201.18 263.3,201.18 264.89,202.77 268.96,202.77 269.72,202.01 271.39,202.01 v1(272.46,200.94) 272.46,199.27 276.83,194.9 286.23,194.9 288.2,192.93 289.08,192.93 292.07,189.94 292.07,186.9 291.31,186.13 289.02,186.13 v1(288.64,186.52)
  BOTTOM w0.254: PR906.1 v1(259.3,202.26) ; PR922.1 v1(272.46,200.94) ; PR1007.1 v1(222.6,202.26) ; PR1024.1 234.92,202.04 v1(235.02,202.14)
  BOTTOM w0.305: PR3533.1 v1(246.98,202.39)
GPU_EDP_AUX_DN: length 112.6
  TOP w0.102: v3(240.39,119.87) 240,119.48 240,118.82 240.33,118.49 R920.1
  IN03 w0.102: v3(240.39,119.87) 240.6,120.08 240.6,120.65 240.52,120.73 238.3,120.73 238.07,120.5 236.99,120.5 236.26,121.24 232.15,121.24 230.72,122.67 230.72,123.54 229.84,124.41 227.3,124.41 226.69,123.8 223.34,123.8 221.71,125.43 215.89,125.43 212.96,128.36 211.81,128.36 209.63,130.54 209.63,146.93 208.9,147.66 208.9,158.44 209.27,158.81 209.27,162.26 208.38,163.15 208.38,175.32 210.2,177.14 210.2,181.05 209.27,181.99 209.27,185.78 208.25,186.79 208.25,189.47 206.38,191.34 200.63,191.34 199.55,192.42 199.55,193.18 v3(199.33,193.4)
  BOTTOM w0.097: v3(199.33,193.4) 199.52,193.59 199.52,193.92 C425.1 ; v3(240.39,119.87) G2.BF11
GPU_EDP_AUX_DP: length 112.6
  TOP w0.102: v3(241.09,119.87) 241.09,119.64 241.4,119.33 241.73,119.33 R921.1
  IN03 w0.102: v3(241.09,119.87) 240.86,120.1 240.86,120.76 240.63,120.98 238.19,120.98 237.96,120.76 237.1,120.76 236.36,121.49 232.25,121.49 230.97,122.77 230.97,123.64 229.94,124.67 227.19,124.67 226.58,124.06 223.44,124.06 221.82,125.68 216,125.68 213.06,128.62 211.92,128.62 209.89,130.65 209.89,147.03 209.15,147.77 209.15,158.33 209.52,158.7 209.52,162.36 208.63,163.25 208.63,175.21 210.45,177.04 210.45,181.16 209.52,182.09 209.52,185.88 208.5,186.9 208.5,189.58 206.49,191.6 200.73,191.6 199.8,192.53 199.8,193.23 v3(199.97,193.4)
  BOTTOM w0.097: v3(199.97,193.4) 199.8,193.57 199.8,193.89 C424.1 ; v3(241.09,119.87) G2.BE11
GPU_EDP_BL_EN_LS: length 147
  TOP w0.097: U2029.2 208.12,164.42 208,164.54 207.61,164.54 207.47,164.4 U2029.1 207.47,163.39 207.03,162.94 R2307.1 207.03,161.27 v1(208.63,159.67)
  IN05 w0.091: v1(207.11,95.22) 207.87,94.46 207.87,93.55 208.76,92.66 211.25,92.66 213.78,90.13 213.78,88.96 214.71,88.03 237.91,88.03 240.01,90.13 240.01,104.49 241.78,106.25 241.78,108.16 243.31,109.69 243.31,112.59 242.87,113.03 242.87,113.16 v3(242.54,113.49)
  IN08 w0.091: v1(207.11,95.22) 207.87,95.98 207.87,97.74 207.36,98.25 206.73,98.25 206.6,98.38 206.6,99.27 206.83,99.5 207.26,99.5 208.65,100.88 208.65,103.56 210.54,105.45 210.54,113.76 208.64,115.65 203.67,115.65 202.78,116.54 202.78,143.33 209.14,149.69 209.14,159.16 v1(208.63,159.67)
  BOTTOM w0.097: v3(242.54,113.49) 242.86,113.17 G2.BB1
GPU_EDP_BL_EN_R: length 1.8
  TOP w0.097: U2029.4 208.77,166.16 R2304.2 R985.1
GPU_EDP_BL_PWM_LS: length 188.1
  TOP w0.097: v1(207.74,193.12) 207.23,192.61 v1(206.34,192.61) 205.2,192.61 204.95,192.87 204.95,194.26 205.2,194.52 205.2,195.74 R2305.1 204.83,196.1 U2027.1 U2027.2
  IN05 w0.091: v1(207.11,96.47) 210.41,96.47 213.08,93.81 213.08,93.04 213.51,92.61 216.43,92.61 218.17,90.87 237.83,90.87 238.35,91.39 238.35,104.47 240.13,106.25 240.13,111.08 241.14,112.09 241.14,117.17 241.4,117.43 v3(241.4,117.81)
  IN08 w0.091: v1(207.11,96.47) 207.61,96.98 207.61,97.62 207.23,98 206.6,98 206.34,98.25 206.34,99.39 206.67,99.72 207.18,99.72 208.43,100.97 208.43,103.65 210.28,105.51 210.28,113.7 208.55,115.44 203.51,115.44 202.53,116.41 202.53,143.46 208.88,149.81 208.88,158.42 207.49,159.81 207.49,169.5 208.76,170.77 208.76,171.91 210.5,173.65 210.5,182.71 210.76,182.97 210.76,192.13 210.65,192.24 210.65,194.52 210.52,194.64 208.12,194.64 207.74,194.26 v1(207.74,193.12)
  BOTTOM w0.1: G2.BD7 241.49,117.4 241.4,117.49 v3(241.4,117.81)
GPU_EDP_BL_PWM_R: length 7.9
  TOP w0.097: v2(201.9,199.98) 202.14,199.74 U2027.4 203.82,199.74 204.44,200.36 205.07,200.36 205.38,200.05 205.38,197.69 R2300.2 R979.1
GPU_EDP_HPD: length 97.4
  TOP w0.097: v1(203.68,127.97) 203.75,128.04 R998.1
  IN08 w0.091: v1(203.68,127.97) 203.68,128.73 203.55,128.86 203.55,142.95 209.9,149.3 209.9,160.23 209.09,161.03 208.33,161.03 208,161.37 208,169.12 209.27,170.39 209.27,171.71 211.04,173.49 211.04,182.58 212.06,183.59 212.06,191.98 211.12,192.92 211.12,194.05 211.4,194.34 211.88,194.34 212.06,194.52 212.06,195.28 209.52,197.82 209.01,197.82 207.23,199.6 195.55,199.6 194.15,200.99 v1(194.03,200.99)
  BOTTOM w0.097: JEDP1.25 194.57,200.2 194.03,200.74 v1(194.03,200.99)
GPU_EDP_HPD_R: length 57.6
  TOP w0.097: v1(205.84,117.96) 205.05,117.96 v2(204.95,118.06) 204.19,118.06 203.42,118.82 203.42,122.89 200.55,125.76 R995.2 200.38,128.26 Q75.3
  BOTTOM w0.097: G2.BH1 238.73,113.12 238.73,112.57 238.45,112.3 235.73,112.3 234.03,114 232.38,114 232,114.38 225.65,114.38 224,112.73 221.2,112.73 220.57,112.09 218.7,112.09 217.3,110.7 216.84,110.7 216.62,110.92 216.62,112.24 216.5,112.35 216.5,116.28 216,116.79 213.58,116.79 212.06,118.32 207.74,118.32 206.98,119.08 206.47,119.08 205.84,118.44 v1(205.84,117.96)
GPU_EDP_TX0_DN: length 105
  IN03 w0.102: v3(233.01,122.76) 232.93,122.76 232.77,122.92 232.77,124 230.83,125.94 223.21,125.94 222.32,126.83 216.5,126.83 213.71,129.62 212.44,129.62 210.78,131.28 210.78,148.04 210.15,148.66 210.15,157.69 210.59,158.13 210.59,162.94 209.63,163.9 209.63,166.69 210.66,167.72 210.66,174.98 211.71,176.02 211.71,181.91 211.06,182.55 211.06,185.86 209.39,187.53 209.39,190.4 207.18,192.61 202.66,192.61 202.27,193 202.27,195.23 v1(202.42,195.38)
  BOTTOM w0.097: v1(202.42,195.38) 202.42,195.39 202.12,195.69 202.12,195.93 C422.1 ; G2.BM17 235.97,124.45 235.97,124.57 235.86,124.67 233.54,124.67 232.73,123.87 232.73,122.95 232.93,122.76 v3(233.01,122.76)
GPU_EDP_TX0_DP: length 105
  IN03 w0.102: v1(201.6,195.38) 202.01,194.98 202.01,192.9 202.55,192.36 207.08,192.36 209.14,190.3 209.14,187.43 210.81,185.76 210.81,182.45 211.45,181.8 211.45,176.13 210.41,175.09 210.41,167.83 209.38,166.8 209.38,163.79 210.34,162.83 210.34,158.24 209.9,157.8 209.9,148.55 210.52,147.93 210.52,131.18 212.33,129.37 213.6,129.37 216.4,126.57 222.22,126.57 223.11,125.68 230.73,125.68 232.52,123.89 232.52,122.9 v3(232.38,122.76)
  BOTTOM w0.097: v3(232.38,122.76) 232.46,122.84 v1(232.46,123.41) 232.46,123.99 233.42,124.95 235.77,124.95 G2.BM18 ; v1(201.6,195.38) 201.85,195.63 201.85,195.89 C423.1
GPU_EDP_TX1_DN: length 104.8
  IN03 w0.102: v1(204.02,195.31) 203.68,194.96 203.68,194.39 204.06,194.01 208,194.01 208.52,193.49 208.52,192.98 210.34,191.15 210.34,188.1 210.53,187.91 211.81,187.91 212.44,187.28 212.44,183.32 213.33,182.43 213.33,174.96 213.33,174.96 213.33,174.94 213.77,174.49 213.77,170.98 211.93,169.14 211.93,167.57 210.65,166.29 210.65,164.37 211.68,163.34 211.68,131.78 212.88,130.57 214.39,130.57 216.32,128.64 222.51,128.64 224.07,127.07 231.73,127.07 234.81,124 234.81,122.99 v3(235.05,122.74)
  BOTTOM w0.097: v3(235.05,122.74) 234.94,122.85 234.94,123.25 235.31,123.63 236.04,123.63 236.39,123.98 236.89,123.98 G2.BK17 ; C421.1 203.82,195.85 203.82,195.51 v1(204.02,195.31)
GPU_EDP_TX1_DP: length 104.9
  IN03 w0.102: v3(234.28,122.76) 234.4,122.76 234.55,122.91 234.55,123.89 231.62,126.82 223.97,126.82 222.4,128.39 216.21,128.39 214.28,130.32 212.78,130.32 211.42,131.67 211.42,163.24 210.4,164.26 210.4,166.4 211.68,167.68 211.68,169.24 213.52,171.09 213.52,174.39 213.08,174.83 213.08,174.85 213.07,174.86 213.07,182.33 212.19,183.21 212.19,187.17 211.7,187.66 210.43,187.66 210.09,187.99 210.09,191.05 208.26,192.87 208.26,193.38 207.89,193.75 203.95,193.75 203.42,194.28 203.42,195.09 v1(203.2,195.31)
  BOTTOM w0.097: v3(234.28,122.76) 234.36,122.68 234.57,122.68 234.66,122.77 234.66,123.36 235.2,123.9 235.92,123.9 236.27,124.25 236.47,124.25 G2.BL17 ; C419.1 203.54,195.97 203.54,195.65 v1(203.2,195.31)
GPU_EDP_VDD_EN_LS: length 160.2
  TOP w0.097: U2028.2 208.99,200.38 209.14,200.23 209.52,200.23 209.65,200.36 209.65,200.87 U2028.1 210.14,200.88 v1(210.66,200.36) 211.09,199.93 R2306.1
  IN05 w0.091: v3(238.39,114.87) 238.33,114.87 237.71,114.25 237.71,112.47 237.33,112.09 236.44,112.09 235.55,111.2 235.55,110.44 234.79,109.68 234.41,109.68 232.32,107.59 232.32,105.57 232.07,105.32 219.69,105.32 217.19,102.82 210.92,102.82 207.36,99.27 207.33,99.27 207.11,99.04 v1(207.11,99.01)
  IN08 w0.091: v1(211.55,194.77) 211.42,194.77 210.87,194.22 210.87,192.48 210.99,192.36 210.99,182.85 210.72,182.58 210.72,173.47 209.01,171.77 209.01,170.51 207.74,169.24 207.74,160.61 208.25,160.1 209.01,160.1 209.39,159.72 209.39,149.56 203,143.17 203,116.96 204.05,115.91 208.7,115.91 210.75,113.85 210.75,105.36 208.86,103.47 208.86,100.79 207.11,99.03 v1(207.11,99.01)
  BOTTOM w0.097: v1(210.66,200.36) 211.93,199.09 211.93,196.04 211.6,195.71 R781.1 211.3,195.02 v1(211.55,194.77) ; v3(238.39,114.87) 238.69,114.57 G2.BH3
GPU_EDP_VDD_EN_R: length 6.3
  TOP w0.097: U2028.4 208.34,199.18 207.87,198.71 207.74,198.71 207.36,198.33 207.36,194.82 R905.1 206.45,193.91 R2302.2
GPU_EDPC_OUTPUT_CAP: length 247
  IN05 w0.091: v1(304.9,83.72) 304.9,91.27 305.02,91.39 305.02,91.9 306.29,93.17 306.7,93.17 307.56,94.03 307.56,102.44 306.66,103.35 304.02,103.35 303.01,104.36 303.01,106.58 304.21,107.78 305.15,107.78 306.42,109.05 306.42,110.82 305.79,111.46 305.79,121.47 306.67,122.36 306.67,171.02 301.47,176.23 301.47,180.29 300.32,181.44 300.32,183.09 300.96,183.72 300.96,191.09 296.13,195.91 296.13,196.55 296.39,196.8 298.29,196.8 298.55,197.06 298.55,197.69 298.04,198.2 295.37,198.2 v1(295.24,198.07)
  IN10 w0.091: v1(304.9,83.72) 304.54,83.36 298,83.36 296.75,82.11 278.24,82.11 277.85,82.5 266.56,82.5 266.16,82.11 251.32,82.11 250.69,82.74 243.07,82.74 241.4,84.41 241.4,98.08 244.44,101.13 244.44,105.24 244.96,105.75 244.96,109.69 246.86,111.59 246.86,111.97 245.37,113.45 v3(244.62,113.45)
  BOTTOM w0.097: v1(295.24,198.07) 295.12,197.95 292.65,197.95 v2(291.82,197.11) 288.34,193.63 PR3560.1
  BOTTOM w0.1: G2.BA3 243.94,114.22 243.94,113.79 244.27,113.45 v3(244.62,113.45)
GPU_EVENT_N: length 125.9
  TOP w0.097: R112.1 229.2,48.09 v3(230.09,48.97)
  IN05 w0.091: v1(207.11,97.49) 207.87,97.49 208.76,98.38 208.76,99.01 211.55,101.81 217.58,101.81 219.98,104.21 234.47,104.21 235.05,104.78 235.05,107.65 238.48,111.08 238.48,111.2 v1(238.6,111.33)
  IN08 w0.091: v1(207.11,97.49) 206.85,97.49 205.44,96.08 205.44,74.26 206.85,72.85 206.85,65.99 209.36,63.49 209.36,49.1 210.37,48.09 213.2,48.09 216.38,44.91 223.36,44.91 227.43,48.97 v3(230.09,48.97)
  BOTTOM w0.097: v1(238.6,111.33) 239.49,111.33 240.25,110.57 240.25,109.17 240.46,108.97 R973.2 241.16,108.97 241.27,109.08 D52.1 ; U2.BB36 230.99,52.78 231.24,52.53 231.24,52.52 231.27,52.49 231.27,50.66 230.73,50.12 230.73,49.61 v3(230.09,48.97)
GPU_EVENT_N_R: length 6.8
  BOTTOM w0.097: R973.1 241.27,109.88 241.38,109.78 D52.2 243.28,109.78 R974.2 243.3,109.93 v2(242.29,110.95) 241.49,111.75 G2.BD1
GPU_FB: length 9.5
  TOP w0.254: PR3571.2 PC1429.1 PR1463.2 ; PR1463.2 295.37,177.93 PR1462.1 295.88,178.82 ; PR1463.2 PR3585.2 ; 295.88,178.82 295.93,178.87 295.93,180.22 295.6,180.55 294.25,180.55 293.6,181.2 PU1605.29 ; 295.88,178.82 PC1430.2
GPU_FSW: length 2.4
  TOP w0.254: PR1460.1 293.59,180.1 292.8,180.9 PU1605.27
GPU_HDMI_CLK_DN: length 1.5
  BOTTOM w0.081: C2410.1 84.55,82.84 83.71,82.84 83.66,82.8 U2019.14
GPU_HDMI_CLK_DP: length 1.5
  BOTTOM w0.081: U2019.13 83.69,83.3 83.83,83.15 84.66,83.15 C2164.1
GPU_HDMI_DATA0_DN: length 1.5
  BOTTOM w0.081: U2019.11 83.4,84.35 84.57,84.35 C2414.1
GPU_HDMI_DATA0_DP: length 1.5
  BOTTOM w0.081: C2163.1 84.64,84.66 83.48,84.66 U2019.10
GPU_HDMI_DATA1_DN: length 1.5
  BOTTOM w0.081: U2019.8 83.42,85.87 84.58,85.87 C2412.1
GPU_HDMI_DATA1_DP: length 1.5
  BOTTOM w0.081: U2019.7 83.47,86.18 84.63,86.18 C2413.1
GPU_HDMI_DATA2_DN: length 1.5
  BOTTOM w0.081: C2411.1 84.59,87.38 83.43,87.38 U2019.5
GPU_HDMI_DATA2_DP: length 1.5
  BOTTOM w0.081: U2019.4 83.45,87.69 84.62,87.69 C2165.1
GPU_HDMI_DDC_CLK: length 309.4
  IN05 w0.091: v1(7.34,121.11) 7.51,120.93 7.51,119.3 9.49,117.32 16.36,117.32 16.89,116.79 21.43,116.79 37.18,101.04 37.18,95.35 38.21,94.32 39.61,92.92 44.8,92.92 46.2,91.52 50.64,91.52 51.4,92.28 52.18,92.28 52.55,91.92 52.55,91.65 52.93,91.26 53.71,91.26 54.22,90.76 54.83,90.76 55.6,90 55.6,88.74 63.87,80.47 66.77,80.47 67.91,79.33 67.91,77.53 65.63,75.24 65.63,73.48 64.41,72.26 64.41,68.36 65.12,67.64 66.66,67.64 73.14,61.17 90.9,61.17 92.3,62.56 92.3,63.85 94.58,66.14 94.58,68.46 99.61,73.48 100.55,73.48 104.11,77.04 106.78,77.04 107.16,77.42 123.3,77.42 126.84,80.97 126.84,87.58 130.4,91.14 132.16,91.14 133.19,92.18 133.19,93.68 138.15,98.63 196.06,98.63 199.61,102.19 209.39,102.19 210.54,103.33 216.99,103.33 219.91,106.25 230.96,106.25 231.37,106.65 231.37,107.8 232.63,109.06 232.63,111.97 235.05,114.38 235.05,115.92 236.54,117.42 236.54,118.06 236.82,118.34 236.82,118.91 v3(236.99,119.07)
  BOTTOM w0.081: v1(7.34,121.11) 7.09,121.36 Q41.4 6.7,122.13 6.12,122.13 R2146.2 ; G2.BK9 v3(236.99,119.07)
GPU_HDMI_DDC_DATA: length 309
  IN05 w0.091: v1(8.22,121.11) 8.22,121.19 8,121.42 7.87,121.42 7.77,121.32 7.77,119.41 9.6,117.58 16.46,117.58 16.99,117.05 21.54,117.05 37.44,101.15 37.44,95.46 39.72,93.17 44.91,93.17 46.3,91.78 50.54,91.78 51.3,92.54 52.29,92.54 52.8,92.03 52.8,91.75 53.04,91.52 53.82,91.52 54.32,91.01 54.94,91.01 55.85,90.1 55.85,88.85 63.97,80.73 66.88,80.73 68.17,79.44 68.17,77.42 65.88,75.14 65.88,73.38 64.66,72.16 64.66,68.46 65.23,67.9 66.77,67.9 73.25,61.42 90.8,61.42 92.04,62.67 92.04,63.96 94.33,66.24 94.33,68.56 99.5,73.74 100.44,73.74 104,77.3 106.67,77.3 107.05,77.68 123.19,77.68 126.59,81.07 126.59,87.69 130.29,91.4 132.05,91.4 132.94,92.28 132.94,93.79 138.04,98.89 195.95,98.89 199.51,102.44 209.29,102.44 210.43,103.59 216.89,103.59 219.81,106.51 230.86,106.51 231.11,106.76 231.11,107.9 232.38,109.17 232.38,112.07 234.79,114.49 234.79,116.03 236.29,117.52 236.29,118.17 236.57,118.45 236.57,118.78 v3(236.29,119.07)
  BOTTOM w0.081: R2145.2 8.91,121.11 v1(8.22,121.11) 8,120.88 8,120.58 Q41.1 ; G2.BL9 v3(236.29,119.07)
GPU_HDMI_HPD: length 101.5
  TOP w0.097: v1(67.66,81.99) 67.66,81.84 R1018.1 ; R568.1 v1(13.18,124.29) ; JHDMI1.19 10.93,136.25 11.54,136.86 D29.2 12.15,137.35 12.21,137.42 R451.1 12.21,138.56 12.47,138.81 v1(13.94,138.81)
  IN05 w0.091: v1(67.66,81.99) 66.77,82.88 63.09,82.88 56.61,89.36 56.61,90.5 55.21,91.9 54.71,91.9 54.53,92.07 54.53,92.45 53.82,93.17 50.9,93.17 49.75,94.31 40.1,94.31 38.45,95.96 38.45,100.88 21.44,117.89 17.72,117.89 13.18,122.43 v1(13.18,124.29)
  IN08 w0.091: v1(13.18,124.29) 12.67,124.79 12.67,137.54 v1(13.94,138.81)
  BOTTOM w0.097: v2(14.07,124.92) 13.81,124.92 v1(13.18,124.29)
GPU_HDMI_HPD_R: length 257.8
  TOP w0.097: v1(66.24,78.18) 65.63,77.58 65.63,74.76 66.01,74.37 v2(66.52,74.37) 68.17,74.37 68.55,74.76 68.55,77.17 68.37,77.35 R1016.2 68.04,77.93 Q74.6
  IN05 w0.091: v1(66.24,78.18) 66.24,77.65 61.44,72.85 61.44,69.04 64.6,65.88 65.74,65.88 66.9,64.72 66.9,64.21 67.53,63.58 67.53,63.2 67.91,62.82 69.44,62.82 71.47,60.79 71.47,59.77 72.36,58.88 74.39,58.88 75.28,59.77 91.92,59.77 93.95,61.8 93.95,62.26 94.44,62.75 94.44,63.78 96.36,65.7 96.36,67.36 100.33,71.33 100.9,71.33 103.69,74.12 104.75,74.12 105.32,74.68 108.5,74.68 109.84,76.03 123.86,76.03 128.18,80.35 128.18,86.38 129.26,87.46 134.21,87.46 134.72,87.96 134.72,90.63 140.05,95.96 208.76,95.96 209.52,95.2 209.52,93.46 209.86,93.12 211.53,93.12 212.62,92.03 216.12,92.03 217.71,90.44 238.03,90.44 238.86,91.26 238.86,104.22 241.02,106.38 241.02,109.43 241.21,109.62 241.21,111.4 241.78,111.97 241.78,113.41 242.49,114.13 v3(242.49,115.62)
  BOTTOM w0.097: G2.BA4 243.23,115.62 v3(242.49,115.62)
GPU_ILIM: length 2.2
  TOP w0.203: PU1605.24 291.6,181.03 291.56,180.99 291.56,180.54 290.93,179.91 PR1447.1
GPU_IOUT: length 2.9
  TOP w0.203: PU1605.25 292,180.98 291.89,180.87 291.89,179.93 PC3590.2
  TOP w0.254: PC3590.2 PR1458.1
GPU_OVERT: length 3.1
  TOP w0.097: v2(303.63,60.28) 303.68,60.23 R798.2 303.67,59.25 ; 303.67,59.25 303.17,58.75 Q87.5 ; 303.67,59.25 Q87.6
GPU_OVERT_N: length 267.2
  TOP w0.097: R797.2 R796.2 249.27,110.44 248.25,111.46 v1(247.62,111.46) 246.6,112.47 244.42,112.47 243.02,113.87 241.02,113.87 240.57,114.31 240.57,114.78 240.29,115.07 240.15,115.07 239.72,115.5 239.72,116.08 v3(239.82,116.18) ; Q87.2 301.6,58.75 301.98,59.12 301.98,61.42 v1(302.1,61.55)
  IN05 w0.091: v1(297.53,196.04) 297.53,195.41 301.21,191.72 301.21,183.59 300.71,183.09 300.71,181.56 301.72,180.55 301.72,176.39 306.93,171.18 306.93,122.25 306.04,121.36 306.04,111.84 306.8,111.08 306.8,108.92 305.28,107.39 304.21,107.39 303.23,106.42 303.23,104.49 304.05,103.67 306.72,103.67 307.81,102.58 307.81,93.31 305.15,90.65 305.15,85.17 v1(305.79,84.53)
  IN10 w0.091: v1(247.62,111.46) 247.11,111.46 245.18,109.53 245.18,105.59 244.7,105.11 244.7,101.04 241.65,98 241.65,84.53 243.23,82.95 250.8,82.95 251.43,82.32 265.98,82.32 266.42,82.76 277.97,82.76 278.4,82.32 296.59,82.32 298.62,84.36 303.63,84.36 303.8,84.53 v1(305.79,84.53) 306.93,83.39 306.93,78.15 305.28,76.5 303.03,76.5 302.74,76.79 301.47,76.79 301.34,76.66 301.34,69.42 301.72,69.04 301.72,61.93 v1(302.1,61.55)
  BOTTOM w0.097: v1(297.53,196.04) 297.82,195.76 PR25.2 ; G2.BG5 239.6,115.97 v3(239.82,116.18)
GPU_PEX_RST_HOLD_N: length 115.4
  TOP w0.097: v1(304.39,77.17) 303.77,76.55 U62.1 ; v1(245.97,111.71) 245.46,112.22 244.19,112.22 243.3,113.11 241.27,113.11 240.89,113.49 240.52,113.49 v3(239.76,114.26)
  IN10 w0.091: v1(304.39,77.17) 304.9,77.68 306.13,77.68 306.67,78.22 306.67,81.36 305.53,82.5 303.5,82.5 302.99,81.99 299.82,81.99 299.18,82.63 298.17,82.63 297.2,81.67 277.92,81.67 277.59,81.99 266.74,81.99 266.42,81.67 251.05,81.67 250.42,82.3 242.74,82.3 240.89,84.15 240.89,98.32 243.89,101.32 243.89,109.64 v1(245.97,111.71)
  BOTTOM w0.097: v1(245.97,111.71) v2(245.97,110.7) 245.84,110.57 R1000.2 ; G2.BG3 239.45,114.57 v3(239.76,114.26)
GPU_PSI_R: length 2.8
  TOP w0.097: PU1605.37 295.46,184.83 295.75,185.12 296.95,185.12 PR3528.2
GPU_PWM1: length 29.4
  TOP w0.254: PU1605.11 289.59,186.03 289.28,186.35 289.28,186.77 v1(289.4,186.9)
  IN08 w0.254: v1(289.4,186.9) 290.93,186.9 291.56,187.53 291.56,189.69 290.93,190.33 288.89,190.33 284.83,194.39 276.58,194.39 273.17,197.79 v1(272.89,197.79)
  BOTTOM w0.254: v1(272.89,197.79) 272.46,198.23 PR992.2 ; PR1420.1 v1(289.4,186.9)
GPU_PWM2: length 37.5
  TOP w0.254: PU1605.10 290.4,186.92 289.91,187.4 289.28,187.4 288.51,188.17 v2(288.51,188.8) 288.26,189.06 v1(288.26,189.44) 288.01,189.44 287.4,190.05 PR1419.1
  IN08 w0.254: v1(288.26,189.44) 283.79,193.91 276.17,193.91 273.27,196.8 272,196.8 271.62,197.18 262.1,197.18 260.83,198.45 v1(260.83,198.83)
  BOTTOM w0.356: PR908.2 v1(260.83,198.83)
GPU_PWM3: length 50.9
  TOP w0.254: PR1418.1 288.28,190.17 289.02,189.44 v1(289.15,189.44) 289.15,188.17 289.53,187.79 290.29,187.79 290.8,187.28 PU1605.9
  IN08 w0.254: v1(289.15,189.44) 288.51,188.8 288.13,188.8 283.46,193.48 275.97,193.48 274.16,195.28 269.08,195.28 268.07,196.29 261.72,196.29 260.83,197.18 250.29,197.18 248.89,198.58 v1(248.89,198.96)
  BOTTOM w0.356: v1(248.89,198.96) 248.76,198.83 PR3535.2
GPU_PWM4: length 64.9
  TOP w0.254: PR1417.1 289.17,190.17 289.91,189.44 v1(290.04,189.44) v2(290.04,188.42) 290.24,188.42 291.2,187.46 PU1605.8
  IN08 w0.254: v1(290.04,189.44) 290.04,188.67 289.53,188.17 288.01,188.17 283.18,192.99 275.81,192.99 274.29,194.52 268.45,194.52 267.56,195.41 261.72,195.41 260.57,196.55 259.68,196.55 259.18,196.04 258.16,196.04 257.65,196.55 249.65,196.55 249.09,197.11 238.04,197.11 236.82,198.33 v1(236.82,198.96)
  BOTTOM w0.356: v1(236.82,198.96) 236.57,198.71 PR1025.2
GPU_PWM5: length 78.7
  TOP w0.254: PU1605.7 291.6,187.73 v2(291.28,188.04) 291.28,188.83 v1(290.93,189.18) 290.93,189.31 290.06,190.17 PR1416.1
  IN08 w0.254: v1(224.38,198.83) 224.38,197.95 226.41,195.91 234.67,195.91 235.05,196.29 244.06,196.29 244.44,195.91 246.48,195.91 246.98,196.42 248.64,196.42 249.4,195.66 257.27,195.66 258.29,194.64 267.05,194.64 267.81,193.88 274.29,193.88 275.56,192.61 282.8,192.61 287.75,187.66 290.55,187.66 290.93,188.04 v1(290.93,189.18)
  BOTTOM w0.254: PR1005.2 v1(224.38,198.83)
GPU_PWM6: length 4
  TOP w0.254: PU1605.6 292,189.13 v2(291.82,189.31) 290.95,190.17 PR3472.1
GPU_PWM7: length 3.8
  TOP w0.254: PR3471.1 291.84,190.17 292.48,189.54 292.48,188.67 292.4,188.6 PU1605.5
GPU_PWM8: length 3.7
  TOP w0.254: PU1605.4 292.8,188 292.96,188.17 292.96,190.02 PR3470.1
GPU_REFADJ: length 4
  TOP w0.254: PU1605.40 295.01,186.03 296.01,187.02 PR3466.2
GPU_SCL_R: length 6.4
  TOP w0.097: PR1469.2 299.61,184.1 299.56,184.1 298.8,184.86 296.39,184.86 296.11,184.58 296.11,184.25 295.81,183.96 295.51,183.96 295.44,184.03 PU1605.35
GPU_SDA_R: length 7
  TOP w0.097: PR1470.2 299.56,183.26 299.56,183.78 298.74,184.61 296.51,184.61 296.39,184.48 296.39,184.17 295.94,183.72 295.46,183.72 295.37,183.63 PU1605.34
GPU_SWN1: length 41.1
  TOP w0.254: v1(283.94,177.75) 284.2,177.75 284.78,177.17 PR1457.2 PR1445.2
  IN08 w0.254: v1(272.64,189.69) 272.74,189.59 280.36,189.59 282.16,187.79 282.16,184.83 280.64,183.31 280.64,179.94 281.81,178.77 283.43,178.77 283.81,178.39 283.81,177.88 v1(283.94,177.75)
  BOTTOM w0.254: v1(272.64,189.69) 272.51,189.56 267.18,189.56 266.58,190.16 PL902.1
  BOTTOM w0.305: PR3558.1 276.52,193.32 275.56,192.36 271.37,192.36
GPU_SWN2: length 45.9
  TOP w0.254: v1(283.69,180.22) 284.27,180.22 284.78,179.71 PR1450.2 285.34,179.53 285.47,179.66 PR1442.2
  IN08 w0.254: v1(260.45,189.69) 260.57,189.56 269.94,189.56 271.21,190.83 273.91,190.83 274.16,190.58 281.69,190.58 284.07,188.2 284.07,184.23 283.31,183.47 283.31,181.18 283.69,180.8 v1(283.69,180.22)
  BOTTOM w0.254: PL901.1 254.39,190.03 254.86,189.56 260.32,189.56 v1(260.45,189.69)
GPU_SWN3: length 58.1
  TOP w0.254: PR1439.2 285.16,182.32 PR1451.2 284.78,182.68 v1(284.58,182.88)
  IN08 w0.254: v1(248.38,190.33) 248.51,190.2 249.49,190.2 250.13,190.83 268.54,190.83 269.69,191.98 274.8,191.98 275.18,191.6 282.04,191.6 285.97,187.66 285.97,183.56 285.62,183.21 284.73,183.21 284.58,183.06 v1(284.58,182.88)
  BOTTOM w0.254: PL1810.1 242.2,190.03 242.54,189.69 247.24,189.69 247.87,190.33 v1(248.38,190.33)
GPU_SWN4: length 64.2
  TOP w0.254: v1(280.89,184.99) 280.89,185.28 281.12,185.5 v2(281.4,185.5) 281.53,185.63 284.65,185.63 284.78,185.5 PR1452.2 PR1436.2
  IN08 w0.254: v1(280.89,184.99) 280.89,186.9 279.75,188.04 260.07,188.04 258.29,189.82 250.79,189.82 249.91,188.93 247.14,188.93 246.51,189.56 236.19,189.56 v1(236.06,189.69)
  BOTTOM w0.254: PL1811.1 230.01,189.9 230.35,189.56 235.94,189.56 v1(236.06,189.69)
GPU_SWN5: length 76.9
  TOP w0.254: v1(279.75,185.88) 279.62,186.01 v2(279.62,187.15) 279.62,187.79 280.13,188.29 284.65,188.29 284.78,188.17 PR1453.2 PR1433.2
  IN08 w0.254: v1(223.87,189.69) 224,189.56 230.25,189.56 231.52,188.29 245.84,188.29 246.35,187.79 250.41,187.79 251.3,188.67 257.78,188.67 259.43,187.02 278.86,187.02 279.75,186.13 v1(279.75,185.88)
  BOTTOM w0.254: v1(223.87,189.69) 223.74,189.56 218.16,189.56 217.82,189.9 PL1001.1
GPU_TERMP: length 4.4
  TOP w0.097: v3(234.53,142.93) 234.16,143.3 v2(234.16,143.46)
  TOP w0.356: R606.1 235.43,141.94 234.53,142.84 v3(234.53,142.93)
  BOTTOM w0.1: v3(234.53,142.93) 236.08,142.93 236.42,143.27 236.58,143.27 G2.BL44
GPU_VCC_R: length 3.1
  TOP w0.254: PU1605.33 295.5,183.23 295.9,182.83 PC1432.2
  TOP w0.356: PR1471.1 296.26,183.28 296.26,182.98 296.18,182.9 PC1432.2
GPU_VRAM: length 2.9
  TOP w0.254: PU1605.3 293.2,187.64 293.59,188.04 PC809.1 PR818.1
GPU_VREF: length 4.1
  TOP w0.254: PU1605.2 293.6,187.28 294.1,187.79 294.99,187.79 295.37,188.17 PC3543.1 296.26,188.6 PR3467.1
GPU_VREFIN: length 6.7
  TOP w0.254: PR3542.1 PC3572.1 PR3547.1 297.91,187.91 297.53,187.53 v2(296.64,187.53) 295.5,187.53 295.24,187.28 294.19,187.28 294,187.09 PU1605.1
GPU_VSN: length 3.3
  TOP w0.254: PR1472.1 296.62,181.97 PC3575.2 295.83,181.99 295.63,182.2 295.63,182.45 295.25,182.83 PU1605.32
GPU_VSP: length 3.5
  TOP w0.254: PU1605.31 295.01,182.43 295.24,182.2 295.24,181.87 295.55,181.56 295.88,181.56 296.36,181.08 PC3575.1 296.62,181.11 PR1473.1
GRM2103_EN: length 5.8
  TOP w0.097: PU605.13 78.58,48.34 77.95,47.7 ; PR623.2 PC622.1 77.01,45.29 77.13,45.42
  TOP w0.102: 77.95,47.7 77.57,47.32 77.57,45.85 77.13,45.42
GRM2103_FB: length 6.2
  TOP w0.305: PC601.1 77.29,56.43 PR621.1 78.58,55.14 PU605.30
  TOP w0.356: PC601.1 77.29,56.95 77.93,57.6 PR622.2
  TOP w0.381: v2(76.88,58.17) 77.58,58.17 PR622.2
GRM2103_OUT: length 2.1
  TOP w0.356: PR622.1 79.95,57.19 PR605.2
  TOP w0.381: PR605.2 79.95,55.99
  vias: v2(82.62,55.99)
GRM2103_PVIN:
  vias: v2(69.03,49.81)
GRM2103_VIN: length 8.1
  TOP w0.254: 77.31,48.59 77.58,48.86 PU605.11
  TOP w0.356: 77.31,48.59 77.31,47.83 76.93,47.45 PC626.2 76.12,47.02 75.41,46.31 75.41,45.8 75.03,45.42 v2(75.03,44.15) 74.9,44.02 PR626.2
GSPI0_MOSI: length 5.4
  BOTTOM w0.076: U2.BD28 234.65,51.65 234.65,50.1
  BOTTOM w0.097: 234.65,50.1 v2(234.13,49.59) 234.03,49.48 233.7,49.48 233.27,49.05 233.27,47.91 R168.1
GSPI1_MOSI: length 2.3
  TOP w0.097: R506.1 R171.1 233.62,55.22 v3(233.65,55.2)
  BOTTOM w0.097: v3(233.65,55.2) 233.82,55.2 U2.AT29
H_A20GATE: length 265.8
  TOP w0.097: v3(238.17,49.1) 238.6,49.53 238.6,50.55 239.24,51.18 239.24,52.61 239.11,52.73 239.11,53.67 v3(239.62,54.18)
  IN05 w0.091: v1(117.83,31.96) 117.32,31.45 113.79,31.45 112.98,30.64 100.38,30.64 98.39,28.65 95.14,28.65 94.25,27.77 83.35,27.77 82.68,27.1 74.81,27.1 72.4,24.68 70.45,24.68 70.24,24.46 63.23,24.46 62.36,23.6 57.39,23.6 56.67,24.32 56.67,26.19 56.48,26.37 55.45,26.37 45.44,36.38 41.01,36.38 39.47,34.83 29.8,34.83 25.11,39.52 25.11,46.31 24.73,46.69 24.73,47.58 25.62,48.47 v1(26.13,48.47)
  IN08 w0.091: v1(117.83,31.96) 120.87,35 120.87,41.28 122.83,43.24 140.42,43.24 143.48,40.18 143.48,39.32 v1(142.97,38.81)
  IN10 w0.091: v1(142.97,38.81) 143.61,39.45 143.61,42.61 146.67,45.67 169.64,45.67 172.82,48.85 201.14,48.85 202.35,50.06 214.4,50.06 215.48,48.98 215.48,47.71 217.14,46.05 223.36,46.05 223.62,46.31 234.92,46.31 237.71,49.1 v3(238.17,49.1)
  BOTTOM w0.097: R180.1 237.46,48.39 v3(238.17,49.1) ; U2.AW17 239.79,54.01 v3(239.62,54.18) ; R239.1 v1(26.13,48.47)
H_A20GATE_R: length 6.4
  BOTTOM w0.097: U5.F1 31.85,52.41 30.42,50.98 29.61,50.98 29.1,50.47 29.1,50.04 28.54,49.48 28.54,49.03 R239.2
H_CATERR_N: length 1.3
  TOP w0.097: v1(151.59,152.62) 152.09,153.11 TP4.1
  BOTTOM w0.097: U1.BM30 151.59,152.55 v1(151.59,152.62)
H_PECI: length 460.7
  TOP w0.097: R252.2 26.26,45.93 v1(26.13,45.8)
  IN03 w0.091: v1(48.36,36.91) 50.13,36.91 50.39,36.66 63.6,36.66 64.61,35.64 80.61,35.64 82.65,33.61 86.87,33.61 87.5,34.24 87.98,34.24 89.5,35.77 92.55,35.77 93.7,36.91 v1(95.73,36.91) 107.91,36.91 119.69,48.69 147.7,48.69 155.67,40.72 v1(155.67,40.08)
  IN05 w0.091: v1(26.13,45.8) 25.67,45.34 25.67,40.08 26.69,39.07 27.66,39.07 27.97,38.75 27.97,38.12 30.49,35.6 39.35,35.6 40.66,36.91 43.28,36.91 44.29,37.93 47.34,37.93 v1(48.36,36.91) ; v1(118.84,166.45) 119.35,166.96 134.97,166.96 146.02,155.91 146.02,155.02 v1(146.65,154.38)
  IN10 w0.091: v1(95.73,36.91) 94.84,36.91 90.67,41.08 86.33,41.08 83.43,43.98 83.43,47.73 84.17,48.47 84.17,62.56 85.19,63.58 85.19,67.01 87.98,69.8 87.98,89.87 90.52,92.41 90.52,99.65 98.14,107.27 106.4,107.27 112.7,113.57 112.7,129.15 115.03,131.48 115.03,162.64 v1(118.84,166.45) ; v1(252.83,56.39) 252.06,55.62 252.06,47.55 250.83,46.32 250.83,43.81 247.73,40.7 215.33,40.7 211.86,44.17 207.28,44.17 204.17,41.06 186.21,41.06 184.93,39.77 160.81,39.77 159.27,41.31 156.9,41.31 v1(155.67,40.08)
  BOTTOM w0.097: R174.2 252.65,56.21 v1(252.83,56.39) ; U1.BT34 146.78,154.51 v1(146.65,154.38)
H_PM_DOWN: length 386.9
  TOP w0.097: v3(249.52,59.26) 249.73,59.46 R177.1
  IN03 w0.091: v1(154.4,38.81) 155.04,39.45 155.04,40.72 147.36,48.4 119.81,48.4 107.82,36.4 93.64,36.4 92.53,35.29 v1(90.14,35.29)
  IN05 w0.091: v1(143.99,154.26) 143.73,154.51 143.73,156.8 134.34,166.2 129.13,166.2 115.63,152.7 115.63,125.39 v1(114.78,124.54)
  IN08 w0.091: v1(114.78,124.54) 114.14,125.17 111.86,125.17 110.84,124.16 110.84,120.35 104.24,113.74 104.24,111.46 101.73,108.95 97.77,108.95 84.07,95.25 81.52,95.25 80.94,94.68 80.94,89.82 80.02,88.9 78.94,88.9 78.68,88.64 78.68,81.72 78.02,81.05 78.02,77.53 78.67,76.88 78.67,69.26 82.36,65.58 82.36,62.85 83.79,61.42 87.8,61.42 89.59,59.63 89.59,39.07 89,38.48 89,36.44 v1(90.14,35.29)
  IN10 w0.091: v3(249.52,59.26) 249.91,58.88 250.06,58.88 251.56,57.38 251.56,50.65 250.79,49.89 250.79,47.01 250.03,46.25 250.03,44.53 246.84,41.33 215.43,41.33 212.07,44.69 206.96,44.69 203.85,41.58 185.74,41.58 184.45,40.29 175.02,40.29 173.58,41.74 156.69,41.74 155.16,40.21 155.16,39.58 v1(154.4,38.81)
  BOTTOM w0.097: U2.AH2 248.29,59.52 248.8,59.01 249.27,59.01 v3(249.52,59.26) ; v1(143.99,154.26) 144.11,154.38 R18.1
H_PM_DOWN_R: length 5.9
  BOTTOM w0.097: R18.2 146.48,153.88 147.04,153.88 147.32,154.16 150.16,154.16 150.28,154.04 150.28,153.31 150.57,153.01 U1.BP31
H_PM_SYNC: length 392.2
  IN03 w0.091: v1(158.21,40.08) 158.21,40.72 149.21,49.72 119.26,49.72 114.13,44.59 107.61,38.06 99.03,38.06 98.19,38.9 96.79,38.9 95.94,39.75 91.42,39.75 v1(89.5,37.83)
  IN05 w0.091: v1(151.59,154.98) 151.25,154.64 148.69,154.64 147.92,153.88 146.53,153.88 145.38,152.73 143.73,152.73 143.23,153.24 143.23,156.67 134.08,165.81 129.51,165.81 115.93,152.23 115.93,124.54 115.29,123.9 112.49,123.9 v1(111.86,124.54)
  IN08 w0.091: v1(89.5,37.83) 89.89,38.21 89.89,59.8 84.81,64.88 84.81,66.12 84.42,66.5 81.85,66.5 78.97,69.38 78.97,78.44 79.89,79.37 79.89,88.23 81.25,89.59 81.25,94.57 81.63,94.95 84.25,94.95 97.96,108.66 102.07,108.66 104.62,111.2 104.62,113.62 111.22,120.22 111.22,123.9 v1(111.86,124.54)
  IN10 w0.091: v1(158.21,40.08) 159.54,38.75 185.48,38.75 186.84,40.11 205.63,40.11 208.08,42.56 210.84,42.56 214.16,39.24 249.21,39.24 254.12,44.15 254.12,46.01 255.24,47.13 255.24,55.58 254,56.81 253.46,56.81 253.04,57.23 252.73,57.23 252.32,57.64 252.32,58.63 v1(252.83,59.13)
  BOTTOM w0.097: v1(151.59,154.98) 151.92,154.66 U1.BM34 ; v1(252.83,59.13) 252.83,59.06 R175.2
H_PM_SYNC_R: length 5.1
  BOTTOM w0.076: U2.AJ4 246.72,59.4 246.96,59.16 247.19,59.16 247.24,59.11 248.15,59.11 248.51,58.75
  BOTTOM w0.097: 248.51,58.75 249.02,58.25 v2(249.78,58.25) 251.1,58.25 R175.1
H_PROCHOT_N: length 247.3
  IN05 w0.091: v1(144.37,153.24) 145.13,154 145.13,156.04 134.59,166.58 128.75,166.58 115.41,153.24 115.41,126.83 114.9,126.32 112.36,126.32 v1(111.86,125.81) ; v1(46.32,45.93) 46.33,45.94 47.71,45.94 52.77,40.88 52.77,36.43 57.75,31.45 63.85,31.45 66.26,29.04 70.71,29.04 73.5,31.83 76.3,31.83 76.8,32.34 77.46,32.34 77.59,32.21 77.59,31.7 77.71,31.58 83.03,31.58 83.14,31.69 85.3,31.69 v1(85.69,32.08)
  IN08 w0.091: v1(111.86,125.81) 110.54,124.49 110.54,120.42 103.86,113.74 103.86,111.59 101.44,109.17 97.53,109.17 83.84,95.48 81.27,95.48 80.69,94.9 80.69,89.94 79.9,89.15 78.81,89.15 78.43,88.77 78.43,81.99 77.8,81.36 77.8,77.44 78.46,76.79 78.46,69.17 82.14,65.48 82.14,62.66 81,61.51 81,55.32 82.61,53.71 82.61,38.09 85.82,34.88 85.82,32.21 v1(85.69,32.08)
  BOTTOM w0.097: R13.2 R11.1 v1(144.37,153.24) ; R556.1 C633.2 45.61,46.38 R580.1 46.32,45.98 v1(46.32,45.93) 47.09,45.93 47.46,46.3 Q53.6
H_PROCHOT_N_R: length 4.8
  BOTTOM w0.097: R13.1 145.97,152.05 146.43,151.59 146.78,151.59 147.06,151.87 149.6,151.87 149.96,152.23 U1.BR30
H_PWRGD: length 379.2
  TOP w0.097: C33.1 148.18,152.94 v1(148.18,153.41) 148.48,153.71 R30.2
  IN03 w0.091: v1(90.27,34.25) 90.4,34.12 95.09,34.12 95.85,34.88 107.22,34.88 120.08,47.74 146.75,47.74 153.13,41.35 v1(153.13,40.08)
  IN05 w0.091: v1(111.86,123.27) 115.16,123.27 116.22,124.33 116.22,151.89 129.76,165.43 133.95,165.43 142.84,156.54 142.84,152.99 143.39,152.44 147.21,152.44 v1(148.18,153.41)
  IN08 w0.091: v1(90.27,34.25) 90.58,34.57 90.58,35.58 89.9,36.26 89.9,36.92 90.27,37.29 90.27,59.9 85.19,64.98 85.19,66.25 84.55,66.88 81.88,66.88 79.26,69.5 79.26,78.32 80.19,79.25 80.19,88.05 81.54,89.4 81.54,94.18 81.91,94.54 84.27,94.54 98.09,108.37 102.29,108.37 105.76,111.84 105.76,113.11 106.14,113.49 106.14,114 111.86,119.71 v1(111.86,123.27)
  IN10 w0.091: v3(246.35,57.74) 246.35,56.09 248.13,54.31 248.13,50.12 247.37,49.36 245.59,49.36 244.44,48.21 242.67,48.21 242.03,47.58 242.03,46.18 238.22,42.37 216.5,42.37 212.76,46.11 206.18,46.11 203,42.93 155.34,42.93 153.13,40.72 v1(153.13,40.08)
  BOTTOM w0.097: U2.AM3 246.36,57.73 v3(246.35,57.74) ; v1(148.18,153.41) 148.6,152.99 U1.BT31
H_SKTOCC_N: length 3.8
  BOTTOM w0.097: U1.BR33 149.97,153.5 149.61,153.14 149.61,152.89 149.4,152.68 148.1,152.68 TP115.1
H_THRMTRIP_N: length 261.1
  TOP w0.097: C2683.1 v1(300.58,55.32) ; C2683.1 301.43,56.01 Q98.6 ; C2683.1 300.15,56.01 299.56,56.59 v2(299.56,57.1) 299.56,57.74 300.12,58.3 C1329.1 301.09,58.3 301.13,58.25 Q87.3 ; R287.2 252.52,59.64 253.33,59.64 253.72,59.26 v1(253.72,59.13)
  IN03 w0.091: v1(208.63,160.61) 203.8,160.61 201.52,158.32 197.86,158.32 197.73,158.19 196.57,158.19 v1(196.18,158.58) 193.77,156.16 189.96,156.16 189.58,156.54 187.68,156.54 187.42,156.29 187.42,153.5 187.17,153.24 186.79,153.24 186.15,152.61 184.83,152.61 v1(184.68,152.45)
  IN05 w0.091: v1(253.72,59.13) 253.84,59.13 258.16,63.45 258.16,64.6 259.05,65.48 267.05,65.48 267.81,64.72 274.04,64.72 277.21,67.9 278.86,67.9 279.62,67.14 279.62,61.83 280.54,60.91 288.51,60.91 v1(290.29,59.13)
  IN08 w0.091: v1(208.63,160.61) 208.88,160.61 209.65,159.85 209.65,149.43 203.22,143.01 203.22,117.12 204.22,116.13 208.79,116.13 210.97,113.94 210.97,105.27 209.08,103.38 209.08,100.7 208.12,99.74 208.12,95.63 205.71,93.22 205.71,74.37 207.11,72.98 207.11,68.41 213.2,62.31 221.94,62.31 222.19,62.56 226.28,62.56 227.43,61.42 240.38,61.42 240.4,61.44 241.54,61.44 242.16,62.06 246.35,62.06 249.65,65.36 253.33,65.36 254.1,64.6 254.1,59.52 v1(253.72,59.13)
  BOTTOM w0.097: U1.J31 184.94,152.72 v1(184.68,152.45) ; v1(196.18,158.58) 196.11,158.5 R15.1 ; v1(300.58,55.32) 294.1,55.32 v1(290.29,59.13)
H_VCCST_PWRGD: length 307.9
  TOP w0.097: v1(196.69,150.93) 196.69,150.96 195.3,152.35 190.52,152.35 189.96,152.91 R14.1 ; R17.1 185.69,141.13 186.37,141.81 v1(186.37,141.83)
  IN05 w0.091: v1(107.92,32.52) 107.89,32.49 99.56,32.49 97.52,30.45 94.69,30.45 94.55,30.31 85.19,30.31 84.55,29.67 80.87,29.67 80.69,29.85 74.31,29.85 71.42,26.97 64.65,26.97 63.1,28.51 57.9,28.51 56.87,29.54 55.98,29.54 50.77,34.75 50.77,39.45 50.26,39.96 48.48,39.96 v1(47.85,40.59)
  IN08 w0.091: v1(114.65,59.77) 115.03,59.77 116.02,58.78 124.76,58.78 125.83,57.71 155.06,57.71 155.59,58.25 166.97,58.25 167.99,59.26 167.99,63.58 166.85,64.72 166.85,65.36 164.07,68.13 164.07,102.46 190.98,129.37 192.12,129.37 192.5,129.75 192.5,130.51 191.99,131.02 190.09,131.02 189.83,131.27 189.83,140.54 188.95,141.43 186.66,141.43 186.37,141.72 v1(186.37,141.83) ; v1(47.34,47.07) 47.34,46.25 46.32,45.24 46.32,41.35 46.96,40.72 47.72,40.72 v1(47.85,40.59)
  IN10 w0.091: v1(114.65,59.77) 115.03,59.77 118.97,55.83 118.97,55.07 119.86,54.18 119.86,52.28 115.27,47.69 115.27,40.83 107.92,33.48 v1(107.92,32.52) ; v1(186.37,141.83) 186.79,142.24 187.98,142.24 189.33,143.59 189.33,146.26 189.96,146.89 191.36,146.89 195.4,150.93 v1(196.69,150.93)
  BOTTOM w0.097: v1(47.34,47.07) 47.64,47.37 R64.2 48.15,48.85 49.12,48.85 49.75,48.21 52.24,48.21 R842.1 ; U58.4 46.06,36.16 45.36,36.86 45.36,38.1 v1(47.85,40.59)
