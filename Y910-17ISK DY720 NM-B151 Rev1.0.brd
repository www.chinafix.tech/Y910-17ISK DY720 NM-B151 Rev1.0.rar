# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_RX_DN3_R: length 7.9
  TOP w0.104: JUSB2.5 12.05,25.83 12.29,26.07 13.39,26.07 v1(13.56,26.24) 13.71,26.39 13.71,27.91 13.83,28.03 14.02,28.03 14.14,27.91 D53.5 D53.6 16.12,27.91 16.56,27.47 CM10.1 17.21,27.47 R530.2
USB3_RX_DN6: length 92.5
  IN10 w0.114: v3(240.73,68.36) 241.1,67.99 241.1,67.88 241.1,67.47 241.87,66.7 241.87,63.08 242.3,62.65 246.9,62.65 248.51,61.04 250.03,61.04 250.49,60.58 255.13,60.58 255.42,60.29 257.03,60.29 259.29,62.55 263.99,62.55 265.51,64.08 267.96,64.08 271.37,60.66 276.96,60.66 279.88,57.74 283.69,57.74 284.63,56.8 284.63,54.13 286.61,52.15 288.39,52.15 289.15,51.39 289.15,46.18 290.05,45.28 291.2,45.28 291.8,44.67 291.8,43.02 294.47,40.36 294.47,39.85 295.77,38.55 298.94,38.55 299.72,37.77 302.51,37.77 303.28,37.01 303.28,36.56 v1(302.99,36.27)
  BOTTOM w0.104: v3(240.73,68.36) 241.11,68.73 U2.K15 ; v1(302.99,36.27) 303.09,36.38 303.28,36.38 303.39,36.26 303.39,35.77 303.25,35.63 300.9,35.63 300.8,35.72 JIO1.44
USB3_RX_DP1: length 99.2
  IN10 w0.114: v1(245.1,73.97) 245.33,73.96 245.33,73.96 245.93,74.49 249.65,74.49 250.38,73.75 252.33,73.75 253.21,74.63 257.65,74.63 258.81,73.47 258.81,72.33 259.04,72.1 262.37,72.1 264.53,74.26 266.56,74.26 267.7,75.4 269.83,75.4 270.73,74.5 270.73,73.23 270.97,72.99 275.28,72.99 275.78,72.48 283.7,72.48 284.85,73.63 287.61,73.63 288.51,72.72 288.51,70.18 290.55,68.15 290.55,61.8 297.15,55.19 297.15,47.95 298.91,46.19 303.36,46.19 304.63,44.92 304.63,40.13 v1(304.8,39.96)
  BOTTOM w0.104: U2.A7 245,73.09 245,73.38 245.1,73.48 v1(245.1,73.97) ; JIO1.39 300.84,37.72 300.9,37.79 303.6,37.79 304.62,38.81 304.62,39.78 v1(304.8,39.96)
USB3_RX_DP3: length 282.3
  TOP w0.104: v1(19.91,28.4) 19.91,28.36 19.57,28.02 19.23,28.02 18.94,28.32 CM10.3 18.29,28.32 R528.1
  IN03 w0.114: v3(244.65,73.54) 244.65,72.42 244.19,71.96 244.19,68.41 243.72,67.94 243.72,67.3 242.17,65.76 242.17,63.24 240.56,61.62 237.61,61.62 237.05,61.07 237.05,58.82 236.14,57.9 222.38,57.9 220.82,56.34 218.28,56.34 216.25,58.37 199.22,58.37 195.68,61.92 137.65,61.92 136.64,62.93 127.87,62.93 126.1,64.71 116.83,64.71 115.54,65.99 109.95,65.99 109.32,66.63 106.02,66.63 105.13,65.74 102.71,65.74 101.82,66.63 90.65,66.63 85.19,61.17 68.8,61.17 68.68,61.04 60.8,61.04 57.96,58.2 55.13,58.2 54.2,59.13 46.71,59.13 45.42,57.85 34.12,57.85 33.12,56.85 29.05,56.85 28.54,56.34 28.54,54.56 27.53,53.55 26.89,53.55 25.62,52.28 25.62,49.99 23.34,47.7 23.34,38.95 23.1,38.7 23.1,34.86 23.37,34.59 24.04,34.59 24.35,34.27 24.35,28.91 21.94,26.5 19.53,26.5 18.8,27.22 18.8,28.03 19.17,28.4 v1(19.91,28.4)
  BOTTOM w0.104: U2.A9 244.13,72.92 244.49,72.92 244.75,73.18 244.75,73.44 v3(244.65,73.54)
USB3_RX_DP3_R: length 7.9
  TOP w0.104: JUSB2.6 12.05,26.56 12.29,26.33 13.29,26.33 13.45,26.49 13.45,28.02 v1(13.58,28.15) 13.72,28.29 14.02,28.29 14.14,28.41 D53.4 D53.7 15.58,28.41 15.83,28.17 16.15,28.17 16.3,28.32 CM10.4 17.21,28.32 R528.2
USB3_RX_DP6: length 92.5
  IN10 w0.114: v3(241.74,68.37) 241.37,67.99 241.37,67.88 241.37,67.58 242.13,66.81 242.13,63.19 242.41,62.91 247.01,62.91 248.62,61.31 250.14,61.31 250.6,60.85 255.24,60.85 255.53,60.56 256.92,60.56 259.18,62.82 263.88,62.82 265.4,64.34 268.07,64.34 271.48,60.93 277.07,60.93 279.99,58 283.8,58 284.89,56.91 284.89,54.24 286.72,52.42 288.5,52.42 289.41,51.5 289.41,46.29 290.16,45.55 291.31,45.55 292.07,44.78 292.07,43.13 294.74,40.47 294.74,39.96 295.88,38.81 299.05,38.81 299.83,38.04 302.62,38.04 303.54,37.12 303.54,36.55 v1(303.82,36.27)
  BOTTOM w0.104: v3(241.74,68.37) 241.74,68.48 241.98,68.73 242.14,68.73 U2.K13 ; JIO1.45 300.8,35.32 300.85,35.37 303.35,35.37 303.64,35.67 303.64,36.1 v1(303.82,36.27)
USB3_TX_DN1: length 105.9
  IN10 w0.114: v1(307.86,39.96) 307.58,40.24 307.58,44.26 304.64,47.2 299.18,47.2 298.05,48.33 298.05,55.56 292.34,61.28 292.34,68.14 290.18,70.29 290.18,72.33 285.83,76.67 282.05,76.67 280.77,75.39 277.34,75.39 276.7,76.03 274.54,76.03 273.91,75.39 271.11,75.39 270.08,76.42 263.76,76.42 262.49,75.15 259.03,75.15 258.66,75.52 244.49,75.52 243.81,74.84 v3(243.53,74.84)
  BOTTOM w0.104: v1(307.86,39.96) 307.67,40.14 307.67,40.61 307.18,41.1 303.76,41.1 301.92,39.27 301.07,39.27 301.02,39.32 JIO1.35 ; v3(243.53,74.84) 243.53,74.7 243.33,74.49 243.33,73.3 243.12,73.09 243.12,72.26 243.31,72.07 U2.C11
USB3_TX_DN3: length 279.5
  TOP w0.104: v1(21.98,29.58) 21.71,29.85 21.43,29.85 C504.1
  IN03 w0.114: v3(242.95,74.2) 243.05,74.09 243.33,74.09 243.6,73.82 243.6,72.9 242.65,71.95 242.65,67.66 242.05,67.06 241.4,67.06 241.29,67.17 240.84,67.17 240.27,66.59 240.27,65.75 239.76,65.24 237.34,65.24 236.96,64.87 236.96,62.45 236.36,61.85 232.07,61.85 231.42,62.5 227.87,62.5 226.71,61.34 224.05,61.34 222.22,59.52 220.06,59.52 219.43,58.88 217.52,58.88 217.14,59.26 214.22,59.26 210.66,62.82 139.16,62.82 138.16,63.82 128.26,63.82 126.35,65.73 117.08,65.73 115.92,66.88 110.84,66.88 109.39,68.34 106.83,68.34 106.4,67.9 90.65,67.9 84.81,62.06 70.71,62.06 70.2,62.56 60.93,62.56 57.49,59.12 55.86,59.12 54.45,60.53 38.32,60.53 37.29,59.5 33.99,59.5 32.48,57.99 29.94,57.99 29.69,57.74 28.42,57.74 27.4,56.72 26.64,56.72 24.86,54.94 22.7,54.94 20.16,52.41 20.16,42.34 19.16,41.33 19.16,33.6 19.7,33.05 22.37,33.05 23.1,32.33 23.1,29.81 22.87,29.58 v1(21.98,29.58)
  BOTTOM w0.076: U2.C13 242.28,72.07 242.38,72.07 242.43,72.12 242.43,73.74 242.58,73.89 242.85,73.89 242.95,73.99 v3(242.95,74.2)
USB3_TX_DN3_C: length 1.6
  TOP w0.104: C504.2 20,29.5 CM11.2 18.9,29.42 R531.1
USB3_TX_DN3_R: length 8.9
  TOP w0.104: JUSB2.8 12.05,31.96 12.16,32.07 12.93,32.07 13.43,31.58 13.43,29.8 13.7,29.53 14.02,29.53 14.14,29.41 D53.2 D53.9 15.51,29.41 15.64,29.53 16.07,29.53 16.25,29.71 v1(16.25,29.72) 16.26,29.72 16.38,29.85 16.63,29.85 16.98,29.5 CM11.1 17.59,29.5 R531.2
USB3_TX_DN6: length 107
  IN10 w0.114: v1(306.72,37.84) 306.72,37.99 306.89,38.16 306.89,38.47 306.69,38.68 300.47,38.68 297.64,41.5 297.64,42.76 296.13,44.28 295.5,44.28 292.96,46.82 292.96,47.7 291.31,49.36 291.31,56.47 290.29,57.48 289.28,57.48 285.6,61.17 281.02,61.17 279.37,62.82 279.37,67.14 278.74,67.77 266.41,67.77 263.99,65.35 256.37,65.35 256.01,64.99 256.01,64.1 254.52,62.6 252.19,62.6 252.11,62.68 248.78,62.68 247.48,63.98 247.48,66.26 246.24,67.5 245.24,67.5 242.17,70.57 242.17,71.44 242.11,71.5 241.39,72.21 241.39,73.39 241.39,73.4 241.39,73.56 241.86,74.03 v3(241.86,74.12)
  BOTTOM w0.076: U2.B15 241.17,72.58 241.37,72.78 241.37,73.63 v3(241.86,74.12)
  BOTTOM w0.104: JIO1.41 300.83,36.92 300.97,36.78 301.72,36.78 302.1,37.17 305.4,37.17 305.72,36.85 306.74,36.85 307.12,37.23 307.12,37.76 306.95,37.93 306.81,37.93 v1(306.72,37.84)
USB3_TX_DN6_C: length 1.5
  TOP w0.104: CM14.2 22.65,59.56 arc(22.88,59.72) 23.15,59.77 23.41,59.77 arc(23.68,59.66) C621.2
USB3_TX_DP1: length 105.8
  IN10 w0.114: v1(307.03,39.96) 307.19,39.96 307.31,40.07 307.31,40.37 307.17,40.51 307.17,40.83 307.31,40.96 307.31,41.29 307.17,41.42 307.17,41.74 307.31,41.88 307.31,42.36 307.19,42.48 307.19,42.87 307.31,42.99 307.31,44.15 304.53,46.93 299.07,46.93 297.78,48.22 297.78,55.45 292.07,61.17 292.07,68.02 289.91,70.18 289.91,72.22 285.72,76.41 282.16,76.41 280.88,75.12 277.23,75.12 276.59,75.76 274.65,75.76 274.02,75.12 271,75.12 269.97,76.15 263.88,76.15 262.61,74.88 258.92,74.88 258.55,75.25 244.6,75.25 243.72,74.36 v3(243.72,74.29)
  BOTTOM w0.104: v1(307.03,39.96) 307.14,39.85 307.27,39.85 307.42,39.99 307.42,40.51 307.08,40.85 303.86,40.85 302.03,39.01 301.11,39.01 301.02,38.92 JIO1.36 ; U2.B11 243.42,72.85 243.59,73.03 243.59,73.8 243.72,73.92 243.87,73.92 244.17,74.23 244.17,74.52 244.06,74.63 243.87,74.63 243.72,74.47 v3(243.72,74.29)
USB3_TX_DP3: length 279.5
  TOP w0.104: C500.1 21.33,30.11 21.61,30.11 v1(21.98,30.47)
  IN03 w0.114: v1(21.98,30.47) 22.13,30.62 22.33,30.62 22.43,30.52 22.43,29.98 22.56,29.85 22.76,29.85 22.83,29.92 22.83,32.21 22.26,32.78 19.59,32.78 18.89,33.48 18.89,41.44 19.9,42.45 19.9,52.52 22.59,55.21 24.75,55.21 26.53,56.99 27.29,56.99 28.31,58 29.58,58 29.83,58.26 32.37,58.26 33.88,59.77 37.18,59.77 38.21,60.8 54.56,60.8 55.97,59.39 57.38,59.39 60.82,62.83 70.31,62.83 70.82,62.32 84.69,62.32 90.54,68.16 106.28,68.16 106.72,68.6 109.5,68.6 110.95,67.15 116.03,67.15 117.19,65.99 126.46,65.99 128.37,64.09 138.27,64.09 139.27,63.08 210.77,63.08 214.33,59.53 217.25,59.53 217.63,59.15 219.31,59.15 219.95,59.78 222.11,59.78 223.94,61.61 226.6,61.61 227.76,62.77 231.53,62.77 232.18,62.11 236.25,62.11 236.7,62.56 236.7,64.98 237.23,65.51 239.65,65.51 240,65.86 240,66.7 240.73,67.43 241.4,67.43 241.51,67.33 241.94,67.33 242.38,67.77 242.38,72.06 243.33,73.01 243.33,73.71 243.22,73.83 243.06,73.83 242.95,73.71 v3(242.95,73.54)
  BOTTOM w0.076: v3(242.95,73.54) 242.74,73.74 242.65,73.74 242.58,73.68 242.58,72.05 242.26,71.73 U2.D13
USB3_TX_DP3_C: length 1.6
  TOP w0.104: R529.1 18.9,30.43 CM11.3 20,30.35 C500.2
USB3_TX_DP3_R: length 8.9
  TOP w0.104: R529.2 17.59,30.35 CM11.4 16.81,30.35 16.57,30.11 16.28,30.11 15.96,29.79 15.64,29.79 15.51,29.91 D53.10 D53.1 14.14,29.91 14.02,29.79 13.8,29.79 13.69,29.91 13.69,31.68 v1(13.53,31.83) 13.53,31.83 13.04,32.33 12.16,32.33 12.05,32.44 JUSB2.9
USB3_TX_DP6: length 107
  IN10 w0.114: v1(307.55,37.84) 307.42,37.71 307.29,37.71 307.16,37.84 307.16,38.58 306.8,38.94 306.58,38.94 300.58,38.94 297.91,41.61 297.91,42.87 296.24,44.54 295.61,44.54 293.22,46.93 293.22,47.82 291.57,49.47 291.57,56.58 290.4,57.75 289.39,57.75 285.71,61.43 281.13,61.43 279.64,62.93 279.64,67.25 278.85,68.04 266.3,68.04 263.88,65.61 256.26,65.61 255.75,65.1 255.75,64.21 254.4,62.87 252.3,62.87 252.23,62.94 248.89,62.94 247.75,64.09 247.75,66.37 246.35,67.77 245.35,67.77 243.61,69.51 243.61,69.7 243.36,69.95 243.17,69.95 243.01,70.1 243.01,70.14 243.01,70.31 242.79,70.53 242.75,70.53 242.59,70.53 242.43,70.68 242.43,71.55 242.25,71.73 242.25,71.8 242.25,71.93 242.01,72.17 241.81,72.17 241.66,72.32 241.66,73.28 v3(241.86,73.49)
  BOTTOM w0.076: U2.C15 241.19,72.07 241.4,72.28 241.4,72.59 241.52,72.71 241.52,73.37 241.64,73.49 v3(241.86,73.49)
  BOTTOM w0.104: JIO1.42 301.82,36.52 302.21,36.91 305.3,36.91 305.61,36.6 306.85,36.6 307.38,37.13 307.38,37.67 v1(307.55,37.84)
USB3_TX_DP6_C: length 1.5
  TOP w0.104: CM14.3 22.68,60.21 arc(22.88,60.07) 23.11,60.03 23.41,60.03 arc(23.68,60.14) C648.2
USB_CHG_CLT1: length 17.5
  TOP w0.097: v1(22.32,42.5) 22.06,42.24 U21.6
  IN08 w0.089: 29.81,48.41 v2(29.81,48.47)
  IN08 w0.091: 29.81,48.41 29.42,48.02 29.42,47.06 29.18,46.82 29.18,44.66 26.89,42.37 22.45,42.37 v1(22.32,42.5)
  BOTTOM w0.076: 32,51.16 32.51,51.16 32.77,50.91 U5.C2
  BOTTOM w0.097: v2(29.81,48.47) 30.34,48.99 30.34,49.51 32,51.16
USB_CHG_CLT2: length 32.3
  TOP w0.097: U21.7 v1(21.56,42.5)
  IN08 w0.091: v1(21.56,42.5) 22.07,41.99 23.85,41.99 23.97,42.12 28.29,42.12 30.55,39.86 32.2,39.86 32.99,39.07 32.99,38.18 33.62,37.54 35.53,37.54 v1(36.16,38.18)
  BOTTOM w0.076: U5.B8 36.02,50.16 36.02,49.1
  BOTTOM w0.097: 36.02,49.1 36.02,45.91 36.44,45.49 36.44,43.11 37.82,41.74 37.82,40.59 v2(37.31,40.08) 36.16,38.94 v1(36.16,38.18)
USB_CHG_CLT3: length 19.4
  TOP w0.097: U21.8 21.06,42.36 v1(20.92,42.5)
  IN08 w0.089: v2(29.81,50.24) 30.2,49.86 30.2,49.1 29.94,48.85 29.81,48.85
  IN08 w0.091: 29.81,48.85 29.59,48.85 29.43,48.7 29.43,48.34 29.18,48.09 29.18,47.45 28.93,47.2 28.42,47.2 28.16,46.94 28.16,44.78 26.72,43.34 21.76,43.34 v1(20.92,42.5)
  BOTTOM w0.097: U5.E1 31.95,51.91 30.52,50.47 30.04,50.47 v2(29.81,50.24)
USB_CHG_EN: length 17.8
  TOP w0.097: v1(22.19,44.78) 22.45,45.04 v2(22.96,45.04) 23.08,44.91 23.08,44.48 R498.1
  IN08 w0.091: v2(29.81,49.36) 29.56,49.36 29.18,48.97 29.18,48.47 28.82,48.11 28.32,48.11 27.91,47.7 27.91,44.89 26.61,43.59 23.39,43.59 v1(22.19,44.78)
  BOTTOM w0.097: v2(29.81,49.36) 30.15,49.7 30.26,49.7 31.98,51.41 U5.D1
USB_CHG_ILIM_HI: length 2.6
  TOP w0.097: R505.1 21.56,36.27 v2(22.53,37.25) 22.56,37.28 U21.16
USB_CHG_ILIM_LO: length 2.8
  TOP w0.097: U21.15 22.06,37.54 20.75,36.22 R504.1
USB_CHG_ILIM_SEL: length 2.9
  TOP w0.097: U21.4 23.71,40.71 23.85,40.85 23.85,42.12 23.72,42.24 R503.1
USB_CHG_STATUS_N: length 23.7
  TOP w0.097: v1(19.15,42.62) 19.15,41.35 19.79,40.71 U21.9
  IN08 w0.091: v1(31.72,38.18) 31.21,38.69 31.21,39.45 31.03,39.63 30.27,39.63 28.04,41.86 24.35,41.86 24.23,41.74 21.05,41.74 20.16,42.62 v1(19.15,42.62)
  BOTTOM w0.097: v1(31.72,38.18) 32.74,38.18 34.26,39.7 34.64,39.7 36.21,41.28 R540.2
USB_OC0_N: length 110.5
  TOP w0.097: v3(224.89,60.4) 224,61.29 224,61.93 223.86,62.07 RP1.1
  IN03 w0.091: v1(267.43,45.55) 267.43,46.05 266.92,46.56 266.92,49.99 265.78,51.13 265.78,54.56 265.02,55.32 265.02,58.88 263.98,59.92 260.04,59.92 258.8,61.17 257.91,61.17 256.76,60.02 256.76,59.39 257.14,59.01 257.14,57.61 v1(256.64,57.1)
  IN05 w0.091: v1(302.09,33.99) 301.34,33.99 300.83,34.5 300.83,35.89 297.4,39.32 295.93,39.32 293.52,41.74 288.07,41.74 287.31,42.5 278.92,42.5 277.15,44.28 275.12,44.28 273.34,42.5 270.41,42.5 267.43,45.48 v1(267.43,45.55)
  IN08 w0.091: v3(224.89,60.4) 225.39,60.4 225.65,60.15 227.3,60.15 227.81,59.64 230.35,59.64 231.87,58.12 237.21,58.12 237.71,57.61 241.9,57.61 242.41,57.1 247.11,57.1 248.5,58.49 254.46,58.49 254.79,58.15 255.58,58.15 v1(256.64,57.1)
  BOTTOM w0.097: v3(224.89,60.4) 225.72,61.24 226.99,61.24 227.32,61.57 U2.AD43 ; JIO1.49 301.83,33.72 v1(302.09,33.99)
USB_OC1_N: length 278.7
  TOP w0.097: v3(228.19,62.06) 227.76,61.62 225.11,61.62 223.67,63.07 RP1.3 ; v1(20.42,68.41) 19.53,67.52 19.15,67.52 18.97,67.69 U18.3
  IN03 w0.091: v1(135.35,38.81) 134.92,38.38 132.99,38.38 128.95,42.43 122.96,42.43 121.89,41.35 121.89,38.23 118.15,34.5 115.67,34.5 115.16,33.99 113.66,33.99 109.51,29.84 100.34,29.84 97.76,27.26 83.28,27.26 82.27,26.24 77.31,26.24 76.3,27.26 72.74,27.26 70.33,29.67 63.6,29.67 62.2,31.07 57.34,31.07 56.71,31.7 42.01,31.7 39.97,33.73 39.97,37.93 38.96,38.94 36.04,38.94 35.68,38.59 35.68,37.7 35.4,37.42 34.39,37.42 34.01,37.8 v1(34.01,38.18)
  IN08 w0.089: 29.81,51.26 30.96,51.26 34.26,47.96 34.26,46.82 34.13,46.69
  IN08 w0.091: 29.81,51.26 26.89,51.26 25.88,52.28 25.88,54.31 24.72,55.47 23.7,55.47 23.1,56.07 23.1,67.25 22.7,67.64 22.7,68.41 22.19,68.91 20.92,68.91 v1(20.42,68.41) ; v1(34.01,38.18) 34.13,38.31 34.13,46.69
  IN10 w0.091: v3(228.19,62.06) 227.17,62.06 226.28,62.94 224.38,62.94 223.71,63.61 220.47,63.61 215.49,58.63 204.19,58.63 203.06,59.76 201.02,59.76 199.49,61.29 183.74,61.29 183.48,61.04 183.48,59.26 180.51,56.29 174.34,56.29 173.21,55.16 167.47,55.16 166.49,54.18 160.88,54.18 160.24,53.55 147.38,53.55 136.11,42.28 136.11,39.58 v1(135.35,38.81)
  BOTTOM w0.097: v3(228.19,62.06) 227.83,61.7 U2.AD42
USB_OC2_N: length 253.1
  TOP w0.097: v1(20.92,37.21) 21.06,37.35 U21.13 ; v3(229.46,61.04) 229.33,61.04 228.77,61.6 228.19,61.6 227.96,61.37 225.04,61.37 223.84,62.57 RP1.2
  IN03 w0.091: v1(135.35,40.08) 131.68,43.75 122.41,43.75 120.8,42.14 120.8,40.01 116.73,35.94 113.96,35.94 108.96,30.94 99.53,30.94 97.12,28.53 82.65,28.53 81.63,27.51 77.95,27.51 76.93,28.53 73.12,28.53 70.87,30.78 68.2,30.78 66.9,32.08 57.88,32.08 57.25,32.72 43.15,32.72 40.99,34.88 40.99,38.37 40.85,38.51 40.85,38.96 40.1,39.7 34.51,39.7 33.63,38.82 33.11,38.82 32.25,39.68 31.19,39.68 v1(30.7,39.2)
  IN08 w0.091: v1(30.7,39.2) 30.5,38.99 21.23,38.99 20.92,38.69 v1(20.92,37.21)
  IN10 w0.091: v1(135.35,40.08) 135.35,41.88 147.27,53.8 159.99,53.8 160.62,54.44 166.38,54.44 168.46,56.52 180.36,56.52 183.23,59.39 183.23,61.29 183.61,61.67 199.49,61.67 201.18,59.98 203.21,59.98 204.31,58.88 215.43,58.88 220.38,63.83 224,63.83 224.51,63.33 227.05,63.33 227.43,62.94 229.08,62.94 229.33,62.69 229.33,61.42 229.46,61.29 v3(229.46,61.04)
  BOTTOM w0.097: U2.AD39 229.46,61.09 v3(229.46,61.04)
USB_OC3_N: length 114.1
  TOP w0.097: RP1.4 223.71,63.57 v3(225.27,62.01)
  IN05 w0.091: v1(305.02,33.99) 305.02,36.53 302.74,38.81 302.74,43.51 296.51,49.74 295.5,49.74 290.42,54.82 290.42,56.72 288.26,58.88 280.06,58.88 279.97,58.97 275.6,63.34 268.84,63.34 268.32,62.82 260.5,62.82 259.05,61.36 259.05,58.83 258.08,57.86 v1(256.64,57.86)
  IN08 w0.091: v1(256.64,57.86) 256.13,58.37 255.02,58.37 254.68,58.71 248.43,58.71 247.07,57.35 242.46,57.35 241.57,58.25 240.13,58.25 239.75,58.63 238.35,58.63 237.97,58.25 237.59,58.25 236.82,59.01 231.62,59.01 230.73,59.9 228.32,59.9 226.92,61.29 225.98,61.29 v3(225.27,62.01)
  BOTTOM w0.097: v3(225.27,62.01) 225.69,62.44 226.54,62.44 226.63,62.34 226.72,62.34 U2.AC44 ; JIO1.48 301.59,34.12 301.97,34.5 302.74,34.5 303.75,33.48 304.52,33.48 v1(305.02,33.99)
USB_OC_N: length 3.4
  TOP w0.097: v3(227.93,64.47) 227.76,64.65 R875.2
  BOTTOM w0.097: U2.Y41 228.32,64.08 v3(227.93,64.47) 227.59,64.47 U2.W43 ; U2.W44 U2.W43 ; U2.W43 227.48,64.01 U2.Y43
USB_OTG_VBUSSENSE: length 4.1
  TOP w0.097: R62.2 246.68,60.68 246.37,60.38 244.62,60.38 v3(244.06,60.94)
  BOTTOM w0.097: v3(244.06,60.94) 243.86,61.14 U2.AD10
USB_STATUS_N_R: length 8.9
  BOTTOM w0.097: R540.1 36.09,42.19 v2(35.64,42.64) 35.53,42.75 35.53,45.04 35.61,45.11 R379.2 35.99,45.42 35.78,45.63 U5.A8
V_PATH: length 57.7
  TOP w0.508: v1(83.54,20.78) 84.04,20.27 84.04,17.1 84.37,16.77 84.37,15.7 84.55,15.52 PR204.1
  IN03 w0.508: v1(83.54,20.78) 83.54,21.67 82.65,22.56 79.98,22.56 75.79,26.75 72.61,26.75 70.2,29.16 58.64,29.16 56.61,31.19 46.32,31.19 42.51,27.38 v1(38.7,27.38)
  vias: v2(37.69,33.48)
VBL_INT_N: length 284.3
  IN05 w0.091: v1(59.28,34.37) 58.52,34.37 55.17,37.72 55.17,42.8 53.18,44.78 53.18,46.43 51.66,47.96 48.72,47.96 47.87,48.81 47.12,48.81 44.93,51.01 43.88,51.01 43.28,51.61 v1(43.28,51.9)
  IN10 w0.091: v1(183.43,198.25) 183.43,199.14 183.36,199.22 181.68,199.22 181.3,198.83 177.13,198.83 175.1,200.87 160.72,200.87 158.69,198.83 155.29,198.83 146.78,190.33 146.78,184.86 144.88,182.96 127.99,182.96 125.7,180.67 118.63,180.67 111.73,173.77 111.73,132.41 109.35,130.04 109.35,119.75 99.92,110.32 97,110.32 87.09,100.41 87.09,94.16 80.74,87.81 80.74,79.71 78.71,77.68 78.71,72.09 75.41,68.79 73.38,68.79 69.82,65.23 69.82,55.45 72.28,52.99 72.28,51.05 67.15,45.93 67.15,44.53 63.34,40.72 63.34,38.43 v1(59.28,34.37)
  BOTTOM w0.097: R777.1 v1(43.28,51.9) ; v1(183.43,198.25) 183.66,198.25 PR1315.1 183.87,197.69 183.72,197.55 PU1306.6
VCIN0_PT1: length 203.2
  TOP w0.203: R558.1 155.29,133.23 155.29,132.16 147.92,124.79 147.92,115.65 140.94,108.66 124.68,108.66 124.23,108.21 v1(124.23,108.06)
  IN05 w0.203: v1(95.47,38.1) 94.89,38.69 94.08,38.69 92.93,37.54 90.14,37.54 88.49,35.89 59.28,35.89 55.98,39.2 55.98,43.26 53.89,45.34 53.89,46.74 52.04,48.59 49.24,48.59 45.81,52.02 v1(45.56,52.02)
  IN08 w0.203: v1(124.23,108.06) 123.87,108.41 122.4,108.41 112.36,98.38 112.36,89.11 108.82,85.57 108.82,70.2 105.51,66.88 105.51,65.99 101.44,61.93 99.92,61.93 98.9,60.91 98.9,43.01 97.25,41.35 97.25,39.88 v1(95.47,38.1)
  BOTTOM w0.076: 38.58,52.66 38.04,52.66 37.78,52.91 U5.G12
  BOTTOM w0.097: v1(45.56,52.02) 45.56,52.65 44.79,53.42 42.01,53.42 41.68,53.09 R557.2 41.29,52.4 40.46,52.4 40.1,52.04 39.58,52.04 38.97,52.66 38.58,52.66
VCOUT1_PROCHOT: length 12.5
  BOTTOM w0.089: U5.B13 39.21,49.47 39.21,47.81 v2(39.26,47.76) 39.42,47.6 39.71,47.6 40.63,46.69
  BOTTOM w0.097: R555.1 43.28,42.75 43.78,43.26 43.78,44.28 43.63,44.43 U26.2 42.61,44.43 42.51,44.53 42.51,45.93 42.21,46.23 41.09,46.23 40.63,46.69
VR_SVID_ALERT_1: length 3
  TOP w0.097: PR1239.1 120.82,193.37 122.02,193.37 122.59,192.8 PU1101.4
VR_SVID_CLK_1: length 3.1
  TOP w0.097: PR1238.2 120.95,193.12 121.89,193.12 122.61,192.4 PU1101.5
VR_SVID_DAT_1: length 3.2
  TOP w0.097: PR1237.1 120.75,194.52 121.64,193.63 122.14,193.63 122.58,193.2 PU1101.3
VRAM_VDDQ_ADJ: length 120.4
  TOP w0.097: R981.2 R980.2 246.32,107.6 v1(246.64,107.28)
  IN03 w0.091: v1(279.5,90.25) 279.12,90.63 276.96,90.63 275.56,92.03 275.56,102.06 281.78,108.28 286.86,108.28 288.39,109.81 300.58,109.81 304.01,106.38 v1(304.01,105.74)
  IN10 w0.091: v1(279.5,90.25) 278.73,90.25 275.08,86.59 275.08,84.76 273.58,83.26 266.03,83.26 265.53,82.76 251.68,82.76 251.05,83.39 243.56,83.39 242.16,84.79 242.16,97.87 245.17,100.88 245.17,103.93 246.35,105.11 246.35,106.99 v1(246.64,107.28)
  BOTTOM w0.097: PR3408.1 304.13,103.71 304.52,104.09 304.52,105.34 PR414.1 304.06,105.79 v1(304.01,105.74)
VRAM_VDDQ_ADJ_R: length 12.7
  TOP w0.097: v2(237.97,116.16) 238.45,116.16 238.99,115.62 v3(238.99,115.57) 238.99,114.12 239.24,113.87 239.24,112.86 239.87,112.22 241.4,112.22 241.52,112.35 242.92,112.35 245.84,109.43 R981.1
  BOTTOM w0.097: G2.BH4 238.69,115.27 v3(238.99,115.57)
VRAM_VREF_CTL: length 253.4
  IN10 w0.091: v1(284.96,175.26) 284.96,176.1 284.45,176.61 284.45,178.69 284.25,178.9 282.67,178.9 280.94,180.62 275.25,180.62 273.81,179.18 270.25,179.18 269.84,178.77 265.4,178.77 264.33,179.84 259.86,179.84 259.18,179.15 253.21,179.15 253.08,179.02 250.92,179.02 249.78,177.88 248.25,177.88 v1(247.75,178.39) ; v1(302.23,124.16) 302.74,123.65 302.74,110.82 301.47,109.55 294.1,109.55 290.67,106.12 280.77,106.12 279.12,104.47 279.12,91.65 274.54,87.07 274.54,85.66 272.65,83.77 265.4,83.77 264.89,83.26 258.03,83.26 v1(257.53,83.77) 256.95,83.2 251.88,83.2 251.21,83.86 243.77,83.86 242.59,85.04 242.59,97.67 245.71,100.79 245.71,103.58 247.57,105.44 247.57,109.72 248.25,110.4 248.25,111.97 248,112.22 v1(247.62,112.22)
  BOTTOM w0.097: Q81.2 247.49,176.61 247.16,176.94 R858.1 247.16,178.06 247.49,178.39 v1(247.75,178.39) ; v1(284.96,175.26) 283.38,175.26 282.8,174.67 Q82.2 282.8,174.07 282.93,173.94 283.56,173.94 283.81,173.69 283.81,163.15 285.85,161.12 300.96,161.12 305.53,156.54 305.53,125.43 304.52,124.41 Q83.2 302.48,124.41 v1(302.23,124.16) ; v1(257.53,83.77) 257.65,83.77 258.16,84.28 Q84.2
  BOTTOM w0.1: v1(247.62,112.22) 245.33,112.22 245.08,112.47 242.79,112.47 242.09,113.18 242.09,113.42 241.84,113.67 241.84,114.04 241.49,114.39 G2.BD3
VRHOT_203: length 7.4
  TOP w0.097: PR1233.2 v2(118.71,186.64) 120.8,186.64 122.16,188 122.16,189.07 122.68,189.6 PU1101.12
VSBP_2: length 15.9
  TOP w0.097: PQ206.1 271.58,40.94 272.51,41.86 v2(272.84,41.86) 274.8,41.86 v1(275.43,41.23) ; v1(276.58,49.23) 275.94,49.86 PR230.1
  IN03 w0.091: v1(276.58,49.23) 276.58,43.63 275.43,42.49 v1(275.43,41.23)
VSBP_3: length 6.1
  TOP w0.254: PC230.1 v2(274.8,53.14) ; PC230.1 PC204.2 273.39,52.09 273.15,51.84 PR234.2 271.89,51.84 271.75,51.98 PQ904.4 ; PC230.1 275.7,52.09 PR230.2
VSN_1PH: length 3.8
  TOP w0.203: PU1101.14 123.93,188.11 122.83,187.01 PR1177.2
  TOP w0.254: PR1177.2 PC1141.2
VSN_3PH_A: length 7.7
  TOP w0.203: PC1139.2 PR1166.2 119.11,197.44 119.27,197.6 120.21,197.6 v2(121.55,196.26) 122.57,195.23 123.8,195.23 123.93,195.09 PU1101.52
VSP_1PH: length 7
  TOP w0.203: PC1143.2 123.16,184.28 123.36,184.48 123.36,187.08 123.81,187.52 123.91,187.52 124.33,187.94 PU1101.15
  TOP w0.254: PC1143.2 122.75,184.2 PR1175.2 v2(123.67,183.34)
VSP_3PH_A: length 10.4
  TOP w0.203: PR1121.2 PC1137.2 117.52,198.1 v2(119.86,198.1) 120.32,198.1 122.75,195.66 124.06,195.66 124.33,195.38 PU1101.51
WLAN_CK_REQ_N: length 6.9
  TOP w0.097: Q8.1 267.52,76.33 R457.2 266.54,75.26 v1(266.42,75.14)
  BOTTOM w0.097: v1(266.42,75.14) 266.54,75.26 266.54,75.9 267.75,77.11 JWLAN1.53
WLAN_RST_N: length 13
  TOP w0.097: R458.1 v1(259.18,64.85)
  BOTTOM w0.097: JWLAN1.52 268,70.16 262.69,64.85 v1(259.18,64.85)
WLAN_SUSCLK: length 13.9
  TOP w0.097: R456.1 v1(259.18,63.58)
  BOTTOM w0.097: v1(259.18,63.58) 261.84,63.58 268.5,70.24 JWLAN1.50
WLAN_WAKE_N: length 8.1
  TOP w0.097: R459.2 265.65,75.77 265.15,75.26 v1(265.15,74.88)
  BOTTOM w0.097: v2(267.38,80.45) 267.25,80.32 JWLAN1.55 267.25,77.37 265.15,75.26 v1(265.15,74.88)
XCLK_BIASREF: length 3.9
  BOTTOM w0.254: 248.56,71.61 248.09,71.14 U2.E1
  BOTTOM w0.508: 248.56,71.61 248.56,72.01 v2(249.65,73.1) 250.21,73.66 R189.1
XDP_BPM0_N: length 1.4
  TOP w0.097: v3(149.64,149.47) 149.23,149.47 v2(148.94,149.18)
  BOTTOM w0.097: U1.BR27 149.97,149.8 v3(149.64,149.47)
XDP_BPM1_N: length 2.8
  BOTTOM w0.097: TP62.1 147.42,149.3 148.05,149.94 149.24,149.94 U1.BT27
XDP_BPM2_N: length 1.5
  TOP w0.097: v1(152.29,152.59) 152.91,151.97 v2(153,151.97)
  BOTTOM w0.097: v1(152.29,152.59) 151.92,152.96 U1.BM31
XDP_BPM3_N: length 2.9
  BOTTOM w0.097: TP3.1 146.91,152.1 147.29,152.48 149.07,152.48 U1.BT30
XDP_HOOK3: length 3.2
  TOP w0.097: R588.2 TP60.1 212.19,51.01 212.06,51.13 212.06,52.53 212.26,52.73 R593.1
XDP_PRDY_N: length 373.2
  TOP w0.097: R201.2 252.57,52.99 253.7,52.99 254.1,52.59 v1(254.1,52.56) ; v3(150.29,149.47) 150.14,149.47 148.94,148.27 TP23.1
  IN03 w0.091: v1(92.43,36.53) 93.31,37.42 98.18,37.42 98.3,37.29 107.87,37.29 119.57,48.98 148.17,48.98 156.18,40.97 156.18,39.58 v1(156.94,38.81)
  IN05 w0.091: v3(150.29,149.47) 149.62,148.8 143.35,148.8 140.81,151.34 140.81,155.91 137.76,158.96 126.46,158.96 117.83,150.32 117.83,121.36 v1(109.32,112.86)
  IN08 w0.091: v1(92.43,36.53) 91.69,37.27 91.69,60.61 86.71,65.59 86.71,67.01 85.49,68.23 82.6,68.23 80.74,70.09 80.74,74.91 81.8,75.98 81.8,76.58 81.76,76.63 81.76,80.72 83.32,82.29 83.32,92.2 84.17,93.04 84.9,93.04 98.9,107.04 103.5,107.04 v1(109.32,112.86)
  IN10 w0.091: v1(156.94,38.81) 157.58,39.45 157.58,40.05 158.12,40.59 158.47,40.59 159.8,39.26 185.46,39.26 186.66,40.47 204.82,40.47 207.74,43.39 211.42,43.39 214.84,39.97 248.37,39.97 252.57,44.17 252.57,46.33 252.95,46.71 252.95,47.73 253.59,48.36 253.59,52.02 254.1,52.53 v1(254.1,52.56)
  BOTTOM w0.097: U1.BP27 150.62,149.8 v3(150.29,149.47)
XDP_PREQ_N: length 412.6
  TOP w0.097: R200.2 v1(252.83,52.53)
  IN03 w0.091: v1(146.65,156.54) 147.16,156.54 150.71,153 152.41,153 152.7,152.71 152.7,152.24 v3(152.33,151.87)
  IN05 w0.091: v1(114.9,128.86) 114.27,129.49 114.27,163.02 118.84,167.59 135.61,167.59 v1(146.65,156.54) ; v1(252.83,52.53) 252.42,52.12 252.42,47.93 250.54,46.05 250.54,44.02 248.68,42.16 236.33,42.16 234.04,44.45 229.72,44.45 229.17,45 225.53,45 224.8,45.72 215.62,45.72 214.61,46.73 212.96,46.73 212.66,47.03 202.45,47.03 201.42,48.06 192.41,48.06 189.47,45.12 153.85,45.12 153.24,44.51 121.48,44.51 119.9,42.94 119.9,31.36 118.96,30.43 114,30.43 110.82,27.25 95.85,27.25 94.55,25.95 84.54,25.95 v1(83.7,26.8)
  IN08 w0.091: v1(114.9,128.86) 112.11,128.86 108.97,125.72 108.97,120.64 102.62,114.29 102.62,112.11 101.17,110.66 97.21,110.66 86.96,100.41 81.25,100.41 79.71,98.88 79.71,94.44 79.03,93.76 77.39,93.76 76.64,93.01 76.64,91.43 76.26,91.05 76.26,90.54 77.4,89.4 77.4,82.27 76.93,81.8 76.93,79.09 76.17,78.33 76.17,76.28 75.79,75.9 75.79,67.32 77.58,65.53 78.12,65.53 78.46,65.2 78.46,60.28 77.71,59.53 77.71,50.64 77.31,50.24 77.31,44.28 79.22,42.37 79.22,36.78 82.01,33.99 82.01,28.48 v1(83.7,26.8)
  BOTTOM w0.097: R25.1 146.27,156.16 v1(146.65,156.54) 146.27,156.92 TP21.1 ; U1.BL30 v3(152.33,151.87)
XDP_PRS: length 2.5
  TOP w0.097: R594.1 v1(232.76,45.8)
  BOTTOM w0.097: R336.1 v2(233.01,45.04) 233.01,45.55 v1(232.76,45.8)
XDP_TCK: length 305.3
  TOP w0.097: v1(150.29,150.26) 150.51,150.48 R27.1 ; R220.2 249.78,57.1 250.67,56.21 v2(251.68,56.21) 252.06,55.83 253.46,55.83 254.1,55.2 v1(254.1,54.18)
  IN03 w0.091: v1(150.29,150.26) 150.29,150.62 148.43,152.48 146.53,152.48 145,154 145,159.08 147.42,161.5 166.09,161.5 168.24,159.34 181.83,159.34 182.6,160.1 182.6,163.4 185.64,166.45 200.63,166.45 201.39,167.21 201.39,175.47 201.77,175.85 207.22,175.85 207.69,175.38 207.69,162.44 v1(208.63,161.5)
  IN08 w0.091: v1(208.63,161.5) 209.14,161.5 210.15,160.48 210.15,149.18 205.2,144.22 205.2,127.08 204.33,126.21 204.33,117.28 204.83,116.78 210.29,116.78 214.47,112.6 214.98,112.6 215.87,111.71 215.87,107.09 215.16,106.38 213.13,106.38 209.74,102.98 209.74,100.37 208.88,99.52 208.88,95.47 206.44,93.02 206.44,76.7 207.61,75.52 218.41,75.52 220.19,73.74 220.19,69.68 223.11,66.75 225.01,66.75 226.66,65.1 228.06,65.1 228.32,64.84 233.64,64.84 234.05,65.25 240.76,65.25 241.17,64.84 247.11,64.84 249.02,66.75 251.81,66.75 252.45,67.39 252.45,68.91 254.1,70.56 256.13,70.56 256.64,70.06 256.64,69.68 256.94,69.37 257.83,69.37 258.03,69.17 258.03,63.2 256.13,61.29 256.13,59.77 256.76,59.13 257.91,59.13 258.16,58.88 258.16,53.93 257.02,52.78 255.49,52.78 v1(254.1,54.18)
  BOTTOM w0.097: v1(150.29,150.26) 150.29,150.33 U1.BR28 149.51,150.19 147.8,150.19 146.27,148.67 TP48.1
XDP_TDI: length 379.8
  TOP w0.097: R306.2 v2(253.08,54.31) 253.08,54.05 TP51.1 253.72,53.42 v1(254.1,53.42)
  IN03 w0.091: v1(156.94,40.08) 156.4,40.63 156.4,41.06 148.26,49.2 119.48,49.2 107.82,37.54 98.52,37.54 98.39,37.67 92.93,37.67 91.77,36.51 v1(90.37,36.51)
  IN05 w0.091: v1(151.59,153.41) 151.2,153.01 148.84,153.01 147.92,152.1 143.23,152.1 142.46,152.86 142.46,156.29 133.7,165.05 130.02,165.05 116.56,151.59 116.56,124.03 106.78,114.25 v1(106.78,113.74)
  IN08 w0.091: v1(90.37,36.51) 90.58,36.72 90.58,59.96 85.44,65.1 85.44,66.37 84.68,67.14 82.01,67.14 79.48,69.67 79.48,78.19 80.41,79.12 80.41,87.88 81.76,89.24 81.76,94.01 82.06,94.31 84.42,94.31 98.26,108.15 102.57,108.15 106.14,111.71 106.14,113.11 v1(106.78,113.74)
  IN10 w0.091: v1(254.1,53.42) 253.33,52.66 253.33,48.47 252.7,47.83 252.7,46.82 252.32,46.43 252.32,44.28 248.23,40.19 214.98,40.19 211.53,43.64 207.64,43.64 204.71,40.72 186.43,40.72 185.19,39.48 160.39,39.48 158.94,40.94 157.79,40.94 v1(156.94,40.08)
  BOTTOM w0.097: U1.BL32 152.56,153.41 v1(151.59,153.41)
XDP_TDO: length 388
  TOP w0.097: R507.2 v1(252.83,55.2)
  IN05 w0.091: v1(108.05,114.25) 117.06,123.27 117.06,150.7 130.91,164.54 133.32,164.54 141.7,156.16 141.7,151.97 143.1,150.57 v1(146.65,150.57) ; v1(252.83,55.2) 251.96,54.33 251.96,48.11 251.43,47.58 251.05,47.58 248.89,45.42 248.89,44.02 247.62,42.75 236.57,42.75 234.28,45.04 229.97,45.04 229.59,45.42 229.59,45.93 229.1,46.41 224.21,46.41 224.06,46.56 223.87,46.56 223.11,47.32 218.03,47.32 217.01,46.31 215.87,46.31 214.85,47.32 213.2,47.32 212.9,47.63 202.68,47.63 201.52,48.79 192.19,48.79 189.11,45.71 153.51,45.71 152.91,45.1 121.23,45.1 119.31,43.18 119.31,31.61 118.72,31.02 113.75,31.02 110.57,27.84 95.42,27.84 94.5,26.92 93.49,26.92 93.06,26.5 v1(93.06,26.5)
  IN08 w0.091: v1(108.05,114.25) 108.05,113.74 107.41,113.11 107.41,112.09 102.96,107.64 98.64,107.64 84.81,93.81 82.77,93.81 82.56,93.6 82.56,82.8 80.95,81.19 80.95,79.05 79.98,78.07 79.98,69.93 82.27,67.64 84.93,67.64 85.95,66.63 85.95,65.46 91.07,60.34 91.07,28.37 92.94,26.5 v1(93.06,26.5)
  BOTTOM w0.097: R24.1 146.53,149.69 146.65,149.81 TP49.1 v1(146.65,150.57) 146.81,150.42 149.08,150.42 U1.BT28
XDP_TMS: length 389.1
  IN05 w0.091: v1(150.94,150.26) 150.56,149.88 147.86,149.88 147.54,149.56 145.37,149.56 144.73,150.19 142.72,150.19 141.32,151.59 141.32,156.04 133.19,164.16 131.03,164.16 117.44,150.57 117.44,122.25 v1(108.05,112.86) ; v1(252.83,53.42) 252.19,52.78 252.19,48.07 250.31,46.18 250.25,46.18 250.16,46.09 250.16,44.15 248.47,42.46 236.45,42.46 234.16,44.74 229.84,44.74 229.3,45.29 225.65,45.29 224.89,46.05 222.85,46.05 221.88,47.03 218.15,47.03 217.13,46.01 215.75,46.01 214.73,47.03 213.08,47.03 212.79,47.32 202.57,47.32 201.46,48.44 192.34,48.44 189.32,45.41 153.63,45.41 153.03,44.81 121.35,44.81 119.6,43.06 119.6,31.48 118.84,30.72 113.87,30.72 110.7,27.55 95.64,27.55 94.58,26.5 v1(94.33,26.5)
  IN08 w0.091: v1(108.05,112.86) 108.05,112.22 103.16,107.33 98.77,107.33 84.86,93.42 84.04,93.42 83.03,92.41 83.03,82.76 81.38,81.11 81.38,78.82 80.91,78.36 80.91,75.69 80.36,75.14 80.36,70.06 82.48,67.94 85.27,67.94 86.33,66.88 86.33,65.54 91.36,60.5 91.36,29.84 94.33,26.88 v1(94.33,26.5)
  BOTTOM w0.076: v1(150.94,150.26) 150.62,150.58 U1.BP28
  BOTTOM w0.097: v1(252.83,53.42) 252.83,53.22 R216.2 ; TP52.1 148.56,151.08 148.69,150.96 150.32,150.96 U1.BP28
XDP_TRST_N: length 390
  TOP w0.097: R29.1 TP50.1 150.08,153.24 150.3,153.03 v3(150.3,152.62)
  IN05 w0.091: v1(95.85,26.11) 96.56,26.82 111.03,26.82 114.21,29.99 119.25,29.99 120.12,30.86 120.12,42.85 121.57,44.3 153.97,44.3 154.21,44.53 189.6,44.53 192.47,47.39 201.47,47.39 202.05,46.81 212.57,46.81 212.98,46.4 214.63,46.4 215.53,45.5 224.71,45.5 225.44,44.78 229.08,44.78 229.63,44.23 233.95,44.23 236.23,41.94 248.97,41.94 250.92,43.89 250.92,46.13 252.64,47.84 252.64,49.29 v1(254.1,50.75) ; v3(150.3,152.62) 148.95,152.62 147.8,151.46 145.38,151.46 144.75,150.83 143.48,150.83 142.08,152.23 142.08,156.29 133.57,164.8 130.53,164.8 116.81,151.08 116.81,123.78 107.28,114.25 107.28,113.36 v1(106.78,112.86)
  IN08 w0.091: v1(95.85,26.11) 95.35,25.61 93.09,25.61 90.8,27.89 90.8,60.13 85.69,65.23 85.69,66.5 84.81,67.39 82.14,67.39 79.7,69.83 79.7,78.1 80.74,79.14 80.74,87.83 82.14,89.23 82.14,93.81 82.39,94.06 84.68,94.06 98.51,107.89 102.83,107.89 106.78,111.84 v1(106.78,112.86)
  BOTTOM w0.097: U1.BP30 150.62,152.3 v3(150.3,152.62) ; R202.2 252.19,50.75 252.7,50.24 253.59,50.24 v1(254.1,50.75)
XTAL_IN: length 19.4
  BOTTOM w0.097: Y6.1 219.03,113.99 219.96,114.92 221.32,114.92 221.74,114.51 222.42,114.51 C1399.1 222.78,114.51 223.43,114.51 v2(223.62,114.33) 223.8,114.51 224.69,114.51 225.34,115.16 234.3,115.16 235.43,116.28 236.2,116.28 G2.BL6
XTAL_LAN_IN: length 4.3
  TOP w0.097: U6.8 45.96,67.04 R281.2 45.87,68.13 C276.1 45.89,69.45 Y4.1
XTAL_LAN_OUT: length 6
  TOP w0.097: U6.7 46.36,66.94 46.56,67.14 R281.1 46.78,67.52 46.73,67.57 C277.1 46.73,68.18 47.42,68.86 47.42,69.98 47.08,70.32 Y4.3
XTAL_OUT: length 19.1
  BOTTOM w0.097: G2.BM6 235.43,116.67 234.2,115.43 225.05,115.43 v2(224.89,115.27) 224.4,114.79 223.01,114.79 C1400.1 222.19,114.79 221.84,114.79 221.43,115.19 219.91,115.19 219.81,115.29 219.81,116.02 219.9,116.11 Y6.3
N34955: length 2.9
  BOTTOM w0.097: R264.1 27.2,53.8 26.69,53.8 C247.1 25.93,54.56 v2(25.34,54.56)
N151202: length 1.8
  TOP w0.254: v2(121.33,201.07) PR1243.1 PC1158.1
N151523: length 0.9
  BOTTOM w0.254: PC1133.1 121.3,197.82 PR1162.2
N153421: length 3.6
  TOP w0.203: v2(116,195.61) PR1165.2 116.02,196.5 PC1137.1 116.86,196.52 PC1139.1 PR1166.1
N162072: length 42.7
  IN05 w0.127: v1(122.96,199.72) 123.21,199.47 124.43,199.47 128.11,195.79 130.53,195.79 130.91,195.41 130.91,194.26 130.53,193.88 130.53,188.29 139.8,179.02 148.54,179.02 148.85,178.71 149.51,178.71 v1(149.58,178.77)
  BOTTOM w0.254: PH1103.2 149.73,178.77 v1(149.58,178.77) ; PR1146.1 PR1148.2 123.29,200.05 v1(122.96,199.72)
N168892: length 3
  TOP w0.203: PR1190.1 131.29,187.53 v2(130.74,188.08) 129.62,189.2 PU1101.27
N169056: length 5.8
  TOP w0.203: PU1101.13 122.79,189.2 122.52,188.93 122.52,187.79
  TOP w0.381: PR1197.2 120.62,185.04 PC1153.2 120.64,185.91 121.51,186.77 121.99,186.77 v2(122.21,186.99) 122.52,187.3 122.52,187.79
N170540: length 0.9
  TOP w0.254: PC1151.1 PR1195.1
N170610: length 0.9
  BOTTOM w0.254: PR1194.2 123.69,186.06 PC1150.1
N171722: length 105.9
  TOP w0.254: PR1198.1 126.69,185.14 PR1199.2 125.83,183.57 v1(125.85,183.54)
  IN03 w0.203: v1(209.29,177.63) 209.04,177.88 208.63,177.88 207.11,176.36 201.65,176.36 201.01,175.72 201.01,167.77 200.2,166.96 186.53,166.96 185.88,167.61 172.71,167.61 170.55,165.46 150.82,165.46 147.9,168.38 147.9,170.67 147.67,170.89 142.46,170.89 131.03,182.32 127.35,182.32 126.13,183.54 v1(125.85,183.54)
  BOTTOM w0.254: PH1106.2 209.21,177.55 v1(209.29,177.63)
N172077: length 6
  TOP w0.203: PU1101.22 127.13,187.57 127.48,187.23 127.48,186.34 PC1142.2 128.04,186.08 128.26,185.86 128.26,184.76 PR1176.1 v2(128.8,183.32)
N187198: length 2.7
  TOP w0.203: 121.51,191.09 121.62,191.2 PU1101.8
  TOP w0.381: 121.51,191.09 121.33,190.91 PR1188.2
N187431: length 32.8
  IN03 w0.203: v1(148.18,178.01) 146.02,178.01 135.99,188.04 131.29,188.04 130.45,188.88 130.45,191.01 131.44,192 v1(131.44,192.97)
  BOTTOM w0.254: PR1179.2 129.89,192.87 130.07,193.04 PR1180.1 131.36,193.04 v1(131.44,192.97) ; PH1105.1 149.14,175.52 148.18,176.48 v1(148.18,178.01)
N188686: length 98.6
  IN05 w0.254: v1(118.76,187.38) 119.22,186.92 122.04,186.92 123.26,185.7 127.78,185.7 137,176.48 151.99,176.48 153.13,177.63 166.34,177.63 167.23,176.74 207.61,176.74 207.74,176.86 v1(209.29,176.86)
  BOTTOM w0.254: v1(209.29,176.86) 208.99,176.56 PH1107.1 ; v1(118.76,187.38) 118.79,187.4 PR1181.2 PR1182.1
N16691093: length 25.7
  BOTTOM w0.076: U2005.AB7 55.72,88.59 56.22,88.59 56.32,88.49 56.33,88.49
  BOTTOM w0.097: C2043.1 69.66,74.26 68.97,74.26 68.84,74.39 67.06,74.39 66.68,74.77 66.68,77.22 67.02,77.55 67.02,81.01 65.25,82.78 65.25,84.92 v1(63.64,86.53) 62.34,87.83 61.03,87.83 60.63,88.23 60.37,88.49 56.33,88.49
N16691099: length 25.7
  BOTTOM w0.076: U2005.AC7 55.84,88.36 55.77,88.28 55.77,88.19 55.84,88.13 56.11,88.13 56.21,88.22 56.54,88.22
  BOTTOM w0.097: C2044.1 69.61,73.98 68.86,73.98 68.72,74.12 66.94,74.12 66.41,74.65 66.41,77.33 66.74,77.66 66.74,80.9 64.97,82.67 64.97,84.81 62.22,87.56 60.91,87.56 v1(60.58,87.89) 60.25,88.22 56.54,88.22
N16691181: length 24.9
  BOTTOM w0.076: U2005.AB9 55.72,87.67 56.13,87.67 56.18,87.62
  BOTTOM w0.097: 56.18,87.62 56.2,87.6 59.94,87.6 v1(61.95,85.59) 64.36,83.19 64.36,82.43 65.76,81.03 65.76,74.39 66.97,73.18 68.56,73.18 68.99,72.75 69.68,72.75 C2045.1
N16691187: length 24.9
  BOTTOM w0.076: 56.22,87.28 56.15,87.21 55.86,87.21 55.79,87.27 55.79,87.38 55.86,87.44 U2005.AC9
  BOTTOM w0.097: 56.22,87.28 56.27,87.33 59.83,87.33 64.08,83.07 64.08,82.31 v1(64.59,81.81) 65.48,80.91 65.48,74.28 66.85,72.91 68.45,72.91 68.88,72.47 69.6,72.47 C2047.1
N16691295: length 25.1
  BOTTOM w0.076: U2005.AB11 55.72,86.75 56.13,86.75 56.18,86.7
  BOTTOM w0.097: C2049.1 69.64,71.18 69.1,71.18 68,72.28 66.59,72.28 64.87,74 v1(64.87,77.31) 64.87,80.62 63.47,82.02 63.47,82.56 59.34,86.68 56.2,86.68 56.18,86.7
N16691301: length 25.1
  BOTTOM w0.076: U2005.AC11 55.8,86.52 55.75,86.47 55.75,86.37 55.83,86.29 56.12,86.29
  BOTTOM w0.097: C2050.1 69.64,70.91 68.98,70.91 67.89,72.01 66.48,72.01 v1(65.53,72.95) 64.59,73.89 64.59,80.51 63.19,81.91 63.19,82.44 59.23,86.41 56.24,86.41 56.12,86.29
N16691335: length 25.2
  BOTTOM w0.076: U2005.AB13 55.72,85.83 56.13,85.83 56.18,85.78
  BOTTOM w0.097: 56.18,85.78 56.2,85.76 58.82,85.76 61.23,83.35 v1(61.23,83.34) 61.45,83.13 62.45,82.12 62.45,81.71 63.97,80.19 63.97,73.58 66.23,71.32 67.53,71.32 69.15,69.71 69.64,69.71 C2051.1
N16691365: length 25.3
  BOTTOM w0.076: U2005.AC13 55.8,85.6 55.75,85.55 55.75,85.45 55.83,85.37 56.12,85.37
  BOTTOM w0.097: 56.12,85.37 56.24,85.49 58.7,85.49 59.15,85.04 61.04,83.15 61.25,82.93 62.18,82.01 62.18,81.6 63.7,80.08 63.7,73.46 66.12,71.05 67.42,71.05 v1(67.67,70.79) 69.03,69.44 69.64,69.44 C2052.1
N16691909: length 9
  BOTTOM w0.076: U2005.Y23 54.58,81.16 54.51,81.23 54.41,81.23 54.34,81.16 54.34,80.83 54.5,80.67 54.5,80.53 55,80.04 55.6,80.04 55.65,79.99 55.67,79.99
  BOTTOM w0.104: 55.67,79.99 57.09,79.99 v1(57.5,79.58) 58.77,78.31 58.77,75.86 58.67,75.76 C2027.1
N16691941: length 4.9
  BOTTOM w0.076: 54.29,79.01 54.28,79.01 54.23,79.06 53.73,79.06 52.66,80.13 52.66,80.67 52.5,80.83 52.5,81.16 52.57,81.23 52.67,81.23 52.74,81.16 U2005.T23
  BOTTOM w0.104: C2031.1 54.85,78.54 54.85,78.68 54.52,79.01 54.29,79.01
N16691945: length 4.9
  BOTTOM w0.076: U2005.T22 52.96,81.23 52.96,80.82 52.81,80.67 52.81,80.2 53.8,79.21 54.22,79.21 54.28,79.27 54.29,79.27
  BOTTOM w0.104: C2033.1 55.1,78.33 55.1,78.79 54.62,79.27 54.29,79.27
N16691949: length 9.1
  BOTTOM w0.076: 55.67,80.24 55.65,80.24 55.6,80.19 55.06,80.19 54.65,80.6 54.65,80.67 54.8,80.82 54.8,81.23 U2005.Y22
  BOTTOM w0.104: 55.67,80.24 57.2,80.24 v1(58.77,78.67) 59.03,78.42 59.03,75.93 C2029.1
N16693389: length 6.1
  BOTTOM w0.076: U2005.V23 53.66,81.16 53.59,81.23 53.49,81.23 53.42,81.16 53.42,80.83 53.58,80.67 53.58,80.39 54.34,79.63 54.83,79.63 55.09,79.38 55.9,79.38 56.13,79.15 56.15,79.15 56.21,79.09 56.21,79.06 56.22,79.05 56.23,79.05
  BOTTOM w0.104: 56.23,79.05 56.65,79.05 57.17,78.53 57.17,78.46 C2028.2
N16693435: length 6.1
  BOTTOM w0.076: U2005.V22 53.88,81.23 53.88,80.82 53.73,80.67 53.73,80.45 54.4,79.78 54.9,79.78 55.15,79.53 55.96,79.53 56.19,79.3 56.23,79.3
  BOTTOM w0.104: C2030.2 57.43,78.37 57.43,78.63 56.76,79.3 56.23,79.3
N16693587: length 9.4
  BOTTOM w0.076: 51.69,80.34 51.69,80.36 51.74,80.41 51.74,80.67 51.58,80.83 51.58,81.16 51.65,81.23 51.75,81.23 51.82,81.16 U2005.P23
  BOTTOM w0.104: C2032.2 55.82,74.26 55.82,74.65 v1(54.33,76.15) 54.02,76.46 53.76,76.46 53.11,77.12 53.11,78.38 51.69,79.8 51.69,80.34
N16693593: length 9.5
  BOTTOM w0.076: U2005.P22 52.04,81.23 52.04,80.82 51.89,80.67 51.89,80.41 51.95,80.36 51.95,80.34
  BOTTOM w0.104: C2034.2 56.08,74.44 56.08,74.76 v1(55.45,75.39) 54.13,76.72 53.87,76.72 53.36,77.22 53.36,78.49 51.95,79.9 51.95,80.34
N16693655: length 10.2
  BOTTOM w0.076: 49.85,80.34 49.85,80.36 49.9,80.41 49.9,80.67 49.74,80.83 49.74,81.16 49.81,81.23 49.91,81.23 49.98,81.16 U2005.K23
  BOTTOM w0.104: 49.85,80.34 49.85,78.98 50.9,77.93 v1(50.9,77.04) 50.9,74.99 49.9,74 49.08,74 48.95,74.12 48.95,74.38 48.86,74.46 48.74,74.46 C2036.2
N16693677: length 10.2
  BOTTOM w0.076: U2005.K22 50.2,81.23 50.2,80.82 50.06,80.67 50.06,80.41 50.11,80.36 50.11,80.34
  BOTTOM w0.104: C2038.2 v1(49.63,73.74) 50.01,73.74 51.15,74.89 51.15,78.04 50.11,79.08 50.11,80.34
N16693763: length 3.6
  BOTTOM w0.076: U2005.F23 48.14,81.16 48.07,81.23 47.97,81.23 47.9,81.16 47.9,80.83 48.06,80.67 48.06,80.41 48.01,80.36 48.01,80.34
  BOTTOM w0.104: C2040.2 47.59,78.48 47.59,79.2 48.01,79.62 48.01,80.34
N16693769: length 3.6
  BOTTOM w0.076: 48.27,80.34 48.27,80.36 48.22,80.41 48.22,80.67 48.36,80.82 48.36,81.23 U2005.F22
  BOTTOM w0.104: 48.27,80.34 48.27,79.51 47.85,79.09 47.85,78.6 C2042.2
N16693791: length 5.9
  BOTTOM w0.076: 50.77,80.34 50.77,80.36 50.82,80.41 50.82,80.67 50.66,80.83 50.66,81.16 50.73,81.23 50.83,81.23 50.9,81.16 U2005.M23
  BOTTOM w0.104: 50.77,80.34 50.77,79.85 52.3,78.33 52.3,76.59 52.3,76.58 C2035.1
N16693827: length 4.6
  BOTTOM w0.076: 48.93,80.34 48.93,80.36 48.98,80.41 48.98,80.67 48.82,80.83 48.82,81.16 48.89,81.23 48.99,81.23 49.06,81.16 U2005.H23
  BOTTOM w0.104: 48.93,80.34 48.93,78.75 49.5,78.18 49.5,77.46 C2039.1
N16693831: length 4.6
  BOTTOM w0.076: 49.19,80.34 49.19,80.36 49.14,80.41 49.14,80.67 49.28,80.82 49.28,81.23 U2005.H22
  BOTTOM w0.104: 49.19,80.34 49.19,78.86 49.76,78.29 49.76,77.64 C2041.1
N16693835: length 5.9
  BOTTOM w0.076: U2005.M22 51.12,81.23 51.12,80.82 50.98,80.67 50.98,80.41 51.03,80.36 51.03,80.34
  BOTTOM w0.104: 51.03,80.34 51.03,79.96 52.55,78.43 v1(52.55,77.55) 52.55,76.69 C2037.1
N16694173: length 28.2
  BOTTOM w0.076: U2005.AB15 55.72,84.91 56.13,84.91 56.18,84.86
  BOTTOM w0.097: 56.18,84.86 56.2,84.84 57.85,84.84 63.08,79.61 63.08,77.68 63.08,76.73 63.08,76.73 63.08,76.72 63.08,76.18 v1(63.08,71.66) 63.08,71.27 59.56,67.75 59.56,64.65 59.22,64.31 59.22,63.56 59.36,63.43 59.67,63.43 C2056.1
N16694179: length 28.3
  BOTTOM w0.076: U2005.AC15 55.8,84.68 55.75,84.63 55.75,84.53 55.83,84.45 56.12,84.45
  BOTTOM w0.097: C2057.1 59.69,63.15 59.24,63.15 58.95,63.45 58.95,64.42 59.28,64.76 59.28,67.87 62.8,71.39 v1(62.8,73.69) 62.8,76.43 62.8,76.81 62.8,79.5 57.73,84.57 56.24,84.57 56.12,84.45
N16694217: length 28.9
  BOTTOM w0.076: U2005.AB17 55.72,83.99 56.13,83.99 56.18,83.94
  BOTTOM w0.097: C2058.1 59.66,62.17 58.9,62.17 57.99,63.08 57.99,64.38 58.26,64.65 v1(58.26,67.37) 58.26,67.76 62.19,71.69 62.19,77.25 62.19,77.79 62.2,77.8 62.19,77.8 62.19,78.75 62.19,78.75 62.19,79.21 57.48,83.92 56.2,83.92 56.18,83.94
N16694223: length 28.9
  BOTTOM w0.076: U2005.AC17 55.8,83.76 55.75,83.71 55.75,83.61 55.83,83.53 56.12,83.53
  BOTTOM w0.097: C2059.1 59.7,61.9 58.78,61.9 57.71,62.97 57.71,64.5 57.98,64.76 v1(57.98,65.15) 57.98,67.87 61.92,71.8 61.92,77.36 61.92,77.5 61.92,77.88 61.92,79.1 57.37,83.65 56.24,83.65 56.12,83.53
N16694285: length 29.1
  BOTTOM w0.076: 56.18,83.02 56.13,83.07 55.72,83.07 U2005.AB19
  BOTTOM w0.097: C2060.1 59.68,61 58.64,61 57.06,62.58 v1(57.06,62.96) 57.06,67.85 61.29,72.08 61.29,75.31 61.29,75.85 61.29,75.86 61.29,75.86 61.29,75.94 61.29,76.81 61.29,78.85 57.14,83 56.2,83 56.18,83.02
N16694291: length 29.2
  BOTTOM w0.076: 56.12,82.61 55.83,82.61 55.75,82.69 55.75,82.79 55.8,82.84 U2005.AC19
  BOTTOM w0.097: C2061.1 59.68,60.72 v1(58.78,60.72) 58.52,60.72 56.79,62.46 56.79,67.96 61.01,72.19 61.01,75.42 61.01,75.56 61.02,75.94 61.02,76.81 61.02,78.74 57.02,82.73 56.24,82.73 56.12,82.61
N16694353: length 32
  BOTTOM w0.076: 56.18,82.1 56.13,82.15 55.72,82.15 U2005.AB21
  BOTTOM w0.097: 56.18,82.1 56.2,82.08 56.76,82.08 60.22,78.63 60.22,75.96 60.22,75.96 60.22,75.96 60.22,75.41 60.22,75.41 60.22,72.56 55.86,68.2 55.86,62.97 54.79,61.91 v1(54.79,61.26) 54.79,60.6 55.71,59.69 59.67,59.69 C2062.1
N16694359: length 32
  BOTTOM w0.076: U2005.AC21 55.8,81.92 55.75,81.87 55.75,81.77 55.83,81.69 56.12,81.69
  BOTTOM w0.097: 56.12,81.69 56.24,81.81 56.65,81.81 59.94,78.51 59.94,75.66 59.94,75.66 59.94,72.68 55.58,68.32 55.58,63.09 54.52,62.02 54.52,60.49 55.59,59.42 v1(57.63,59.42) 59.67,59.42 C2063.1
N16694397: length 6.5
  TOP w0.097: C2133.2 59.5,86.06 59.6,85.96 59.6,85.73 59.5,85.63 58.7,85.63 58.27,86.06 57.4,86.06 57.01,86.44 54.91,86.44 54.85,86.38 v2(54.47,86.38)
  BOTTOM w0.102: U2005.Y12 v2(54.47,86.38)
N16694403: length 6.6
  TOP w0.097: C2134.2 59.14,85.36 58.58,85.36 58.16,85.78 v1(57.95,85.78) 57.28,85.78 56.9,86.17 55.02,86.17 54.86,86.01 54.25,86.01 53.87,86.38 v2(53.82,86.38)
  BOTTOM w0.102: v2(53.82,86.38) U2005.W12
N16694687: length 43.2
  IN03 w0.114: v2(54.47,84.43) 54.28,84.24 54.28,84.16 54.61,83.82 55.44,83.82 55.85,83.42 55.85,81.61 55.39,81.16 53.61,81.16 48.48,76.03 47.09,76.03 45.56,74.5 45.56,71.71 43.78,69.93 43.78,68.42 43.26,67.9 42.64,67.9 40.72,65.98 32.12,65.98 31.45,66.64 31.45,68.14 31.19,68.41 30.1,68.41 29.97,68.28 29.97,68.04 v1(30.25,67.76)
  BOTTOM w0.104: v1(30.25,67.76) 29.97,68.04 29.97,68.67 C2070.1
  BOTTOM w0.114: v2(54.47,84.43) 54.8,84.76 U2005.Y15
N16694693: length 43.2
  IN03 w0.114: v1(29.43,67.76) 29.71,68.04 29.71,68.39 29.99,68.67 31.3,68.67 31.72,68.25 31.72,66.75 32.23,66.25 40.61,66.25 42.53,68.16 43.15,68.16 43.52,68.53 43.52,70.04 45.3,71.82 45.3,74.61 46.98,76.29 48.37,76.29 53.5,81.42 55.28,81.42 55.58,81.72 55.58,83.31 55.33,83.56 54.5,83.56 54.01,84.04 54.01,84.24 v2(53.82,84.43)
  BOTTOM w0.104: C2071.1 29.71,68.67 29.71,68.04 v1(29.43,67.76)
  BOTTOM w0.114: v2(53.82,84.43) 54.15,84.76 U2005.W15
N16695077: length 2.4
  BOTTOM w0.076: 45.34,83.57 45.36,83.57 45.36,83.58 45.45,83.58 arc(45.48,83.57) 45.5,83.57 45.63,83.53 arc(45.65,83.53) 45.66,83.53 45.91,83.53 arc(46.06,83.56) 46.18,83.64 U2005.B17
  BOTTOM w0.097: 45.34,83.57 44.43,83.57 arc(44.37,83.57) 44.31,83.58 44.29,83.58 arc(44.16,83.54) C2067.1
N16695083: length 2.4
  BOTTOM w0.076: U2005.A17 45.95,83.76 arc(46.03,83.79) 46.06,83.87 46.06,83.87 arc(46.03,83.96) 45.94,83.99 45.72,83.99 arc(45.7,83.99) 45.68,83.98 45.43,83.88
  BOTTOM w0.097: 45.43,83.88 arc(45.34,83.85) 45.24,83.84 44.43,83.84 arc(44.25,83.88) C2066.1
N16695201: length 2.5
  BOTTOM w0.076: U2005.B19 46.18,82.95 arc(46.06,83.04) 45.91,83.07 45.73,83.07 arc(45.7,83.06) 45.67,83.04 45.66,83.03 arc(45.63,83.01) 45.58,83 45.5,83
  BOTTOM w0.097: 45.5,83 arc(45.48,83) 45.46,83 45.21,83 arc(45.01,82.96) 44.83,82.85 44.69,82.7 arc(44.58,82.63) 44.46,82.6 44.3,82.6 arc(44.16,82.66) C2069.1
N16695207: length 2.5
  BOTTOM w0.076: U2005.A19 45.96,82.84 arc(46.08,82.72) 45.96,82.61 45.76,82.61 arc(45.68,82.62) 45.61,82.67
  BOTTOM w0.097: 45.61,82.67 arc(45.54,82.71) 45.46,82.73 45.21,82.73 arc(45.11,82.71) 45.03,82.65 44.88,82.51 arc(44.78,82.43) 44.67,82.37 arc(44.57,82.34) 44.46,82.33 44.3,82.33 arc(44.19,82.31) C2068.1
N16731494: length 4.9
  BOTTOM w0.076: U2007.L4 31.18,73.82 29.84,73.82
  BOTTOM w0.089: R2087.2 28.37,72.34 v2(29.04,73.02) 29.84,73.82
N16731524: length 5.8
  BOTTOM w0.076: U2007.K4 31.49,73.62 30.18,73.62
  BOTTOM w0.089: R2088.2 27.12,71.61 v2(27.91,71.61) 28.16,71.61 30.18,73.62
N16732102: length 5.5
  TOP w0.089: v2(33.93,76.38) 33.93,77.52 34.13,77.72 v2(34.13,78.06) 32.89,78.06 R2078.2 R2077.2
  BOTTOM w0.089: U2007.F10 33.75,76.56 v2(33.93,76.38)
N16819243: length 2.7
  TOP w0.104: U6.32 50.12,61.29 50.19,61.36 50.36,61.36 51.13,60.6 51.52,60.6 R278.2
N16819245: length 2.7
  TOP w0.104: U6.33 50.12,61.69 50.19,61.62 50.47,61.62 51.24,60.85 51.52,60.85 R279.2
N16821473: length 3.4
  TOP w0.097: R282.1 48.48,67.39 v2(48.09,67) 47.42,66.32 47.42,66.07 47.16,65.81 U6.5
N16827117: length 4.4
  BOTTOM w0.457: TL1.7 v1(30.32,96.48) ; TL1.4 v1(30.36,99.48) ; TL1.10 v1(30.32,93.48) ; TL1.1 v1(30.36,102.48)
  vias: v2(30.2,101.04)
N16827394: length 1.7
  TOP w0.097: C291.1 19.46,104.66 v2(19.53,104.6)
N16843215: length 3.2
  BOTTOM w0.076: U2007.C10 35.5,77.13 36.8,77.13
  BOTTOM w0.089: R2063.2 37.66,76.53 37.06,77.13 36.8,77.13
N16897992: length 5.8
  BOTTOM w0.076: U2007.B2 35.99,72.64 35.99,72.13
  BOTTOM w0.089: 35.99,72.13 35.99,71.24 ; 37.64,68.91 37.69,68.96 37.69,69.93 37.48,70.13 R2060.2
  BOTTOM w0.097: 37.64,68.91 37.31,68.58 v2(37.31,68.28)
  BOTTOM w0.102: R2060.2 37.1,70.13 35.99,71.24
N16898760: length 2.2
  TOP w0.089: R2062.2 v2(35.15,76.99) 34.94,76.79 v2(34.94,76.43)
  BOTTOM w0.089: U2007.D10 34.75,76.63 v2(34.94,76.43)
N16899256: length 2.9
  BOTTOM w0.089: R2084.2 33.25,80.13 v2(33.25,79.2) U2007.G11
N16968466: length 1.2
  TOP w0.356: v2(34.13,73.36) 34.21,73.28 R2068.1
  BOTTOM w0.178: v2(34.13,73.36) 34.25,73.48 U2007.E4
N16968469: length 1.7
  TOP w0.356: v2(34.75,73.38) 34.84,73.29 34.84,73.03 R2070.1
  BOTTOM w0.178: v2(34.75,73.38) U2007.D5
N16968572: length 1.1
  TOP w0.356: v2(32.19,75.38) 32.23,75.43 C2131.2
  BOTTOM w0.178: U2007.H7 v2(32.19,75.38)
N16976376: length 3.6
  TOP w0.097: U7.18 286.73,29.46 v2(286.23,28.96) 285.47,28.2 C328.2 C329.2
N16976592: length 4.9
  TOP w0.203: v1(287.75,28.88) 287.93,29.06 U7.21
  BOTTOM w0.305: v1(287.75,28.88) 287.75,28.58 288.44,27.89 C326.2 C327.2 v2(288.94,26.09)
N16976910: length 2.9
  TOP w0.203: U7.22 288.33,28.94 v1(288.41,28.86)
  BOTTOM w0.097: C324.2 C325.1 288.44,28.88 v1(288.41,28.86)
N16977173: length 4.9
  TOP w0.203: U7.27 290.33,29.63 290.93,29.03 291.44,29.03 291.82,28.65 291.82,27.82 C318.2 v2(293.24,27.31)
N16977182: length 2.8
  TOP w0.203: C318.1 292.32,28.65 291.56,29.41 291.18,29.41 290.73,29.86 U7.28
