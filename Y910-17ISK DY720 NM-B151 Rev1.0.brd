# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DIM1_ODT2: length 85.5
  TOP w0.102: v1(173.23,71.96) 173.23,72.75 173.33,72.86 173.9,72.86 174,72.75 174,72.06 173.9,71.96 173.78,71.96 173.68,71.86 173.68,71.66 173.78,71.56 173.9,71.56 174,71.45 174,71.25 173.9,71.15 173.75,71.15 173.65,71.05 173.65,70.85 173.75,70.74 173.9,70.74 174,70.64 174,70.44 173.9,70.34 173.75,70.34 173.65,70.24 173.65,70.03 173.75,69.93 173.9,69.93 174,69.83 174,69.63 173.9,69.52 173.75,69.52 173.65,69.42 173.65,69.22 173.75,69.12 173.9,69.12 174,69.02 174,68.81 173.9,68.71 173.75,68.71 173.4,68.36 172.72,68.36 171.6,67.24 JDIMM4.155
  IN10 w0.076: 174.04,125.28 173.22,126.09 173.22,131.2 172.73,131.69 172.73,135.97 v1(173.11,136.35)
  IN10 w0.14: v1(173.23,71.96) 173.23,73.29 174.49,74.55 174.49,75.11 173.96,75.64 173.96,77.76 174.54,78.34 174.54,79.64 174.92,80.02 174.92,91.14 175.99,92.21 175.99,93.55 176.44,94 176.44,94.51 176.63,94.69 177.14,94.69 177.33,94.88 177.33,111.05 175.62,112.75 175.62,112.92 175.76,113.06 176.21,113.06 176.35,113.2 176.35,113.48 176.21,113.61 175.76,113.61 175.62,113.75 175.62,114.03 175.76,114.17 176.21,114.17 176.35,114.31 176.35,114.59 176.21,114.73 175.76,114.73 175.62,114.87 175.62,115.15 175.76,115.29 176.21,115.29 176.35,115.43 176.35,115.71 176.21,115.85 175.74,115.85 175.62,115.98 175.62,116.28 175.74,116.41 176.22,116.41 176.35,116.54 176.35,116.84 176.22,116.97 175.76,116.97 175.62,117.11 175.62,121.66 174.04,123.24 174.04,125.28
  BOTTOM w0.152: U1.AE9 v1(173.11,136.35)
M_B_DIM1_ODT3: length 85
  TOP w0.102: JDIMM4.161 173.1,67.1 173.39,67.39 174.31,67.39 175.54,68.62 175.54,70.35 175.64,70.45 175.89,70.45 175.99,70.55 175.99,70.76 175.89,70.86 175.64,70.86 175.54,70.96 175.54,71.16 175.64,71.26 175.89,71.26 175.99,71.37 175.99,71.57 175.89,71.67 175.64,71.67 175.35,71.96 v1(175.13,71.96)
  IN10 w0.076: 175.74,125.12 173.93,126.93 173.93,131.73 173.43,132.24 173.43,134.21 173.63,134.42 173.63,134.61 173.8,134.78 173.8,135.49 173.65,135.64 173.65,137.12 v1(173.11,137.65)
  IN10 w0.14: v1(175.13,71.96) 175.86,71.96 176.01,72.11 176.01,72.37 175.87,72.51 175.5,72.51 175.36,72.65 175.36,72.93 175.5,73.07 175.87,73.07 176.01,73.21 176.01,78.53 178.15,80.67 178.15,81.41 177.52,82.04 177.52,85.41 177.62,85.51 178.07,85.51 178.18,85.62 178.18,85.97 178.07,86.07 177.62,86.07 177.52,86.18 177.52,86.53 177.62,86.63 178.07,86.63 178.18,86.73 178.18,87.09 178.07,87.19 177.62,87.19 177.52,87.29 177.52,87.65 177.62,87.75 178.07,87.75 178.18,87.85 178.18,88.21 178.07,88.31 177.62,88.31 177.52,88.41 177.52,91.14 177.74,91.37 177.75,91.37 179.26,92.87 179.26,111.85 178.58,112.52 178.58,117.34 177.55,118.37 177.55,121.99 175.74,123.8 175.74,125.12
  BOTTOM w0.152: v1(173.11,137.65) U1.AE11
M_B_DQ0: length 94.3
  TOP w0.102: v1(132.32,68.05) 132.32,67.91 132.15,67.75 130.5,67.75 130.43,67.81 130.43,67.96 130.58,68.1 131.52,68.1 131.92,68.51 132.89,68.51 133.07,68.33 133.07,67.59 132.6,67.13 JDIMM4.7
  IN10 w0.13: v1(132.32,68.05) 133.45,69.19 133.45,71.33 133.16,71.63 133.16,92.56 132.33,93.38 132.33,107.9 132.54,108.11 132.54,108.43 132.33,108.64 132.33,108.93 132.54,109.15 132.54,109.46 132.33,109.68 132.33,109.97 132.54,110.18 132.54,110.5 132.33,110.71 132.33,111.01 132.54,111.22 132.54,111.54 132.33,111.75 132.33,112.04 132.54,112.26 132.54,112.57 132.33,112.79 132.33,113.08 132.54,113.29 132.54,113.61 132.33,113.82 132.33,114.11 132.54,114.33 132.54,114.65 132.33,114.86 132.33,115.15 132.54,115.36 132.54,115.68 132.33,115.89 132.33,116.14 133.19,117 133.19,120.25 142.56,129.62 142.56,131.56 v1(147.23,136.22)
  BOTTOM w0.102: JDIMM3.7 134.3,73.42 133.99,73.11 133.99,69.05 133,68.05 v1(132.32,68.05)
  BOTTOM w0.14: U1.BT11 149.01,136.96 148.36,136.96 147.62,136.22 v1(147.23,136.22)
M_B_DQ1: length 91.7
  TOP w0.102: JDIMM4.16 134.85,73.39 134.92,73.32 134.92,69.86 134.49,69.42 v1(134.47,69.42)
  IN10 w0.076: 147.25,134.84 147.25,135.19 148.26,136.2 v1(148.31,136.2)
  IN10 w0.13: v1(134.47,69.42) 134.77,69.42 134.9,69.29 134.9,68.51 135.02,68.38 135.41,68.38 135.54,68.51 135.54,73.23 135.39,73.38 135.39,80.78 134.69,81.47 134.69,92.96 134.3,93.36 134.3,93.64 134.17,93.77 134.08,93.77 133.95,93.9 133.95,94.16 134.08,94.29 134.17,94.29 134.3,94.42 134.3,94.71 134.17,94.84 134.06,94.84 133.93,94.97 133.93,95.23 134.06,95.36 134.17,95.36 134.3,95.49 134.3,95.75 134.17,95.88 134.01,95.88 133.88,96.01 133.88,96.27 134.01,96.4 134.17,96.4 134.3,96.53 134.3,96.79 134.17,96.92 134.01,96.92 133.88,97.05 133.88,97.3 134.01,97.43 134.17,97.43 134.3,97.56 134.3,97.82 134.17,97.95 134.01,97.95 133.88,98.08 133.88,98.34 134.01,98.47 134.17,98.47 134.3,98.6 134.3,98.86 134.17,98.99 134.01,98.99 133.88,99.12 133.88,99.38 134.01,99.51 134.17,99.51 134.3,99.64 134.3,99.91 134.04,100.17 134.04,115.36 134.59,115.9 134.59,119.76 143.56,128.73 143.56,131.14 147.25,134.84
  BOTTOM w0.102: v1(134.47,69.42) 134.58,69.52 134.82,69.52 135.01,69.33 135.01,67.86 135.22,67.65 136.42,67.65 136.55,67.52 JDIMM3.16
  BOTTOM w0.14: v1(148.31,136.2) 148.85,136.73 149.1,136.73 149.25,136.89 149.59,136.89 U1.BR11
M_B_DQ2: length 95.7
  TOP w0.102: v1(129.36,71.71) 128.67,72.39 128.67,74.7 129,75.04 130.37,75.04 130.91,74.5 130.91,73.54 131.14,73.31 131.62,73.31 131.85,73.54 JDIMM4.4
  IN10 w0.13: v1(145.64,136.32) 141.52,132.21 141.52,130.1 132.11,120.69 132.11,117.89 131.26,117.04 131.26,87.16 128.3,84.21 128.3,81.88 130.88,79.3 130.88,72.29 130.3,71.71 v1(129.36,71.71)
  BOTTOM w0.076: U1.BT8 148.95,135.46 148.64,135.77 147.11,135.77
  BOTTOM w0.102: JDIMM3.4 133.55,66.97 133.26,67.26 131.36,67.26 128.85,69.77 128.85,71.2 v1(129.36,71.71)
  BOTTOM w0.14: 147.11,135.77 146.19,135.77 v1(145.64,136.32)
M_B_DQ3: length 93
  TOP w0.102: v1(136.37,71.96) 135.38,70.98 135.38,67.65 135.1,67.37 JDIMM4.17
  IN10 w0.13: v1(147.85,135.06) 147.85,134.66 144.24,131.04 144.24,128.4 135.3,119.46 135.3,115.29 135.18,115.17 134.88,115.17 134.76,115.04 134.76,114.81 134.88,114.68 135.18,114.68 135.3,114.56 135.3,114.35 135.18,114.23 134.88,114.23 134.76,114.1 134.76,113.87 134.88,113.74 135.18,113.74 135.3,113.62 135.3,113.36 135.18,113.24 134.88,113.24 134.76,113.11 134.76,112.86 134.88,112.73 135.18,112.73 135.3,112.6 135.3,112.37 135.18,112.25 134.88,112.25 134.76,112.12 134.76,111.83 134.88,111.71 135.17,111.71 135.27,111.61 135.27,111.46 134.76,110.94 134.76,110.68 135.02,110.42 135.02,110.16 134.76,109.9 134.76,109.65 135.02,109.39 135.02,109.13 134.76,108.87 134.76,108.61 135.02,108.35 135.02,108.09 134.76,107.83 134.76,107.57 135.02,107.31 135.02,107.05 134.76,106.8 134.76,106.54 135.02,106.28 135.02,106.02 134.76,105.76 134.76,105.5 135.02,105.24 135.02,104.98 134.76,104.72 134.76,104.46 135.02,104.2 135.02,103.95 134.76,103.69 134.76,103.43 135.02,103.17 135.02,102.91 134.76,102.65 134.76,102.39 135.02,102.13 135.02,101.87 134.76,101.61 134.76,101.35 135.02,101.1 135.02,93.58 135.4,93.2 135.4,81.71 136.6,80.51 136.6,79.78 136.47,79.65 136.22,79.65 136.09,79.52 136.09,79.27 136.22,79.14 136.47,79.14 136.6,79.01 136.6,78.75 136.47,78.62 136.22,78.62 136.09,78.49 136.09,78.23 136.22,78.1 136.47,78.1 136.6,77.97 136.6,75.86 136.47,75.73 136.22,75.73 136.09,75.6 136.09,75.34 136.22,75.21 136.47,75.21 136.6,75.08 136.6,74.82 136.47,74.69 136.22,74.69 136.09,74.56 136.09,74.3 136.22,74.18 136.47,74.18 136.6,74.05 136.6,73.04 136.79,72.85 136.79,71.99 136.66,71.86 136.47,71.86 v1(136.37,71.96)
  BOTTOM w0.076: v1(147.85,135.06) 147.92,134.99 149.47,134.99 149.97,135.5 U1.BR8
  BOTTOM w0.102: JDIMM3.17 136.8,73.46 136.67,73.33 136.52,73.33 136.42,73.24 136.42,73.1 136.52,73 136.98,73 137.08,72.91 137.08,72.78 136.98,72.68 136.89,72.68 136.77,72.56 136.77,72.39 136.89,72.27 136.95,72.27 137.08,72.15 137.08,70.93 136.99,70.84 136.86,70.84 136.77,70.93 136.77,71.83 136.65,71.96 v1(136.37,71.96)
M_B_DQ4: length 97
  TOP w0.102: v1(132.32,72.72) 131.55,71.96 129.84,71.96 129.36,72.44 129.36,72.98 129.59,73.21 130.27,73.21 130.5,72.98 130.5,72.5 130.73,72.27 131.46,72.27 131.8,72.6 131.8,72.85 132.26,73.32 132.68,73.32 132.85,73.48 JDIMM4.8
  IN10 w0.076: v1(148.72,137.37) 147.42,137.37 146.45,136.4
  IN10 w0.13: 146.45,136.4 141.88,131.83 141.88,129.95 132.47,120.54 132.47,117.74 131.61,116.89 131.61,87.04 128.64,84.07 128.64,82.27 131.46,79.45 131.46,73.57 v1(132.32,72.72)
  BOTTOM w0.102: JDIMM3.8 134.55,66.97 133.88,67.64 132.15,67.64 131.91,67.88 131.91,68.22 132.18,68.49 132.44,68.49 133.32,69.37 133.32,71.72 v1(132.32,72.72)
  BOTTOM w0.14: U1.BP11 150.41,137.27 150.1,137.58 149.21,137.58 149,137.37 v1(148.72,137.37)
M_B_DQ5: length 93.9
  TOP w0.102: JDIMM4.3 131.6,67.3 131.5,67.4 129.7,67.4 129.38,67.72 129.38,68.2 129.66,68.48 131.44,68.48 131.9,68.94 v1(132.32,68.94)
  IN10 w0.076: v1(150.94,137.66) 149.81,137.66 149.06,136.91 147.39,136.91 146.46,135.98
  IN10 w0.13: v1(132.32,68.94) 133.01,69.64 133.01,71.05 132.8,71.26 132.8,92.45 131.97,93.27 131.97,116.41 132.83,117.27 132.83,120.39 142.23,129.8 142.23,131.75 146.46,135.98
  BOTTOM w0.102: JDIMM3.3 133.3,73.57 133,73.27 132.21,73.27 131.9,72.95 131.9,72.19 133.01,71.07 133.01,69.64 v1(132.32,68.94)
  BOTTOM w0.14: v1(150.94,137.66) 151.27,137.34 U1.BN11
M_B_DQ6: length 92.2
  TOP w0.102: v1(136.37,69.42) 136.39,69.42 136.77,69.8 136.77,72.77 136.43,73.11 136.15,73.11 135.85,73.41 JDIMM4.20
  IN10 w0.076: 147.01,134.21 147.43,134.64 147.43,135.16 147.76,135.49 148.29,135.49 v1(148.42,135.36)
  IN10 w0.13: 147.01,134.21 143.91,131.11 143.91,128.58 134.95,119.61 134.95,115.75 134.4,115.21 134.4,100.47 134.66,100.21 134.66,93.47 135.04,93.09 135.04,81.6 135.74,80.89 135.74,73.5 135.88,73.36 135.88,67.52 136.01,67.39 136.66,67.39 136.79,67.52 136.79,69 v1(136.37,69.42)
  BOTTOM w0.076: U1.BP8 150.33,135.98 149.87,135.98 149.68,135.79 149.68,135.44 149.44,135.2 148.58,135.2 v1(148.42,135.36)
  BOTTOM w0.102: v1(136.37,69.42) 135.66,69.42 135.35,69.12 135.35,68.43 135.62,68.16 136.79,68.16 137.55,67.4 JDIMM3.20
M_B_DQ7: length 91.4
  TOP w0.102: v1(136.37,70.69) 136.14,70.69 135.89,70.45 135.89,68.27 136.1,68.06 JDIMM4.21
  IN10 w0.13: v1(136.37,70.69) 136.8,70.26 136.8,69.73 137.27,69.26 137.27,68.63 137.4,68.51 137.92,68.51 138.04,68.63 138.04,69.32 137.43,69.93 137.43,70.43 137.12,70.74 137.12,72.99 136.93,73.18 136.93,80.65 135.76,81.82 135.76,86.23 135.88,86.35 136.02,86.35 136.15,86.48 136.15,86.74 136.02,86.87 135.88,86.87 135.76,87 135.76,87.26 135.88,87.39 136.02,87.39 136.15,87.52 136.15,87.78 136.02,87.91 135.88,87.91 135.76,88.04 135.76,90.49 135.88,90.62 136.02,90.62 136.15,90.75 136.15,91.01 136.02,91.14 135.88,91.14 135.76,91.27 135.76,91.53 135.88,91.66 136.02,91.66 136.15,91.79 136.15,92.05 136.02,92.18 135.88,92.18 135.76,92.3 135.76,93.31 135.37,93.69 135.37,111.04 135.66,111.33 135.66,119.31 144.55,128.2 144.55,130.92 149.72,136.09 v1(150.94,136.09)
  BOTTOM w0.102: v1(136.37,70.69) 136.52,70.54 137.12,70.54 137.38,70.81 137.38,73.16 137.8,73.58 JDIMM3.21
  BOTTOM w0.14: v1(150.94,136.09) 150.94,135.97 151.22,135.69 U1.BN8
M_B_DQ8: length 88.1
  TOP w0.102: JDIMM4.25 137.1,67.23 137.2,67.33 137.36,67.33 137.46,67.43 137.46,67.64 137.36,67.74 137.2,67.74 137.1,67.84 137.1,68.04 137.2,68.14 137.36,68.14 137.46,68.24 137.46,68.45 137.36,68.55 137.2,68.55 137.1,68.65 137.1,68.99 137.54,69.42 v1(138.54,69.42)
  IN10 w0.076: 149.9,135.43 150.19,135.72 151.1,135.72 152.24,136.87 v1(152.24,137.66)
  IN10 w0.13: v1(138.54,69.42) 138.12,69.84 138.12,70.31 137.45,70.97 137.45,73.13 137.26,73.32 137.26,80.96 136.84,81.38 136.84,92.72 136.14,93.42 136.14,110.72 136.43,111.01 136.43,119.11 144.86,127.55 144.86,129.89 148.2,133.23 148.76,133.23 149.11,133.57 149.11,134.64 149.9,135.43
  BOTTOM w0.102: JDIMM3.25 138.8,73.45 138.13,72.79 138.13,69.83 v1(138.54,69.42)
  BOTTOM w0.14: v1(152.24,137.66) 152.24,137.73 U1.BL12
M_B_DQ9: length 87.3
  TOP w0.102: v1(138.54,70.69) 137.89,70.69 137.52,71.06 137.52,72.91 137.53,72.91 137.53,73.04 137.24,73.32 137.11,73.32 136.85,73.58 JDIMM4.24
  IN10 w0.076: 150.08,134.57 150.09,134.57 151.03,135.51 151.11,135.51 152.52,136.93 152.52,137.13 v1(153.04,137.65)
  IN10 w0.13: v1(138.54,70.69) 138.21,70.69 137.79,71.11 137.79,73.3 137.6,73.49 137.6,81.1 137.2,81.49 137.2,92.83 136.5,93.54 136.5,95.86 136.98,96.34 136.98,100.36 136.85,100.48 136.63,100.48 136.5,100.61 136.5,100.87 136.63,101 136.85,101 136.98,101.13 136.98,101.39 136.85,101.52 136.63,101.52 136.5,101.65 136.5,108.48 136.63,108.61 136.66,108.61 136.78,108.74 136.78,109 136.66,109.13 136.63,109.13 136.5,109.26 136.5,109.52 136.63,109.65 136.66,109.65 136.78,109.78 136.78,110.03 136.66,110.16 136.63,110.16 136.5,110.29 136.5,110.55 136.63,110.68 136.66,110.68 136.78,110.81 136.78,118.96 145.18,127.36 145.18,127.77 146.1,128.68 146.1,130.03 146.5,130.43 146.65,130.43 147.6,131.39 147.6,131.41 148.25,132.06 148.27,132.06 148.55,132.34 148.91,132.34 149.32,132.74 149.32,133.81 150.08,134.57
  BOTTOM w0.102: JDIMM3.24 138.55,67.89 138.95,68.28 138.95,70.29 v1(138.54,70.69)
  BOTTOM w0.14: v1(153.04,137.65) U1.BL11
M_B_DQ10: length 88.4
  TOP w0.102: v1(138.54,71.96) 138.44,72.06 138.26,72.06 138.13,71.94 138.13,71.19 138.04,71.1 137.92,71.1 137.83,71.19 137.83,72.14 137.95,72.27 138.05,72.27 138.14,72.36 138.14,72.5 138.05,72.6 137.94,72.6 137.83,72.71 137.83,72.87 137.94,72.98 138.4,72.98 138.47,73.05 138.47,73.22 138.37,73.32 138.01,73.32 137.85,73.48 JDIMM4.28
  IN10 w0.076: v1(152.24,136.09) 151.47,135.31 151.04,135.31 150.31,134.58 150.31,134.5 150.08,134.27 150.08,134.26
  IN10 w0.13: 150.08,134.26 149.52,133.69 149.52,132.06 146.41,128.95 146.41,128.62 145.49,127.69 145.49,127.06 137.14,118.72 137.14,107.99 137.02,107.86 136.98,107.86 136.85,107.73 136.85,107.31 136.98,107.19 137.21,107.19 137.34,107.06 137.34,106.8 137.21,106.67 136.98,106.67 136.85,106.54 136.85,106.28 136.98,106.15 137.21,106.15 137.34,106.02 137.34,105.76 137.21,105.63 136.98,105.63 136.85,105.5 136.85,105.24 136.98,105.11 137.21,105.11 137.34,104.99 137.34,104.72 137.21,104.6 136.98,104.6 136.85,104.47 136.85,104.2 136.98,104.08 137.21,104.08 137.34,103.95 137.34,103.69 137.21,103.56 136.98,103.56 136.85,103.43 136.85,103.17 136.98,103.04 137.21,103.04 137.34,102.91 137.34,102.65 137.21,102.52 136.98,102.52 136.85,102.4 136.85,102.13 136.98,102 137.21,102 137.34,101.88 137.34,96.19 136.85,95.71 136.85,93.75 137.56,93.05 137.56,81.66 137.93,81.29 137.93,73.77 138.12,73.58 138.12,72.19 138.35,71.96 v1(138.54,71.96)
  BOTTOM w0.102: v1(138.54,71.96) 139.37,71.13 139.37,67.65 139.55,67.47 JDIMM3.28
  BOTTOM w0.14: v1(152.24,136.09) U1.BL8
M_B_DQ11: length 88
  TOP w0.102: v1(142.48,70.69) 141.99,70.21 141.65,70.21 141.42,70.44 141.42,71.61 141.04,71.99 141.04,72.84 140.35,73.53 JDIMM4.38
  IN10 w0.076: 151.15,132.95 151.7,133.49 152.4,133.49 153.49,134.59 153.49,135.28 v1(153.91,135.7)
  IN10 w0.13: v1(142.48,70.69) 142.27,70.69 141.64,71.33 141.64,75.52 141.12,76.03 141.12,79.88 140.79,80.21 140.79,93.42 139.75,94.47 139.75,104.79 139.87,104.92 140.1,104.92 140.23,105.05 140.23,105.31 140.1,105.44 139.87,105.44 139.75,105.57 139.75,105.83 139.87,105.96 140.1,105.96 140.23,106.09 140.23,106.35 140.1,106.48 139.87,106.48 139.75,106.61 139.75,106.87 139.87,106.99 140.1,106.99 140.23,107.12 140.23,107.38 140.1,107.51 139.87,107.51 139.75,107.64 139.75,107.9 139.87,108.03 140.1,108.03 140.23,108.16 140.23,108.42 140.1,108.55 139.87,108.55 139.75,108.68 139.75,108.94 139.87,109.07 140.1,109.07 140.23,109.2 140.23,109.46 140.1,109.59 139.87,109.59 139.75,109.71 139.75,109.98 139.87,110.1 140.1,110.1 140.23,110.23 140.23,118.4 147.17,125.34 147.17,126.94 151.15,130.92 151.15,132.95
  BOTTOM w0.102: JDIMM3.38 142.05,67.24 142.15,67.34 142.23,67.34 142.34,67.44 142.34,67.64 142.23,67.75 142.15,67.75 142.05,67.85 142.05,68.08 142.15,68.18 142.67,68.18 142.95,68.46 142.95,70.22 142.48,70.69 v1(142.48,70.69)
  BOTTOM w0.14: U1.BJ8 v1(153.91,135.7)
M_B_DQ12: length 88.8
  TOP w0.102: JDIMM4.37 140.1,67.54 140.98,68.42 140.98,71.56 v1(140.57,71.96)
  IN10 w0.076: 150.69,133.12 151.48,133.91 152.22,133.91 153.07,134.76 153.07,135.78 153.5,136.21 153.5,136.59 v1(153.91,137)
  IN10 w0.13: 150.69,133.12 150.69,131.17 146.7,127.18 146.7,125.89 139.03,118.21 139.03,117.94 139.16,117.82 139.38,117.82 139.51,117.69 139.51,117.43 139.38,117.3 139.16,117.3 139.03,117.17 139.03,116.91 139.16,116.78 139.38,116.78 139.51,116.65 139.51,116.39 139.38,116.26 139.16,116.26 139.03,116.13 139.03,115.87 139.16,115.74 139.38,115.74 139.51,115.61 139.51,115.35 139.38,115.22 139.16,115.22 139.03,115.09 139.03,114.84 139.16,114.71 139.38,114.71 139.51,114.58 139.51,114.32 139.38,114.19 139.16,114.19 139.03,114.06 139.03,113.8 139.16,113.67 139.38,113.67 139.51,113.54 139.51,113.28 139.38,113.15 139.16,113.15 139.03,113.02 139.03,94.21 139.59,93.65 139.59,80.47 139.86,80.2 139.86,76.41 139.86,76.41 139.86,75.69 140.11,75.44 140.11,72.34 140.49,71.96 v1(140.57,71.96)
  BOTTOM w0.102: v1(140.57,71.96) 140.81,71.96 141.07,71.71 141.5,71.71 141.61,71.82 141.61,71.98 141.5,72.09 141.3,72.09 141.19,72.2 141.19,72.36 141.3,72.47 141.64,72.47 141.76,72.6 141.76,72.78 141.64,72.9 140.84,72.9 140.72,73.02 140.72,73.2 140.84,73.32 141.67,73.32 141.8,73.45 JDIMM3.37
  BOTTOM w0.14: v1(153.91,137) U1.BJ11
M_B_DQ13: length 88.1
  TOP w0.102: v1(142.48,69.42) 142.09,69.8 141.68,69.8 141.42,69.55 141.42,69.1 141.52,68.99 141.65,68.99 141.75,68.89 141.75,68.69 141.65,68.59 141.52,68.59 141.42,68.49 141.42,68.28 141.52,68.18 141.61,68.18 141.73,68.06 141.73,67.89 141.61,67.78 141.52,67.78 141.42,67.67 141.42,67.36 141.1,67.04 JDIMM4.41
  IN10 w0.076: 150.9,133 151.6,133.7 152.31,133.7 153.28,134.67 153.28,135.63 153.91,136.26 v1(153.91,136.35)
  IN10 w0.13: 150.9,133 150.9,131.02 146.94,127.06 146.94,125.61 139.87,118.55 139.87,112.79 139.74,112.66 139.52,112.66 139.39,112.53 139.39,112.28 139.52,112.15 139.74,112.15 139.87,112.02 139.87,111.76 139.74,111.63 139.52,111.63 139.39,111.5 139.39,111.24 139.52,111.11 139.74,111.11 139.87,110.98 139.87,110.72 139.74,110.59 139.52,110.59 139.39,110.46 139.39,94.34 139.95,93.78 139.95,80.58 140.79,79.74 140.79,75.86 141.26,75.39 141.26,70.18 142.02,69.42 v1(142.48,69.42)
  BOTTOM w0.102: v1(142.48,69.42) 142.07,69.83 142.07,73.06 142.25,73.24 142.57,73.24 142.8,73.47 JDIMM3.41
  BOTTOM w0.14: U1.BJ10 v1(153.91,136.35)
M_B_DQ14: length 87.4
  TOP w0.102: JDIMM4.29 138.1,67.31 137.89,67.52 137.89,67.92 138.12,68.15 138.75,68.15 139.47,68.86 139.47,69.09 139.8,69.42 v1(140.57,69.42)
  IN10 w0.076: v1(152.29,135.27) 152.18,135.16 151.12,135.16 150.46,134.5 150.46,134.32 150.34,134.19
  IN10 w0.13: 150.34,134.19 149.73,133.58 149.73,131.78 146.81,128.86 146.81,128.63 145.79,127.61 145.79,126.86 137.5,118.57 137.5,118.38 137.7,118.19 137.7,117.86 137.5,117.67 137.5,117.28 137.7,117.08 137.7,116.76 137.5,116.57 137.5,116.24 137.7,116.05 137.7,115.72 137.5,115.53 137.5,115.21 137.7,115.01 137.7,114.69 137.5,114.49 137.5,114.17 137.7,113.98 137.7,113.65 137.5,113.46 137.5,113.13 137.7,112.94 137.7,112.62 137.5,112.42 137.5,112.1 137.7,111.9 137.7,111.58 137.5,111.39 137.5,111.06 137.7,110.87 137.7,110.54 137.5,110.35 137.5,110.02 137.7,109.83 137.7,109.51 137.5,109.31 137.5,108.99 137.7,108.79 137.7,108.47 137.5,108.28 137.5,107.73 137.7,107.54 137.7,95.96 137.21,95.48 137.21,93.86 137.92,93.16 137.92,81.77 138.26,81.42 138.26,78.23 138.88,77.61 138.88,73.45 138.96,73.37 138.96,70.2 139.73,69.42 v1(140.57,69.42)
  BOTTOM w0.102: v1(140.57,69.42) 139.8,70.19 JDIMM3.29
  BOTTOM w0.14: U1.BL7 v1(152.29,135.27)
M_B_DQ15: length 88.4
  TOP w0.102: JDIMM4.42 141.35,74.37 141.35,73.32 141.45,73.22 141.56,73.22 141.68,73.1 141.68,72.93 141.56,72.81 141.45,72.81 141.35,72.71 141.35,72.11 141.73,71.73 141.73,70.68 141.82,70.59 141.94,70.59 142.03,70.68 142.03,71.65 142.34,71.96 v1(142.48,71.96)
  IN10 w0.076: v1(153.91,135.05) 153.91,134.72 152.48,133.29 151.8,133.29 151.39,132.88
  IN10 w0.13: v1(142.48,71.96) 142.27,71.96 142.02,72.22 142.02,75.77 141.49,76.31 141.49,79.99 141.14,80.34 141.14,93.61 140.59,94.16 140.59,95.36 140.46,95.49 140.26,95.49 140.13,95.62 140.13,95.87 140.26,96 140.46,96 140.59,96.13 140.59,96.39 140.46,96.52 140.26,96.52 140.13,96.65 140.13,96.91 140.26,97.04 140.46,97.04 140.59,97.17 140.59,97.43 140.46,97.56 140.26,97.56 140.13,97.69 140.13,97.95 140.26,98.08 140.46,98.08 140.59,98.21 140.59,98.47 140.46,98.59 140.26,98.59 140.13,98.72 140.13,98.98 140.26,99.11 140.46,99.11 140.59,99.24 140.59,99.5 140.46,99.63 140.26,99.63 140.13,99.76 140.13,100.02 140.26,100.15 140.46,100.15 140.59,100.28 140.59,100.54 140.46,100.67 140.26,100.67 140.13,100.8 140.13,101.06 140.26,101.19 140.46,101.19 140.59,101.32 140.59,101.57 140.46,101.7 140.26,101.7 140.13,101.83 140.13,102.09 140.26,102.22 140.46,102.22 140.59,102.35 140.59,102.61 140.46,102.74 140.26,102.74 140.13,102.87 140.13,103.13 140.26,103.26 140.46,103.26 140.59,103.39 140.59,103.65 140.46,103.78 140.26,103.78 140.13,103.91 140.13,104.16 140.26,104.29 140.46,104.29 140.59,104.42 140.59,118.24 147.4,125.05 147.4,126.79 151.39,130.79 151.39,132.88
  BOTTOM w0.102: JDIMM3.42 143.05,68.07 143.25,68.27 143.25,70.35 142.88,70.72 142.88,71.5 142.48,71.9 v1(142.48,71.96)
  BOTTOM w0.14: U1.BJ7 v1(153.91,135.05)
M_B_DQ16: length 88.1
  TOP w0.102: v1(144.38,69.42) 143.15,69.42 143.05,69.32 143.05,68.56 143.15,68.46 143.55,68.46 143.65,68.35 143.65,67.89 143.52,67.76 142.89,67.76 142.1,66.97 JDIMM4.45
  IN10 w0.076: v1(155.74,137.64) 155.21,137.1 155.21,135.64 153.88,134.32 153.77,134.32 153.36,133.91 153.36,131.64 153.35,131.63
  IN10 w0.13: 153.35,131.63 147.95,126.23 147.95,124.84 141.35,118.24 141.35,94.56 141.49,94.42 141.49,81.19 142.69,79.99 142.69,73.05 142.9,72.85 142.9,70.91 v1(144.38,69.42)
  BOTTOM w0.102: JDIMM3.45 143.8,73.58 143.53,73.31 143.28,73.31 142.97,73 142.97,71.96 143.33,71.61 143.33,71 143.97,70.35 143.97,69.83 v1(144.38,69.42)
  BOTTOM w0.14: U1.BG11 v1(155.74,137.64)
M_B_DQ17: length 87.9
  TOP w0.102: v1(144.38,70.06) 143.05,70.06 142.92,70.18 142.92,72.77 142.35,73.34 JDIMM4.46
  IN10 w0.076: 153.08,130.99 153.46,130.99 154.13,131.66 154.13,134.2 155.36,135.43 155.36,136.62 v1(155.74,137)
  IN10 w0.13: 153.08,130.99 148.28,126.19 148.28,124.66 141.71,118.09 141.71,103.34 141.84,103.21 142.07,103.21 142.19,103.09 142.19,102.82 142.06,102.69 141.84,102.69 141.71,102.56 141.71,102.3 141.84,102.17 142.07,102.17 142.19,102.06 142.19,101.78 142.06,101.65 141.84,101.65 141.71,101.53 141.71,94.69 141.85,94.55 141.85,81.3 143.03,80.12 143.03,73.3 143.23,73.1 143.23,71.21 v1(144.38,70.06)
  BOTTOM w0.102: JDIMM3.46 144.05,67.31 144.15,67.42 144.7,67.42 144.82,67.54 144.82,67.69 144.7,67.82 144.24,67.82 144.11,67.95 144.11,68.13 144.24,68.25 144.72,68.25 144.8,68.33 144.8,69.8 144.55,70.06 v1(144.38,70.06)
  BOTTOM w0.14: U1.BG10 v1(155.74,137)
M_B_DQ18: length 87.1
  TOP w0.102: JDIMM4.50 143.35,73.36 143.23,73.23 143.23,70.56 143.35,70.44 143.81,70.44 143.96,70.59 143.96,70.91 v1(144.38,71.33)
  IN10 w0.076: 153.28,130.81 153.59,130.81 154.35,131.58 154.35,134.2 155.74,135.59 v1(155.74,135.7)
  IN10 w0.13: v1(144.38,71.33) 143.56,72.15 143.56,73.41 143.36,73.61 143.36,80.26 142.69,80.93 142.69,93.1 142.55,93.24 142.55,103.42 142.42,103.55 142.19,103.55 142.07,103.67 142.07,103.93 142.19,104.06 142.42,104.06 142.55,104.18 142.55,104.44 142.42,104.57 142.19,104.57 142.07,104.7 142.07,104.96 142.19,105.09 142.42,105.09 142.55,105.22 142.55,105.48 142.42,105.61 142.19,105.61 142.07,105.73 142.07,106 142.19,106.13 142.42,106.13 142.55,106.25 142.55,106.52 142.42,106.64 142.19,106.64 142.07,106.77 142.07,107.03 142.19,107.16 142.42,107.16 142.55,107.29 142.55,107.55 142.42,107.68 142.19,107.68 142.07,107.81 142.07,108.07 142.19,108.2 142.42,108.2 142.55,108.33 142.55,108.59 142.42,108.72 142.19,108.72 142.07,108.84 142.07,109.11 142.19,109.23 142.42,109.23 142.55,109.36 142.55,109.63 142.42,109.75 142.19,109.75 142.07,109.88 142.07,117.94 148.61,124.49 148.61,126.14 153.28,130.81
  BOTTOM w0.102: v1(144.38,71.33) 144.62,71.33 144.8,71.15 144.8,70.29 145.13,69.96 145.13,67.38 145.05,67.3 JDIMM3.50
  BOTTOM w0.14: U1.BG8 v1(155.74,135.7)
M_B_DQ19: length 87.8
  TOP w0.102: v1(146.4,68.91) 145.28,70.03 145.28,74.31 JDIMM4.58
  IN10 w0.076: 155.42,132.85 155.42,133.29 157.02,134.9 157.02,135.33 v1(156.65,135.7)
  IN10 w0.13: 155.42,132.85 155.42,130.08 150.79,125.45 150.79,123.71 145.08,117.99 145.08,111.35 144.98,111.25 144.75,111.25 144.6,111.1 144.6,110.88 144.75,110.73 144.98,110.73 145.08,110.63 145.08,110.32 144.98,110.21 144.75,110.21 144.6,110.06 144.6,109.85 144.75,109.7 144.98,109.7 145.08,109.59 145.08,109.28 144.98,109.18 144.75,109.18 144.6,109.02 144.6,108.81 144.75,108.66 144.98,108.66 145.08,108.56 145.08,108.25 144.98,108.14 144.75,108.14 144.6,107.99 144.6,93.43 144.93,93.1 144.93,81.48 146.63,79.78 146.63,74.18 146.82,73.99 146.82,69.33 v1(146.4,68.91)
  BOTTOM w0.102: v1(146.4,68.91) 146.4,69.01 146.27,69.13 145.7,69.13 145.58,69.01 145.58,68.7 145.74,68.54 146.08,68.54 146.2,68.42 146.2,68.25 146.08,68.13 145.74,68.13 145.64,68.03 145.64,67.41 145.8,67.25 146.89,67.25 147.05,67.09 JDIMM3.58
  BOTTOM w0.14: U1.BF8 v1(156.65,135.7)
M_B_DQ20: length 87.2
  TOP w0.102: v1(148.57,69.8) 148.57,70.29 146.81,72.05 146.81,72.27 146.35,72.72 JDIMM4.62
  IN10 w0.076: 155.86,131.56 155.86,133.25 157.34,134.73 157.34,135.45 157.19,135.59 157.19,135.62 157.19,135.62 157.19,136.84 157.12,136.91 157.12,137.17 v1(156.65,137.64)
  IN10 w0.13: v1(148.57,69.8) 147.49,70.89 147.49,74.5 147.3,74.69 147.3,80.06 145.79,81.57 145.79,103.46 145.8,103.47 145.8,104.53 145.67,104.66 145.5,104.66 145.37,104.79 145.37,105.05 145.5,105.18 145.67,105.18 145.8,105.31 145.8,105.57 145.67,105.7 145.5,105.7 145.37,105.83 145.37,106.09 145.5,106.22 145.67,106.22 145.8,106.35 145.8,106.61 145.67,106.74 145.5,106.74 145.37,106.87 145.37,107.12 145.5,107.25 145.67,107.25 145.8,107.38 145.8,117.7 151.61,123.51 151.61,125.2 151.91,125.5 155.86,129.45 155.86,129.81 155.86,131.56
  BOTTOM w0.102: v1(148.57,69.8) 148.18,69.8 147.89,69.51 147.76,69.51 147.64,69.39 147.64,69.22 147.76,69.11 147.93,69.11 148.05,68.99 148.05,68.82 147.93,68.7 147.81,68.7 147.7,68.58 147.7,68.41 147.81,68.29 147.95,68.29 148.05,68.19 148.05,67.99 147.95,67.89 147.8,67.89 147.7,67.78 147.7,67.58 147.8,67.48 147.95,67.48 148.05,67.38 JDIMM3.62
  BOTTOM w0.14: U1.BF11 v1(156.65,137.64)
M_B_DQ21: length 88.6
  TOP w0.102: JDIMM4.63 146.6,66.97 147.82,68.19 147.82,70.01 147.92,70.11 148.06,70.11 148.16,70.01 148.16,68.94 v1(148.57,68.53)
  IN10 w0.076: 155.65,132.57 155.65,133.28 157.19,134.83 157.19,135.38 157.04,135.53 157.04,135.55 157.03,135.56 157.03,136.62 v1(156.65,137)
  IN10 w0.13: 155.65,132.57 155.65,129.92 155.64,129.8 151.2,125.35 151.2,123.61 145.44,117.85 145.44,107.96 145,107.52 145,93.5 145.38,93.12 145.38,81.5 146.96,79.92 146.96,74.44 147.15,74.25 147.15,69.95 v1(148.57,68.53)
  BOTTOM w0.102: JDIMM3.63 148.3,72.65 148.17,72.51 148.17,70.9 148.98,70.09 148.98,69 148.57,68.59 v1(148.57,68.53)
  BOTTOM w0.14: U1.BF10 v1(156.65,137)
M_B_DQ22: length 89
  TOP w0.102: JDIMM4.49 143.1,67.04 143.45,67.39 143.58,67.39 144.79,68.6 144.79,72.19 v1(144.38,72.6)
  IN10 w0.076: 153.46,130.63 153.74,130.63 154.55,131.45 154.55,133.87 v1(155.74,135.05)
  IN10 w0.13: v1(144.38,72.6) 144.38,73.47 143.69,74.16 143.69,80.4 143.05,81.04 143.05,93.21 142.91,93.35 142.91,110.06 142.81,110.16 142.55,110.16 142.42,110.29 142.42,110.52 142.55,110.65 142.78,110.65 142.91,110.77 142.91,111.06 142.78,111.19 142.55,111.19 142.42,111.32 142.42,111.58 142.55,111.71 142.78,111.71 142.91,111.84 142.91,112.1 142.78,112.23 142.55,112.23 142.42,112.36 142.42,112.62 142.55,112.75 142.78,112.75 142.91,112.87 142.91,113.14 142.78,113.26 142.55,113.26 142.42,113.39 142.42,113.65 142.55,113.78 142.78,113.78 142.91,113.91 142.91,114.17 142.78,114.3 142.55,114.3 142.42,114.43 142.42,114.69 142.55,114.82 142.78,114.82 142.91,114.95 142.91,115.21 142.78,115.34 142.55,115.34 142.42,115.47 142.42,115.73 142.55,115.86 142.78,115.86 142.91,115.98 142.91,116.25 142.78,116.37 142.55,116.37 142.42,116.5 142.42,116.76 142.55,116.89 142.78,116.89 142.91,117.02 142.91,117.28 142.78,117.41 142.55,117.41 142.42,117.54 142.42,117.8 148.94,124.31 148.94,126.11 153.46,130.63
  BOTTOM w0.102: JDIMM3.49 144.8,73.43 144.67,73.31 144.06,73.31 143.76,73 143.4,73 143.3,72.9 143.3,72.75 143.4,72.65 143.61,72.65 143.73,72.54 143.73,72.38 143.61,72.27 143.38,72.27 143.3,72.19 143.3,72.06 143.63,71.73 143.63,71.12 143.73,71.03 143.86,71.03 143.96,71.12 143.96,72.38 144.18,72.6 v1(144.38,72.6)
  BOTTOM w0.14: v1(155.74,135.05) U1.BG7
M_B_DQ23: length 89.3
  TOP w0.102: JDIMM4.59 145.6,67.29 146.12,67.81 147.01,67.81 147.52,68.32 147.52,70.91 146.4,72.03 v1(146.4,72.09)
  IN10 w0.076: v1(156.65,135.05) 156.65,134.87 155.19,133.4 155.19,132.97
  IN10 w0.13: v1(146.4,72.09) 146.4,73.61 146.27,73.74 146.27,74.39 146.02,74.64 146.02,74.9 146.27,75.16 146.27,75.41 145.79,75.9 145.79,80.15 144.6,81.35 144.6,92.96 144.24,93.32 144.24,111.44 144.37,111.57 144.59,111.57 144.72,111.7 144.72,111.96 144.59,112.09 144.37,112.09 144.24,112.21 144.24,112.48 144.37,112.61 144.6,112.61 144.72,112.73 144.72,113 144.6,113.12 144.37,113.12 144.24,113.25 144.24,113.51 144.37,113.64 144.6,113.64 144.72,113.77 144.72,114.03 144.6,114.16 144.37,114.16 144.24,114.29 144.24,114.55 144.37,114.68 144.6,114.68 144.72,114.81 144.72,115.07 144.6,115.2 144.37,115.2 144.24,115.32 144.24,115.59 144.37,115.71 144.6,115.71 144.72,115.84 144.72,116.11 144.6,116.23 144.37,116.23 144.24,116.36 144.24,116.62 144.37,116.75 144.59,116.75 144.72,116.88 144.72,117.14 144.59,117.27 144.37,117.27 144.24,117.4 144.24,117.66 144.37,117.79 144.59,117.79 144.72,117.92 144.72,118.21 150.36,123.85 150.36,125.51 155.19,130.33 155.19,132.97
  BOTTOM w0.14: U1.BF7 v1(156.65,135.05) ; v1(146.4,72.09) 146.58,72.09 146.96,71.71 146.96,70.13 147.09,70.01 147.67,70.01 147.8,70.13 147.8,73 147.3,73.5 JDIMM3.59
M_B_DQ24: length 91.8
  TOP w0.102: v1(152.38,72.34) 152.91,71.81 152.91,68.03 152.4,67.52 151.75,67.52 151.6,67.37 JDIMM4.83
  IN10 w0.076: 159.74,128.98 159.85,129.09 159.85,133.91 160.08,134.14 160.08,135.45 159.93,135.6 159.93,137.12 v1(159.4,137.65)
  IN10 w0.13: v1(152.38,72.34) 152.06,72.34 151.73,72.67 151.73,93.73 151.02,94.44 150.63,94.44 150.5,94.57 150.5,94.96 150.63,95.09 151.24,95.09 151.37,95.22 151.37,95.48 151.24,95.61 150.65,95.61 150.53,95.73 150.53,96 150.65,96.12 151.24,96.12 151.37,96.25 151.37,96.51 151.24,96.64 150.65,96.64 150.53,96.77 150.53,97.03 150.65,97.16 151.24,97.16 151.37,97.29 151.37,97.55 151.24,97.68 150.65,97.68 150.53,97.81 150.53,98.07 150.65,98.2 151.24,98.2 151.37,98.33 151.37,98.59 151.24,98.72 150.65,98.72 150.53,98.84 150.53,99.11 150.65,99.23 151.24,99.23 151.37,99.36 151.37,117.66 156.46,122.75 156.46,123.4 159.74,126.69 159.74,128.98
  BOTTOM w0.102: JDIMM3.83 153.3,73.32 153.4,73.22 154.51,73.22 154.63,73.1 154.63,72.93 154.51,72.81 154.24,72.81 154.14,72.71 154.14,72.1 154.02,71.98 153.85,71.98 153.73,72.1 153.73,72.79 153.6,72.91 153.43,72.91 153.3,72.79 153.3,72.15 153.17,72.03 152.77,72.03 152.45,72.34 v1(152.38,72.34)
  BOTTOM w0.14: U1.BB11 v1(159.4,137.65)
M_B_DQ25: length 91.1
  TOP w0.102: JDIMM4.79 150.6,67.55 150.74,67.69 150.91,67.69 151.08,67.52 151.25,67.52 151.37,67.64 151.37,67.8 151.27,67.9 151.27,68.05 151.37,68.15 151.53,68.15 151.78,68.4 151.78,68.6 151.68,68.7 151.35,68.7 151.23,68.83 151.23,69.17 151.35,69.29 151.62,69.29 v1(152.38,68.53)
  IN10 w0.076: 157.17,133.15 157.17,133.29 157.46,133.59 157.46,134.49 157.57,134.6 157.57,135.2 157.95,135.58 157.95,137.1 v1(158.48,137.64)
  IN10 w0.13: v1(152.38,68.53) 151.07,68.53 150.65,68.11 150.3,68.11 148.99,69.42 148.99,69.98 147.82,71.15 147.82,74.76 147.63,74.95 147.63,81.11 147.23,81.5 147.23,93.37 146.56,94.03 146.56,117.85 152.37,123.65 152.37,124.69 156.74,129.06 156.74,132.59 157.17,133.02 157.17,133.15
  BOTTOM w0.102: v1(152.38,68.53) 152.37,68.53 151.98,68.93 151.98,73.25 152.3,73.58 JDIMM3.79
  BOTTOM w0.14: U1.BC11 v1(158.48,137.64)
M_B_DQ26: length 89.8
  TOP w0.102: v1(152.38,69.8) 152.37,69.8 151.4,70.77 151.4,72.98 150.85,73.53 JDIMM4.80
  IN10 w0.076: 159.23,129.16 159.43,129.37 159.43,134.21 159.77,134.54 159.77,135.23 159.4,135.6 v1(159.4,135.7)
  IN10 w0.13: v1(152.38,69.8) 151.04,71.14 151.04,93.03 150.92,93.16 150.48,93.16 150.35,93.28 150.35,93.78 149.81,94.32 149.81,105.15 149.94,105.27 150.53,105.27 150.65,105.4 150.65,105.67 150.53,105.79 149.94,105.79 149.81,105.92 149.81,106.18 149.94,106.31 150.53,106.31 150.65,106.44 150.65,106.7 150.53,106.83 149.94,106.83 149.81,106.96 149.81,107.22 149.94,107.35 150.53,107.35 150.65,107.47 150.65,107.74 150.53,107.86 149.94,107.86 149.81,107.99 149.81,108.26 149.94,108.38 150.53,108.38 150.65,108.51 150.65,108.77 150.53,108.9 149.94,108.9 149.81,109.03 149.81,109.32 149.94,109.45 150.53,109.45 150.65,109.57 150.65,109.83 150.53,109.96 149.94,109.96 149.81,110.09 149.81,110.35 149.94,110.48 150.52,110.48 150.65,110.61 150.65,118 155.65,122.99 155.65,123.47 159.23,127.05 159.23,129.16
  BOTTOM w0.102: v1(152.38,69.8) 152.52,69.8 152.95,69.37 152.95,68.2 152.5,67.75 152,67.75 151.88,67.63 151.88,67.46 152,67.34 152.45,67.34 152.55,67.24 JDIMM3.80
  BOTTOM w0.14: U1.BB8 v1(159.4,135.7)
M_B_DQ27: length 90.7
  TOP w0.102: v1(150.48,68.53) 149.92,67.97 149.6,67.97 149.5,68.08 149.5,68.9 149.38,69.02 149.21,69.02 149.09,68.9 149.09,68.08 148.99,67.97 148.81,67.97 148.66,67.82 148.66,67.47 148.42,67.23 147.87,67.23 147.6,66.95 JDIMM4.67
  IN10 w0.076: v1(158.48,135.7) 158.48,135.59 158.33,135.43 158.32,135.43 158.1,135.21 158.1,135.21 158.06,135.16 158.06,134.44 157.77,134.15 157.77,133.46 157.58,133.27 157.58,132.9
  IN10 w0.13: 157.58,132.9 157.58,132.48 157.27,132.17 157.27,127.98 153.46,124.17 153.46,123.73 147.28,117.55 147.28,116.79 147.41,116.66 147.63,116.66 147.76,116.53 147.76,116.31 147.63,116.18 147.41,116.18 147.28,116.06 147.28,115.83 147.41,115.7 147.63,115.7 147.76,115.57 147.76,105.32 147.63,105.19 147.41,105.19 147.28,105.07 147.28,104.8 147.41,104.67 147.63,104.67 147.76,104.55 147.76,104.28 147.63,104.15 147.41,104.15 147.28,104.03 147.28,103.76 147.41,103.64 147.63,103.64 147.76,103.51 147.76,103.25 147.63,103.12 147.41,103.12 147.28,102.99 147.28,102.73 147.41,102.6 147.63,102.6 147.76,102.47 147.76,102.21 147.63,102.08 147.41,102.08 147.28,101.96 147.28,101.69 147.41,101.56 147.63,101.56 147.76,101.44 147.76,101.18 147.63,101.05 147.41,101.05 147.28,100.92 147.28,94.26 147.95,93.59 147.95,81.96 148.29,81.61 148.29,78.51 148.8,78.01 148.8,75.99 148.48,75.67 148.48,73.59 148.99,73.08 148.99,70.45 149.38,70.06 149.38,69.5 150.35,68.53 v1(150.48,68.53)
  BOTTOM w0.102: v1(150.48,68.53) 150.48,68.59 150.07,69 150.07,71.96 149.3,72.73 JDIMM3.67
  BOTTOM w0.14: U1.BC8 v1(158.48,135.7)
M_B_DQ28: length 91
  TOP w0.102: v1(148.57,71.71) 148.42,71.56 148.31,71.56 148.08,71.78 148.08,72.05 148.17,72.14 148.17,72.34 148.04,72.47 147.18,72.47 147.09,72.57 147.09,72.7 147.18,72.8 148.05,72.8 148.13,72.88 148.13,73 148.05,73.08 147.17,73.08 147.09,73.16 147.09,73.27 147.17,73.35 147.25,73.35 147.35,73.45 JDIMM4.66
  IN10 w0.076: v1(158.48,137) 158.1,136.62 158.1,135.51 157.83,135.24 157.83,134.52 157.62,134.3 157.62,133.53 157.38,133.28 157.38,133.05
  IN10 w0.13: 157.38,133.05 157.38,132.75 156.97,132.34 156.97,128.83 152.78,124.64 152.78,123.55 146.92,117.7 146.92,115.49 147.05,115.37 147.28,115.37 147.4,115.24 147.4,114.98 147.28,114.85 147.05,114.85 146.92,114.72 146.92,114.46 147.05,114.33 147.28,114.33 147.4,114.2 147.4,113.94 147.28,113.81 147.05,113.81 146.92,113.69 146.92,113.42 147.05,113.29 147.28,113.29 147.4,113.17 147.4,112.9 147.28,112.78 147.05,112.78 146.92,112.65 146.92,112.38 147.05,112.26 147.28,112.26 147.4,112.13 147.4,111.87 147.28,111.74 147.05,111.74 146.92,111.61 146.92,111.35 147.05,111.22 147.28,111.22 147.4,111.09 147.4,110.83 147.28,110.7 147.05,110.7 146.92,110.58 146.92,110.31 147.05,110.18 147.28,110.18 147.4,110.06 147.4,109.79 147.28,109.67 147.05,109.67 146.92,109.54 146.92,109.28 147.05,109.15 147.28,109.15 147.4,109.02 147.4,108.76 147.28,108.63 147.05,108.63 146.92,108.5 146.92,108.24 147.05,108.11 147.28,108.11 147.4,107.99 147.4,107.72 147.28,107.59 147.05,107.59 146.92,107.47 146.92,107.2 147.05,107.08 147.28,107.08 147.4,106.95 147.4,106.68 147.28,106.56 147.05,106.56 146.92,106.43 146.92,106.17 147.05,106.04 147.28,106.04 147.4,105.92 147.4,105.65 147.28,105.53 147.05,105.53 146.92,105.4 146.92,94.15 147.59,93.48 147.59,81.73 147.96,81.36 147.96,75.2 148.15,75.01 148.15,73.45 148.48,73.12 148.48,72.85 148.15,72.52 148.15,71.83 148.28,71.71 v1(148.57,71.71)
  BOTTOM w0.102: v1(148.57,71.71) 149.71,70.56 149.71,68.5 149.4,68.18 149.4,67.32 149.05,66.97 JDIMM3.66
  BOTTOM w0.14: U1.BC10 v1(158.48,137)
M_B_DQ29: length 89.9
  TOP w0.102: v1(152.38,71.07) 152.25,70.95 151.96,70.95 151.71,71.2 151.71,72.5 151.96,72.75 152.52,72.75 152.64,72.86 152.64,73.19 152.55,73.28 151.99,73.28 151.85,73.42 JDIMM4.84
  IN10 w0.076: 159.49,128.87 159.49,129.11 159.63,129.25 159.63,134.08 159.92,134.37 159.92,135.4 159.78,135.54 159.78,136.62 v1(159.4,137)
  IN10 w0.13: 159.49,128.87 159.49,126.84 156.05,123.4 156.05,122.86 151.01,117.82 151.01,105.01 150.88,104.88 150.3,104.88 150.17,104.75 150.17,104.49 150.3,104.36 150.89,104.36 151.01,104.23 151.01,103.98 150.89,103.85 150.3,103.85 150.17,103.72 150.17,103.46 150.3,103.33 150.89,103.33 151.01,103.2 151.01,102.94 150.89,102.81 150.3,102.81 150.17,102.69 150.17,102.42 150.3,102.29 150.89,102.29 151.01,102.17 151.01,101.9 150.89,101.78 150.3,101.78 150.17,101.65 150.17,101.39 150.3,101.26 150.89,101.26 151.01,101.13 151.01,100.87 150.89,100.74 150.3,100.74 150.17,100.61 150.17,100.35 150.3,100.22 150.89,100.22 151.01,100.09 151.01,99.83 150.89,99.7 150.3,99.7 150.17,99.58 150.17,94.43 150.49,94.11 150.82,94.11 151.38,93.55 151.38,72.1 152.38,71.1 v1(152.38,71.07)
  BOTTOM w0.102: JDIMM3.84 153.55,67.27 153.36,67.46 153.36,70.09 v1(152.38,71.07)
  BOTTOM w0.14: U1.BB10 v1(159.4,137)
M_B_DQ30: length 90.6
  TOP w0.102: JDIMM4.70 148.35,73.21 148.99,72.57 148.99,70.44 150.26,69.17 v1(150.48,69.17)
  IN10 w0.076: v1(158.48,135.05) 158.48,134.55 157.92,133.99 157.92,133.4 157.79,133.26 157.79,132.88
  IN10 w0.13: v1(150.48,69.17) 150.19,69.17 149.77,69.59 149.77,70.15 149.32,70.59 149.32,73.47 148.82,73.98 148.82,75.4 149.13,75.72 149.13,78.52 148.63,79.02 148.63,80.07 148.79,80.24 148.79,85.72 148.28,86.23 148.28,87.56 148.79,88.07 148.79,90.2 148.66,90.33 148.56,90.33 148.43,90.46 148.43,90.72 148.56,90.85 148.66,90.85 148.79,90.98 148.79,91.24 148.66,91.37 148.56,91.37 148.43,91.5 148.43,91.76 148.56,91.89 148.66,91.89 148.79,92.02 148.79,93.22 148.12,93.89 148.12,94.87 147.99,95 147.76,95 147.64,95.13 147.64,95.39 147.76,95.52 147.99,95.52 148.12,95.65 148.12,95.91 147.99,96.04 147.77,96.04 147.64,96.17 147.64,96.43 147.77,96.56 147.99,96.56 148.12,96.69 148.12,96.94 147.99,97.07 147.76,97.07 147.64,97.2 147.64,97.46 147.76,97.59 147.99,97.59 148.12,97.72 148.12,97.98 147.99,98.11 147.76,98.11 147.64,98.23 147.64,98.5 147.76,98.63 147.99,98.63 148.12,98.75 148.12,99.02 147.99,99.14 147.76,99.14 147.64,99.27 147.64,99.53 147.76,99.66 147.99,99.66 148.12,99.79 148.12,100.05 147.99,100.18 147.76,100.18 147.64,100.31 147.64,100.57 147.76,100.7 147.99,100.7 148.12,100.83 148.12,116.87 147.99,117 147.76,117 147.64,117.12 147.64,117.4 147.76,117.53 147.99,117.53 148.12,117.66 148.12,117.88 153.83,123.59 153.84,123.61 153.84,124.13 157.64,127.93 157.64,132.08 157.79,132.23 157.79,132.88
  BOTTOM w0.102: JDIMM3.70 150.05,67.1 150.18,67.23 150.47,67.23 150.56,67.32 150.56,67.45 150.47,67.54 149.79,67.54 149.7,67.63 149.7,68.05 149.82,68.18 149.94,68.18 150.03,68.08 150.03,67.9 150.14,67.8 150.28,67.8 150.39,67.9 150.39,68 150.51,68.13 150.77,68.13 150.9,68.26 150.9,69.17 150.77,69.29 150.6,69.29 v1(150.48,69.17)
  BOTTOM w0.14: U1.BC7 v1(158.48,135.05)
M_B_DQ31: length 92.7
  TOP w0.102: v1(150.48,72.34) 150.51,72.34 150.92,71.93 150.92,68.31 149.95,67.33 148.96,67.33 148.6,66.97 JDIMM4.71
  IN10 w0.076: 158.97,129.37 159.22,129.61 159.22,134.34 159.4,134.52 v1(159.4,135.05)
  IN10 w0.13: 158.97,129.37 158.97,127.26 155.24,123.52 155.24,123.12 150.3,118.17 150.3,116.15 150.17,116.02 149.58,116.02 149.45,115.89 149.45,115.63 149.58,115.5 150.17,115.5 150.3,115.37 150.3,115.11 150.17,114.98 149.58,114.98 149.45,114.85 149.45,114.59 149.58,114.46 150.17,114.46 150.3,114.34 150.3,114.07 150.17,113.95 149.58,113.95 149.45,113.82 149.45,113.55 149.58,113.43 150.17,113.43 150.3,113.3 150.3,113.04 150.17,112.91 149.58,112.91 149.45,112.78 149.45,112.52 149.58,112.39 150.17,112.39 150.3,112.26 150.3,112 150.17,111.87 149.58,111.87 149.45,111.75 149.45,111.48 149.58,111.35 150.17,111.35 150.3,111.23 150.3,110.96 150.17,110.84 149.58,110.84 149.45,110.71 149.45,94.2 149.85,93.8 149.85,92.5 149.98,92.37 150.58,92.37 150.71,92.24 150.71,86.95 150.58,86.83 150.08,86.83 149.96,86.7 149.96,86.43 150.08,86.31 150.58,86.31 150.71,86.18 150.71,72.58 v1(150.48,72.34)
  BOTTOM w0.102: JDIMM3.71 150.3,73.42 150.17,73.29 149.87,73.29 149.74,73.16 149.74,72.72 149.87,72.59 150.08,72.59 150.27,72.77 150.8,72.77 151.01,72.99 151.01,73.11 151.14,73.24 151.33,73.24 151.51,73.06 151.51,71.5 151.38,71.38 151.14,71.38 151.01,71.5 151.01,72.28 150.81,72.48 150.61,72.48 v1(150.48,72.34)
  BOTTOM w0.14: U1.BB7 v1(159.4,135.05)
M_B_DQ32: length 87.1
  TOP w0.102: v1(181.39,69.04) 181.29,69.14 181.07,69.14 180.92,68.99 180.92,68.25 180.31,67.64 179.45,67.64 179.32,67.52 179.32,67.37 179.22,67.28 179.08,67.28 178.99,67.37 178.99,67.54 178.89,67.64 178.72,67.64 178.6,67.52 JDIMM4.183
  IN10 w0.076: 180.88,125.23 180.88,125.34 177.16,129.06 177.16,133.99 176.68,134.47 176.68,135.34 176.39,135.62 176.39,137.12 v1(175.86,137.65)
  IN10 w0.13: 180.88,125.23 180.88,124.48 181.69,123.67 181.69,120.22 184.79,117.12 184.79,101.44 184.66,101.31 184.36,101.31 184.23,101.18 184.23,100.92 184.36,100.79 184.66,100.79 184.79,100.66 184.79,93.54 185.36,92.96 185.36,88.74 184.5,87.87 184.5,80.6 182.21,78.31 182.21,75.9 181.87,75.55 181.87,69.52 v1(181.39,69.04)
  BOTTOM w0.102: v1(181.39,69.04) 180.62,69.81 180.62,72.48 180.3,72.8 JDIMM3.183
  BOTTOM w0.14: U1.AA11 v1(175.86,137.65)
M_B_DQ33: length 86.7
  TOP w0.102: JDIMM4.186 179.35,73.45 180.77,72.04 180.77,71.91 180.69,71.83 180.42,71.83 180.32,71.73 180.32,71.04 180.42,70.94 180.64,70.94 180.74,71.04 180.74,71.3 180.82,71.38 181.33,71.38 181.39,71.44 v1(181.39,71.58)
  IN10 w0.076: v1(175.86,137) 176.24,136.62 176.24,135.56 176.5,135.3 176.5,134.35 176.96,133.9 176.96,128.97 180.49,125.44 180.49,125.1
  IN10 w0.13: v1(181.39,71.58) 181.39,75.68 181.83,76.13 181.83,78.44 184.12,80.72 184.12,87.96 184.46,88.3 184.46,95.18 184.33,95.3 183.99,95.3 183.87,95.43 183.87,101.68 183.99,101.81 184,101.81 184.3,101.81 184.43,101.94 184.43,102.2 184.3,102.33 184,102.33 183.87,102.46 183.87,102.72 184,102.85 184.3,102.85 184.43,102.98 184.43,103.24 184.3,103.37 184,103.37 183.87,103.5 183.87,103.76 184,103.89 184.3,103.89 184.43,104.02 184.43,104.27 184.3,104.4 184,104.4 183.87,104.53 183.87,104.79 184,104.92 184.3,104.92 184.43,105.05 184.43,105.31 184.3,105.44 184,105.44 183.87,105.57 183.87,105.83 184,105.96 184.3,105.96 184.43,106.09 184.43,116.97 181.15,120.25 181.15,123.65 180.49,124.31 180.49,125.1
  BOTTOM w0.102: JDIMM3.186 181.05,68.13 181.79,68.87 181.79,71.17 v1(181.39,71.58)
  BOTTOM w0.14: U1.AA10 v1(175.86,137)
M_B_DQ34: length 89.2
  TOP w0.102: v1(178.09,69.04) 178.63,69.59 178.63,71.69 178.19,72.13 176.76,72.13 175.35,73.54 JDIMM4.170
  IN10 w0.076: 175.74,126.44 175.61,126.58 175.61,126.95 174.72,127.83 174.72,134.3 174.26,134.77 174.26,135.45 174.41,135.6 174.41,136.77 174.49,136.86 174.49,137.2 v1(174.94,137.65)
  IN10 w0.13: v1(178.09,69.04) 177,70.13 177,78.43 179.32,80.75 179.32,89.79 180.16,90.63 180.16,92.97 180.03,93.1 180.03,112 179.35,112.67 179.35,117.24 178.03,118.57 178.03,122.28 176.52,123.78 176.52,125.66 175.74,126.44
  BOTTOM w0.076: U1.AC11 v1(174.94,137.65)
  BOTTOM w0.102: JDIMM3.170 177.05,67.26 176.92,67.39 175.76,67.39 175.64,67.52 175.64,69.65 175.76,69.78 177.69,69.78 178.09,69.38 v1(178.09,69.04)
M_B_DQ35: length 87.6
  TOP w0.102: JDIMM4.173 176.1,67.5 176.3,67.69 176.3,68.81 176.46,68.97 176.6,68.97 176.79,68.78 176.96,68.78 177.08,68.9 177.08,69.07 176.89,69.26 176.89,69.41 177.03,69.55 177.18,69.55 177.3,69.43 177.46,69.43 177.58,69.55 177.58,69.72 177.46,69.84 177.46,69.98 177.79,70.31 v1(178.09,70.31)
  IN10 w0.076: 175.95,126.53 175.8,126.67 175.8,127.01 174.92,127.88 174.92,134.31 174.41,134.83 174.41,135.38 174.56,135.54 174.56,136.62 v1(174.94,137)
  IN10 w0.13: v1(178.09,70.31) 177.33,71.06 177.33,78.13 180.18,80.98 180.18,90.12 180.52,90.46 180.52,93.42 180.38,93.55 180.38,102.28 180.51,102.4 180.97,102.4 181.09,102.53 181.09,102.79 180.97,102.92 180.51,102.92 180.38,103.05 180.38,103.31 180.51,103.44 180.96,103.44 181.09,103.57 181.09,103.83 180.96,103.96 180.51,103.96 180.38,104.08 180.38,104.35 180.51,104.48 180.96,104.48 181.09,104.6 181.09,104.86 180.96,104.99 180.51,104.99 180.38,105.12 180.38,112.14 179.71,112.82 179.71,117.39 178.38,118.72 178.38,122.43 176.83,123.98 176.83,125.64 175.95,126.53
  BOTTOM w0.102: v1(178.09,70.31) 178.38,70.31 178.51,70.44 178.51,71.74 178.25,71.99 177.31,71.99 176.93,72.37 176.93,73.08 177.16,73.31 177.53,73.31 177.8,73.58 JDIMM3.173
  BOTTOM w0.14: U1.AC10 v1(174.94,137)
M_B_DQ36: length 86.9
  TOP w0.14: JDIMM4.182 178.35,73.41 178.22,73.28 177.54,73.28 177.41,73.16 177.41,73 177.54,72.88 178.58,72.88 178.93,73.23 179.11,73.23 179.33,73.02 179.33,72.73 179.2,72.61 179.17,72.61 179.04,72.48 179.04,72.27 179.34,71.96 v1(179.74,71.96)
  IN10 w0.076: v1(175.86,135.05) 175.98,134.93 175.98,128.46 179.62,124.82
  IN10 w0.13: v1(179.74,71.96) 180.12,71.96 180.56,72.41 180.56,78.18 182.85,80.47 182.85,87.89 183.71,88.75 183.71,93.08 183.59,93.21 183.27,93.21 183.14,93.34 183.14,111 183.27,111.13 183.59,111.13 183.71,111.25 183.71,111.52 183.59,111.64 183.19,111.64 183.06,111.77 183.06,112.34 182.93,112.46 182.67,112.46 182.54,112.59 182.54,112.85 182.67,112.98 183.09,112.98 183.21,113.11 183.21,113.37 183.09,113.5 182.67,113.5 182.54,113.63 182.54,113.89 182.67,114.02 183.09,114.02 183.21,114.14 183.21,114.41 183.09,114.54 182.67,114.54 182.55,114.66 182.55,114.93 182.67,115.05 183.09,115.05 183.21,115.18 183.21,115.45 183.09,115.57 182.63,115.57 182.5,115.7 182.5,115.96 182.63,116.09 183.09,116.09 183.21,116.22 183.21,116.48 183.09,116.61 182.6,116.61 182.47,116.74 182.47,117 182.6,117.13 182.79,117.13 182.91,117.26 182.91,117.47 180.43,119.96 180.43,123.28 179.62,124.09 179.62,124.82
  BOTTOM w0.102: JDIMM3.182 180.05,68.08 180.25,68.28 180.25,71.45 v1(179.74,71.96)
  BOTTOM w0.14: U1.AA7 v1(175.86,135.05)
M_B_DQ37: length 86.9
  TOP w0.102: v1(181.39,70.31) 181.9,69.8 181.9,68.8 180.36,67.26 179.74,67.26 179.6,67.13 JDIMM4.187
  IN10 w0.076: v1(175.86,135.7) 176.35,135.21 176.35,134.29 176.75,133.88 176.75,128.86 180.09,125.52 180.09,125.15
  IN10 w0.13: 180.09,125.15 180.09,124.12 180.79,123.42 180.79,120.1 183.57,117.32 183.57,114.28 183.7,114.15 183.71,114.15 183.84,114.02 183.84,113.76 183.71,113.63 183.7,113.63 183.57,113.5 183.57,113.24 183.7,113.11 183.71,113.11 183.84,112.98 183.84,112.72 183.71,112.59 183.7,112.59 183.57,112.46 183.57,112.17 184.07,111.67 184.07,110.77 183.94,110.64 183.63,110.64 183.5,110.51 183.5,110.25 183.63,110.12 183.95,110.12 184.07,109.99 184.07,109.73 183.95,109.6 183.63,109.6 183.5,109.48 183.5,109.21 183.63,109.08 183.95,109.08 184.07,108.96 184.07,108.69 183.95,108.57 183.63,108.57 183.5,108.44 183.5,108.18 183.63,108.05 183.95,108.05 184.07,107.92 184.07,107.66 183.95,107.53 183.63,107.53 183.5,107.4 183.5,107.14 183.63,107.01 183.95,107.01 184.07,106.88 184.07,106.62 183.95,106.49 183.64,106.49 183.51,106.36 183.51,94.31 183.64,94.19 183.97,94.19 184.1,94.06 184.1,88.53 183.74,88.17 183.74,80.85 180.94,78.06 180.94,70.76 v1(181.39,70.31)
  BOTTOM w0.102: JDIMM3.187 181.3,73.33 181.17,73.21 180.97,73.21 180.84,73.08 180.84,72.69 180.96,72.57 180.96,72.53 181.07,72.42 181.53,72.42 181.64,72.31 181.64,72.15 181.53,72.04 181.12,72.04 180.96,71.89 180.96,70.74 v1(181.39,70.31)
  BOTTOM w0.14: U1.AA8 v1(175.86,135.7)
M_B_DQ38: length 87.4
  TOP w0.102: JDIMM4.169 175.1,66.97 175.99,67.86 175.99,69.49 v1(178.09,71.58)
  IN10 w0.076: v1(174.94,135.7) 174.56,135.32 174.56,134.89 175.13,134.33 175.13,127.93 175.91,127.15 175.91,127.15 175.99,127.07 175.99,126.78 176.12,126.65
  IN10 w0.13: 176.12,126.65 177.16,125.6 177.16,124.16 178.74,122.57 178.74,118.87 180.07,117.54 180.07,112.97 180.74,112.29 180.74,109.75 180.87,109.63 181.32,109.63 181.45,109.5 181.45,109.24 181.32,109.11 180.87,109.11 180.74,108.98 180.74,108.72 180.87,108.59 181.32,108.59 181.45,108.46 181.45,108.2 181.32,108.07 180.87,108.07 180.74,107.94 180.74,107.68 180.87,107.55 181.32,107.55 181.45,107.42 181.45,107.16 181.32,107.04 180.87,107.04 180.74,106.91 180.74,106.64 180.87,106.52 181.32,106.52 181.45,106.39 181.45,106.13 181.32,106 180.87,106 180.74,105.87 180.74,105.61 180.87,105.48 181.32,105.48 181.45,105.35 181.45,93.58 180.97,93.09 180.97,90.44 180.56,90.03 180.56,80.85 177.67,77.95 177.67,72 v1(178.09,71.58)
  BOTTOM w0.102: v1(178.09,71.58) 177.59,71.58 177.25,71.24 177.25,70.72 177.12,70.59 176.43,70.59 176.04,70.98 176.04,72.74 176.8,73.5 JDIMM3.169
  BOTTOM w0.14: U1.AC8 v1(174.94,135.7)
M_B_DQ39: length 88.5
  TOP w0.102: JDIMM4.174 176.35,73.38 177.18,72.55 178.23,72.55 178.94,71.83 178.94,69.45 179.6,68.79 v1(179.74,68.79)
  IN10 w0.076: 176.36,126.7 176.14,126.92 176.14,127.18 175.33,127.98 175.33,134.42 174.94,134.81 v1(174.94,135.05)
  IN10 w0.13: v1(179.74,68.79) 179.23,68.79 178.59,69.42 178.59,78.25 180.94,80.6 180.94,89.87 181.81,90.73 181.81,109.86 181.68,109.98 181.23,109.98 181.1,110.11 181.1,110.38 181.23,110.5 181.68,110.5 181.81,110.63 181.81,110.85 181.68,110.97 181.23,110.97 181.1,111.1 181.1,112.44 180.43,113.12 180.43,117.69 179.1,119.02 179.1,122.72 177.49,124.33 177.49,125.57 176.36,126.7
  BOTTOM w0.102: v1(179.74,68.79) 179.74,68.46 179.57,68.3 178.05,68.3 177.87,68.48 176.32,68.48 176.14,68.3 176.14,67.92 176.27,67.8 176.98,67.8 177.54,67.24 177.92,67.24 178.05,67.11 JDIMM3.174
  BOTTOM w0.14: U1.AC7 v1(174.94,135.05)
