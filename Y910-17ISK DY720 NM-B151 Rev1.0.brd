# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N16977185: length 2.4
  TOP w0.203: C321.1 291.18,28.27 289.93,29.52 U7.26
N16977188: length 3.7
  TOP w0.203: C321.2 290.88,27.31 290.55,27.64 290.55,28.27 v2(289.98,28.84) 289.98,28.99 289.53,29.44 U7.25
N16977287: length 3.5
  TOP w0.203: C315.1 293.03,30.03 293.03,30.1 292.65,30.48 292.65,31.29 292.13,31.81 291.61,31.81 U7.31
N16977319: length 3.7
  TOP w0.203: U7.29 291.61,31.01 291.75,31.01 291.94,30.81 291.94,29.67 292.2,29.42 292.55,29.42 v2(292.7,29.26)
  TOP w0.254: v2(292.7,29.26) 293.26,28.71 C317.1
N16977470: length 3.9
  TOP w0.203: v1(293.25,36.99) 292.07,35.81 U7.41
  BOTTOM w0.254: C313.1 293.09,38.43 293.34,38.18 293.34,37.07 v1(293.25,36.99)
N16978248: length 3.4
  TOP w0.203: 291.48,37.6 290.98,37.6 290.73,37.35 U7.43
  TOP w0.356: 291.48,37.6 291.66,37.6 292.19,38.13 C307.1 C306.2
N16979537: length 2.1
  TOP w0.203: 291,38 290.77,38 290.33,37.56 U7.44
  TOP w0.356: C309.1 291.33,38.33 291,38
N16980185: length 3.6
  TOP w0.097: C330.2 C331.1 R314.1 R313.1 v2(285.54,24.69)
N17007017: length 4.7
  TOP w0.097: R296.2 282.57,38.1 v2(283.28,38.1) 283.61,38.1 283.94,37.77 285.67,37.77 285.93,37.51 U7.55
N17007044: length 3.8
  TOP w0.097: R298.2 282.24,37.54 285.34,37.54 285.53,37.35 U7.56
N17007081: length 2.8
  TOP w0.097: U7.1 284.26,36.21 283.69,36.78 v2(283.56,36.78) R301.2
N17007119: length 2.7
  TOP w0.097: R302.2 283.44,35.89 283.92,35.41 U7.3
N17009629: length 2.5
  TOP w0.102: U8.28 275.02,27.45 v1(275.03,27.46)
  BOTTOM w0.097: C358.2 274.37,26.8 v1(275.03,27.46)
N17009645: length 4.9
  TOP w0.097: C360.2 279.75,30.23 278.94,30.23 v2(278.86,30.15) 278.78,30.23 278.02,30.23 277.25,29.45 U8.32
N17009647: length 5.3
  TOP w0.097: v2(281.43,30.38) C360.1 280.33,30.56 277.59,30.56 277.48,30.45 U8.34
N17009661: length 2.1
  TOP w0.203: U8.35 278.16,30.95 C361.2
N17009677: length 2.2
  TOP w0.097: U8.36 277.77,31.45 C362.1
N17009679: length 3.3
  TOP w0.097: U8.37 277.21,31.95 277.7,32.45 278.7,32.45 C362.2
N17009693: length 4.5
  TOP w0.097: C363.1 280.05,32.16 v2(279.34,32.87) 279.14,32.67 277.54,32.67 277.33,32.45 U8.38
N17009767: length 2.3
  TOP w0.102: C364.1 266.92,31.7 267.67,32.45 U8.11
N17009783: length 3.5
  TOP w0.097: U8.12 267.68,31.95 266.67,30.94 266.08,30.94 C365.1
N17009785: length 2.4
  TOP w0.097: C365.2 266.54,30.43 267.56,31.45 U8.13
N17010419: length 4
  TOP w0.097: U8.21 267.63,27.45 267.3,27.13 267.3,26.37 266.92,25.99 R322.2 266.49,25.23 v2(266.64,25.07)
N17011679: length 3.4
  TOP w0.254: 267.3,35.28 267.47,35.45 U8.5
  TOP w0.508: 267.3,35.28 266.54,35.28 C351.2 v2(265.32,35.56)
N17011706:
  vias: v2(269.49,38.61)
N17011853:
  vias: v2(277.08,38.54)
N17011867: length 2.3
  TOP w0.254: U8.44 277.19,35.45 277.59,35.06
  TOP w0.508: C354.2 277.97,34.67 277.59,35.06
N17104532: length 5.4
  TOP w0.097: v3(37.43,74.38) 38.19,74.38 39.09,73.49 39.09,72.04 R2058.2
  BOTTOM w0.102: v3(37.43,74.38) U2007.A5
N17104536: length 5.1
  TOP w0.097: R2059.2 v2(38.7,72.98) 38.7,73.23 38.2,73.74 v2(37.43,73.74)
  BOTTOM w0.076: U2007.B5 36.01,74.12 36.15,74.12 36.15,74.12 36.8,74.12
  BOTTOM w0.102: v2(37.43,73.74) 37.31,73.74 36.92,74.12 36.8,74.12
N17166492: length 1.6
  TOP w0.089: R2086.2 35.61,75.21 v2(35.3,75.52)
  BOTTOM w0.089: U2007.D7 34.89,75.52 v2(35.3,75.52)
N17166775: length 1.5
  TOP w0.089: R2085.2 33.07,76.74 v2(33.42,76.38)
  BOTTOM w0.089: U2007.G10 33.25,76.55 v2(33.42,76.38)
N17246415: length 3
  TOP w0.076: 51.54,89.98 51.54,89.35 v2(51.91,88.98)
  TOP w0.102: R2032.1 50.9,90.63 v2(51.38,90.15) 51.54,89.98
  BOTTOM w0.102: v2(51.91,88.98) 51.59,88.66 U2005.N6
N17249246: length 2.1
  TOP w0.097: U7.4 283.9,35.01 283.4,35.51 v2(283.28,35.51) TP93.1
N17282944: length 4.9
  TOP w0.089: R2089.1 29,76.31 v2(28.87,76.43) 28.54,76.76 v2(28.54,76.91)
  BOTTOM w0.076: U2007.K8 31.49,76.14 30.71,76.14 30.2,76.66 29.1,76.66 v2(28.87,76.43)
N17283025: length 3.6
  TOP w0.089: v2(29.94,76.28) 30.04,76.18 v2(30.04,75.67) R2090.2
  BOTTOM w0.076: U2007.L8 30.72,75.88 30.32,76.28 v2(29.94,76.28)
N17351028: length 9.1
  TOP w0.097: v3(30.93,81.26) 31.19,81.51 31.77,81.51 31.87,81.41 R2093.1 ; U2011.4 v1(26.67,77.96)
  IN08 w0.089: 26.97,80.55 27.15,80.72
  IN08 w0.091: v1(26.67,77.96) 26.77,78.06 26.77,80.34 26.97,80.55 ; 27.15,80.72 27.4,80.98 30.65,80.98 v3(30.93,81.26)
N17351043: length 4.9
  TOP w0.089: R2096.2 29.94,79.84 29.86,79.76 C2139.1 R2097.2 28.34,79.96 27.4,79.96 26.97,80.39 ; U2011.2 27.02,79.84 26.97,79.89
  TOP w0.097: 26.97,80.39 v2(26.89,80.47) 26.89,79.96 26.97,79.89
N17738807: length 1.2
  TOP w0.356: R344.1 278.35,45.24 R346.1
N17740217: length 6.3
  TOP w0.254: C374.2 287.5,50.42 287.29,50.63 v1(287.12,50.63) 286.99,50.63 286.68,50.32 U9.22 ; U9.26 286.99,52.92 v1(287.12,53.04)
  BOTTOM w0.254: v1(287.12,50.63) v1(287.12,53.04)
N17740396: length 6
  TOP w0.254: v1(287.12,47.32) 286.86,47.07 U9.17 ; U9.21 286.68,49.67 286.99,49.36 v1(287.12,49.36) 287.37,49.36 287.57,49.56 C376.2
  BOTTOM w0.254: v1(287.12,47.32) v1(287.12,49.36)
N17741392: length 1.8
  TOP w0.457: C379.1 R333.2
  TOP w0.508: C379.1 v2(290.72,52.2)
N17741619: length 0.9
  TOP w0.457: R334.2 289.78,48.06 289.71,47.98 C380.1
N17787956: length 5.2
  BOTTOM w0.254: R554.2 203.55,108.39 204.16,107.78 v2(206.12,107.78) 206.59,108.25 U25.7
N17791490: length 2
  TOP w0.508: R343.1 277.16,43.64 C382.1 277.21,44.33 R344.2
N17791569: length 3
  TOP w0.508: v2(274.87,43.34) R339.1 276.24,43.77 C382.2 275.36,44.28 R340.2
N18154072: length 2.5
  TOP w0.254: PQ1404.3 117.95,69.15 v2(117.95,69.55) 118.89,69.55 PR1407.1
N18154233: length 1.1
  BOTTOM w0.356: PQ1405.3 208.26,194.38 207.97,194.67 PR1411.1
N18154289: length 1
  BOTTOM w0.097: PR1410.2 207.51,193.78 207.61,193.88 PQ1405.2
N18154418: length 3.3
  TOP w0.097: PQ1404.2 119.45,67.9 119.83,67.52 v2(119.83,67.34) 119.83,66.91 119.12,66.2 PR1408.2
N18154431: length 1.3
  TOP w0.097: PR1405.2 107.46,66.88 PQ1401.2
N18155028: length 4.2
  TOP w0.254: PQ1403.3 110.47,70.74 110.8,71.07 112.11,71.07 v2(112.24,70.95) 112.8,70.39 PR1404.1
N18155196: length 2.7
  TOP w0.254: PR1413.1 112.43,67.83 112.62,68.02 v2(112.62,68.41) 111.86,68.41 111.72,68.54 PQ1403.6
N18288660: length 7.2
  TOP w0.254: PU201.18 87.51,8.6 87.82,8.29
  TOP w0.508: 87.82,8.29 88.28,7.83 89.48,7.83 v2(89.61,7.7) 89.63,7.7 90.77,6.56 PC220.1 91.22,6.49 92.34,5.38 PR218.1
N18288662: length 2.3
  TOP w0.356: PQ203.4 101.65,19.46 PR231.2 PC203.1
N18288666: length 50
  TOP w0.254: v1(87.76,3) 87.76,3.44 PR211.2 ; v1(111.09,21.67) 110.57,21.15 PR207.1
  TOP w0.356: PC203.2 105.38,20.65
  IN05 w0.254: v1(87.76,3) 87.66,3.11 87.66,4.47 83.54,8.59 83.54,14.81 84.42,15.7 86.74,15.7 92.46,21.42 106.01,21.42 106.4,21.8 110.97,21.8 v1(111.09,21.67)
N18288670: length 6.4
  TOP w0.254: 88.9,8.41 88.54,8.41 v2(88.09,8.86) 87.94,9 PU201.19
  TOP w0.381: PR214.1 90.27,7.89 89.75,8.41 88.9,8.41
  TOP w0.508: PC214.1 92.49,7.57 91.22,7.57 PR214.1
N18288674: length 5.4
  TOP w0.254: PC221.2 PR221.2 81.76,5.24 81.76,5.81 82.35,6.4 82.52,6.4 82.8,6.68 83.66,6.68 84.19,7.21 PU201.10
N18343239: length 1.1
  BOTTOM w0.254: PTP903.1 268.3,201.74 PU902.28
N18346836: length 4.1
  BOTTOM w0.254: PU901.27 255.71,202.17 PC906.1 256.54,202.17 256.54,201.53 256.51,201.5 PU901.29
N18346842: length 2.1
  BOTTOM w0.254: PU901.30 256.91,201.4 257.4,201.88 PR902.2
N18346852: length 1.3
  BOTTOM w0.508: PR902.1 PC906.2
N18349561: length 1.1
  BOTTOM w0.254: PT1001.1 219.54,201.74 PU1001.28
N18349775: length 4.1
  BOTTOM w0.254: PU1001.27 219.14,202.17 PC1006.1 219.96,202.17 219.96,201.53 219.94,201.5 PU1001.29
N18349779: length 2.1
  BOTTOM w0.254: PR1001.2 220.82,201.88 220.34,201.4 PU1001.30
N18349781: length 1.3
  BOTTOM w0.508: PC1006.2 PR1001.1
N18350194: length 4.1
  BOTTOM w0.254: PU1002.27 231.33,202.17 PC1007.1 232.15,202.17 232.15,201.53 232.13,201.5 PU1002.29
N18350200: length 2.1
  BOTTOM w0.254: PR1008.2 233.01,201.88 232.53,201.4 PU1002.30
N18421582: length 1.3
  BOTTOM w0.508: PC1007.2 PR1008.1
N19686618: length 1
  BOTTOM w0.457: R96.2 164.54,58.93 C175.1
N19687681: length 1.1
  BOTTOM w0.457: R92.2 161.01,94.52 C172.1
N20070704: length 4.7
  BOTTOM w0.254: PU901.7 257.31,196.69 PC972.2
  BOTTOM w0.508: PC972.2 258.34,195.18 258.56,194.96 259.37,194.96 260.13,194.2 PR904.1
N20070817: length 1.6
  BOTTOM w0.254: PU901.3 258.51,199.03 259.2,199.72 PR909.1
N20070821: length 2.6
  BOTTOM w0.254: PR910.2 258.54,202.39 257.31,201.16 PU901.31
N20070823: length 2.2
  BOTTOM w0.254: PU901.2 258.35,199.43 258.59,199.67 258.59,200.28 258.97,200.66 PR906.2
N20071127: length 1.3
  BOTTOM w0.254: PU901.4 259.03,198.63 PR908.1
N20073306: length 1.1
  BOTTOM w0.254: PTP901.1 256.11,201.74 PU901.28
N20073337: length 0.8
  BOTTOM w0.356: PTP902.1 257.4,195.79 256.89,196.29
N20074453: length 0.9
  BOTTOM w0.356: 269.06,196.32 269.59,195.79 PTP904.1
N20074727: length 2
  BOTTOM w0.254: PR919.2 269.46,201.76 269.1,201.4 PU902.30
N20074738: length 4.1
  BOTTOM w0.254: PU902.27 267.9,202.29 PC23.1 268.73,202.04 268.73,201.53 268.7,201.5 PU902.29
N20076374: length 0.8
  BOTTOM w0.356: 220.31,196.29 220.82,195.79 PTP905.1
N20077877: length 0.8
  BOTTOM w0.356: 232.51,196.29 233.01,195.79 PTP906.1
N20137254: length 1
  BOTTOM w0.254: PR429.2 208.91,113.67 208.83,113.74 PC435.1
N20137290: length 1.3
  BOTTOM w0.508: PC428.1 213.38,112.32 PR418.2
N20137326: length 1
  BOTTOM w0.508: PR428.2 PC424.1
N20137941: length 2.7
  TOP w0.254: PU401.12 110.06,87.39 PC411.1 109.3,86.63 PR405.2
N20137996: length 1.3
  TOP w0.254: PU401.13 110.46,86.9 PR404.1
N20138007: length 4.9
  TOP w0.254: v2(107.03,85.27) 107.11,85.35 PR406.1 PR407.1 107.16,87.07 107.54,87.46 109.32,87.46 109.66,87.8 PU401.11
N20153824: length 15.2
  TOP w0.254: PU603.3 272.77,64.6 272.64,64.72 270.99,64.72 ; PC230.2 274.8,49.48 274.16,48.85 270.23,48.85 269.72,49.36 PQ904.5
  TOP w0.457: 270.99,64.72 269.84,64.72 268.36,63.24
  BOTTOM w0.508: PR608.2 269.4,60.9 v1(268.62,60.13)
  vias: v2(268.5,64.67)
N20153845: length 4.9
  TOP w0.254: v1(273.91,60.02) 273.78,60.15 273.65,60.15 273.27,60.54 PU603.9
  BOTTOM w0.457: v1(273.91,60.02) 273.73,60.2 PC666.1
  BOTTOM w0.508: PC666.1 271.56,60.2 PR608.1
N20154004: length 1.4
  BOTTOM w0.508: v1(272.18,57.51) 272.21,57.48 PR417.1
N20154042: length 2.6
  TOP w0.254: PU603.2 273.27,64.77 273.6,65.1 PR612.1 PR609.2
N20154060: length 1.6
  TOP w0.254: PC678.2 274.87,60.53 274.09,60.53 273.77,60.85 PU603.10
N20154066: length 2.9
  TOP w0.254: PU603.1 274.83,64.04 v2(275.05,64.26) 275.05,64.72 274.54,65.23 PR611.1
N20154076: length 0.9
  TOP w0.254: PC677.1 PR611.2
N20157139: length 2
  BOTTOM w0.508: v2(135.43,147.02) 135,147.45 PC1271.1 PR1225.2
N20157150: length 2.2
  BOTTOM w0.508: v2(126.97,149.5) PR1222.2 128.19,150.37 PC1275.1
N20171191: length 1.3
  BOTTOM w0.508: PR1501.2 PC1510.2
N20171267: length 2.3
  BOTTOM w0.305: PU1501.30 164.02,189.48 164.21,189.67 164.21,190.77 PR1501.1
N20172372: length 1.3
  BOTTOM w0.508: PR1508.2 PC1530.2
N20172448: length 2.4
  BOTTOM w0.305: PR1508.1 175.36,190.71 174.82,190.17 PU1502.30
N20172556:
  vias: v2(173.83,184.31)
N20172566:
  vias: v2(168.24,184.99)
N20172586: length 4.6
  BOTTOM w0.305: PU1502.29 174.42,190.82 PC1530.1 173.62,190.68 PU1502.27
N20172640: length 8.3
  BOTTOM w0.203: PL1502.3 169.34,177.04 168.63,177.75 166.29,177.75 PR1511.1 v2(164.15,176.53)
N20172665: length 8.2
  BOTTOM w0.203: v2(164.15,179.23) PR1513.1 166.16,178.13 168.63,178.13 169.34,178.84 PL1502.2
N20172725:
  vias: v2(152.85,180.32)
N20172742: length 9.2
  BOTTOM w0.203: PL1501.3 157.27,177.45 156.97,177.75 153.59,177.75 PR1505.1 v2(151.45,176.53)
N20172758: length 9
  BOTTOM w0.203: PL1501.2 157.27,178.44 156.97,178.13 153.46,178.13 PR1504.1 v2(151.45,179.23)
N20172788: length 4.6
  BOTTOM w0.305: PU1501.29 163.62,189.67 163.72,189.77 163.72,190.59 PC1510.1 162.8,190.63 162.8,189.67 162.82,189.65 PU1501.27
N20172887:
  vias: v2(152.12,185.25)
N20172906: length 2.8
  BOTTOM w0.508: PC1541.1 165.12,184.15 164.47,183.51 PR1514.2
N20233119: length 1.6
  TOP w0.254: PR1412.1 108.68,66.37 PQ1401.3
N20234305: length 1.3
  BOTTOM w0.097: PT1501.1 163.22,190.26 PU1501.28
N20234840: length 1.1
  BOTTOM w0.097: PT1503.1 174.02,190.06 PU1502.28
N21283256: length 3.6
  TOP w0.457: v3(242.67,58.63) 243.12,59.08 R226.2 243.81,59.26 244.06,59.01 R224.2
  BOTTOM w0.254: R223.2 v2(255.82,64.66)
  vias: v3(253.59,62.18)
N21871531:
  vias: v2(79.73,21.8)
N21871557: length 7.1
  TOP w0.508: R571.2 73.81,18.67 74.2,19.07 Q11.3 v2(76.52,19.07) 77.25,19.07 77.85,19.67 D38.1 78.61,19.64 D39.1
N21871764: length 2.4
  TOP w0.097: Q11.2 75.66,20.98 v2(75.66,21.92)
  TOP w0.508: Q11.2 76.07,20.58 R569.1
N22215424: length 2.1
  BOTTOM w0.097: v2(72.87,98.38) 72.94,98.45 R395.1 74.05,98.5 Q7.6
N22216469: length 1.1
  BOTTOM w0.097: R396.1 76.85,97.5 Q7.3
N22751697: length 2.7
  TOP w0.097: PU1304.4 20.86,18.07 20.7,18.24 20.7,19 v2(21.08,19.38) PR1306.1
N22751755:
  vias: v2(183.99,194.52)
N22751764: length 1.4
  BOTTOM w0.097: PU1306.8 183.71,196.55 PR1310.2
N22751770: length 1.3
  BOTTOM w0.097: PU1306.5 178.5,197.55 PR1314.2
N22751809: length 3.2
  BOTTOM w0.305: 179.04,196.55 PU1306.3
  BOTTOM w0.356: PR1309.1 177.29,195.15 178.48,196.35 PC1312.1 178.61,196.55 179.04,196.55
N22751813: length 3.5
  BOTTOM w0.097: PR1312.2 176.7,197.23 176.88,197.05 PU1306.4
N22751871: length 1.5
  BOTTOM w0.097: PR1311.1 194.53,194.14 194.79,194.39 PU1307.2
N22751880: length 2.5
  TOP w0.356: PC1313.2 196.62,194.34 197.12,194.34 v1(197.33,194.14) 197.5,194.31 PC1311.2
  BOTTOM w0.254: v1(197.33,194.14) 197.07,194.39 PU1307.5
N22752556: length 2.9
  BOTTOM w0.097: PR1302.1 60.37,44.4 60.42,44.45 v2(61.11,44.45) 61.11,43.44 60.89,43.22 PU1301.4
N22806469: length 4.5
  TOP w0.356: PR108.1 v2(79.17,91.88) ; PR108.1 79.17,93.65 PR106.2 ; PR108.1 79.18,92.77 PQ101.3 80.62,92.77 80.85,93 80.85,93.2 80.62,93.42 PQ101.2
N22806481: length 4.7
  TOP w0.305: PQ101.6 82.03,94.07 82.27,94.31 82.27,94.69 82.09,94.87 PR107.2
  TOP w0.356: PR107.2 82.15,95.27 83.41,95.27 PR105.2
  TOP w0.381: PR105.2 v2(85.14,94.76)
N22806527:
  vias: v2(24.99,21.42)
N22807451:
  vias: v2(87.22,17.99)
N22864850: length 4.4
  TOP w0.097: PU402.2 103.28,85.32 PR433.2 103.35,85.04 103.09,84.79 102.79,84.79 PR409.2 101.82,83.82 v2(101.82,83.26)
N22864858: length 1.6
  TOP w0.097: PR426.2 104.58,85.46 PU402.4
N22864873: length 6.5
  TOP w0.097: v2(106.27,83.9) 106.27,84.81 106.03,85.04 105.46,85.04 PR430.2 105,85.5 105,87.58 104.58,88 PU402.5
N22875618: length 3.6
  TOP w0.254: PR1414.1 56.03,9.98 PQ1402.3 ; PR1414.1 56.76,9.25 v2(56.76,8.56) ; PR1414.1 PQ1402.2
N23003437: length 2.7
  TOP w0.254: PR610.2 PC676.1 274.86,39.31 PQ206.2
N23054269: length 1.8
  BOTTOM w0.254: PR506.2 266.62,48.95 PC515.1 v2(267.53,48.09)
N23054303: length 1.1
  TOP w0.457: PR504.2 PC514.1
N23054336: length 1.3
  TOP w0.508: PR502.2 266.42,50.69 PC504.1
N23056736: length 1.1
  TOP w0.254: PU1254.5 187.55,129.04 PC1259.1
N23057133: length 3.5
  TOP w0.254: PR1251.2 PC1251.1 205.66,153.57 206.09,154 206.6,154 206.84,154.25 PU1252.1
N23057736: length 1.4
  TOP w0.254: PU1252.5 205.18,155.71 PC1254.1
N23081959:
  vias: v2(189.17,181.18)
N23081971: length 8.3
  BOTTOM w0.203: v2(188.28,176.53) PR1605.1 190.42,177.75 192.76,177.75 193.47,177.04 PL1601.3
N23081985: length 8.2
  BOTTOM w0.203: PL1601.2 193.47,178.84 192.76,178.13 190.29,178.13 PR1604.1 v2(188.28,179.23)
N23082001: length 4.4
  BOTTOM w0.305: PU1601.27 195.21,189.65 195.18,189.67 195.18,190.34 195.42,190.58 196.37,190.58 PC1608.1 196.44,190.2 196.01,189.77 PU1601.29
N23082126: length 1.3
  BOTTOM w0.508: PR1601.2 PC1608.2
N23082214: length 2.4
  BOTTOM w0.305: PU1601.30 196.41,189.41 196.82,189.82 197.45,189.82 197.71,190.07 PR1601.1
N23082223: length 1.3
  BOTTOM w0.508: PR1607.2 188.93,184.27 PC1619.1
N23083331:
  vias: v2(177.08,181.23)
N23083348: length 8.4
  BOTTOM w0.203: PL1602.3 181.4,177.04 180.69,177.75 178.35,177.75 PR1613.1 176.35,176.53 v2(176.22,176.66)
N23083362: length 8.2
  BOTTOM w0.203: PL1602.2 181.4,178.84 180.69,178.13 178.23,178.13 PR1612.1 v2(176.22,179.23)
N23083378: length 4.6
  BOTTOM w0.305: PU1602.29 185.21,190.82 PC1627.1 184.39,190.66 184.39,189.67 184.41,189.65 PU1602.27
N23083503: length 1.3
  BOTTOM w0.508: PR1608.2 PC1627.2
N23083591: length 2.4
  BOTTOM w0.305: PR1608.1 185.71,190.71 185.71,189.5 185.61,189.41 PU1602.30
N23083597: length 1.6
  BOTTOM w0.508: PR1614.2 177.69,184.32 177.18,184.83 PC1638.1
N23089662:
  vias: v2(200.07,181.56)
N23089674: length 8.3
  BOTTOM w0.203: v2(199.21,176.53) PR1619.1 201.34,177.75 203.68,177.75 204.39,177.04 PL1603.3
N23089690: length 8.2
  BOTTOM w0.203: v2(199.21,179.23) PR1618.1 201.21,178.13 203.68,178.13 204.39,178.84 PL1603.2
N23089696: length 4.3
  BOTTOM w0.305: PU1603.27 206.13,189.65 206.11,189.67 206.11,190.21 206.47,190.58 207.3,190.58 PC1650.1 207.36,190.2 206.93,189.77 PU1603.29
N23089821: length 2.9
  BOTTOM w0.508: v2(210.03,191.34) 209.46,191.91 PR1615.2 PC1650.2
N23089907: length 2.4
  BOTTOM w0.305: PU1603.30 207.33,189.41 207.74,189.82 208.38,189.82 208.63,190.07 PR1615.1
N23163323: length 1.5
  BOTTOM w0.254: PU902.3 271.24,199.03 PR920.1
N23163349: length 4.6
  BOTTOM w0.254: PU902.7 269.5,196.76 269.84,196.42
  BOTTOM w0.508: 269.84,196.42 270.53,195.74 PC973.2 270.53,195.1 271.05,194.58 PR918.1
N23163371: length 2.6
  BOTTOM w0.254: PU902.31 269.5,201.16 270.61,202.26 PR915.2
N23163373: length 1.7
  BOTTOM w0.254: PR922.2 271.5,200.23 270.7,199.43 PU902.2
N23163385: length 1.5
  BOTTOM w0.254: PU902.4 271.36,198.63 PR992.1
N23164129: length 1.6
  BOTTOM w0.254: PR1009.1 222.63,199.72 221.94,199.03 PU1001.3
N23164159: length 4.9
  BOTTOM w0.254: 221.08,196.42 220.74,196.76 PU1001.7
  BOTTOM w0.356: PC1074.2 221.08,196.35 221.08,196.42
  BOTTOM w0.508: PC1074.2 221.76,195.1 222.03,194.83 223.17,194.83 223.87,194.14 PR1053.1
N23164181: length 2.6
  BOTTOM w0.254: PR1020.2 221.97,202.39 220.74,201.16 PU1001.31
N23164183: length 2.1
  BOTTOM w0.254: PU1001.2 221.78,199.43 222.02,199.67 222.02,200.28 222.4,200.66 PR1007.2
N23164187: length 1.3
  BOTTOM w0.254: PR1005.1 222.45,198.63 PU1001.4
N23165109: length 1.8
  BOTTOM w0.254: PU1002.3 234.23,199.03 234.79,199.6 PR1014.1
N23165131: length 4.8
  BOTTOM w0.254: 233.27,196.35 233.27,196.42 232.93,196.76 PU1002.7
  BOTTOM w0.356: PC1081.2 233.27,196.35
  BOTTOM w0.508: PR1022.1 235.17,194.96 234.16,194.96 233.95,195.16 PC1081.2
N23165157: length 2.6
  BOTTOM w0.254: PR1023.2 234.16,202.39 232.93,201.16 PU1002.31
N23165159: length 1.9
  BOTTOM w0.254: PU1002.2 233.97,199.43 234.67,200.13 234.67,200.28 PR1024.2
N23165163: length 1.5
  BOTTOM w0.254: PU1002.4 235.02,198.63 PR1025.1
N23165920: length 2.4
  TOP w0.356: PR1597.1 166.57,188.52 v1(166.21,188.17)
  BOTTOM w0.305: PU1501.3 165.66,187.36 166.21,187.91 v1(166.21,188.17)
N23165924: length 1.4
  BOTTOM w0.254: v1(165.17,185.22) 165.47,185.52 165.47,185.98 165.29,186.16 PU1501.6
N23165942: length 3.6
  BOTTOM w0.305: PU1501.7 164.43,185.3 164.43,184.41 v2(164.36,184.33) PC1512.2
  BOTTOM w0.381: PR1503.1 163.16,182.58 163.49,182.91 PC1512.2
N23165976: length 2.7
  BOTTOM w0.305: PU1501.31 164.42,189.18 164.74,189.5 164.74,190.22 164.99,190.48 165.09,190.48 165.58,190.96 PR1598.2
N23165978: length 4.6
  BOTTOM w0.203: PU1501.2 165.43,187.76 165.7,188.04 165.7,188.55 165.25,189 v2(165.25,190) 165.83,190.58 165.91,190.58 PR1506.2
N23165982: length 3.5
  BOTTOM w0.203: PR1599.1 166.47,188.8 166.69,188.57 166.69,187.84 165.82,186.96 PU1501.4
N23166837: length 2.5
  TOP w0.356: PR1595.1 176.83,187.71 v1(177.08,187.96)
  BOTTOM w0.305: v1(177.08,187.96) 176.48,187.36 PU1502.3
N23166841: length 0.9
  BOTTOM w0.254: v1(176.25,185.53) 176.25,186.01 176.09,186.16 PU1502.6
N23166859: length 3.6
  BOTTOM w0.305: PC1532.2 174.26,183.65 175.22,184.6 PU1502.7
  BOTTOM w0.381: PR1510.1 174.28,183.33 PC1532.2
N23166885: length 2.6
  BOTTOM w0.305: PR1596.2 176.37,190.94 v2(175.48,190.05) 175.22,189.78 PU1502.31
N23166887: length 4.2
  BOTTOM w0.203: PU1502.2 176.22,187.76 176.5,188.04 176.5,190.33 177.26,191.09 PR1512.2
N23166891: length 3.3
  BOTTOM w0.305: PR1622.1 177.62,188.24 177.62,187.73 176.97,187.09 v2(176.94,187.09) 176.82,186.96 PU1502.4
N23167680: length 1.6
  BOTTOM w0.305: PU1601.3 198.05,187.36 198.72,188.04 PR1624.1
N23167702: length 2.7
  BOTTOM w0.305: PC1610.2 197,184.56 196.81,184.75 PU1601.7
  BOTTOM w0.356: PR1603.1 197.01,183.96 PC1610.2
N23167736: length 2.4
  BOTTOM w0.305: PU1601.31 196.81,189.18 196.98,189.35 197.33,189.35
  BOTTOM w0.356: PR1625.2 198.43,189.82 197.96,189.35 197.33,189.35
N23167738: length 2
  BOTTOM w0.203: PR1606.2 198.6,188.93 198.09,188.42 198.09,188.04 197.81,187.76 PU1601.2
N23167742: length 1.4
  BOTTOM w0.305: PR1623.1 198.59,186.96 PU1601.4
N23168679: length 2.4
  TOP w0.356: v1(187.78,188.17) 187.7,188.09 PR1631.1
  BOTTOM w0.305: PU1602.3 187.23,187.36 187.78,187.91 v1(187.78,188.17)
N23168701: length 2.7
  BOTTOM w0.305: PC1629.2 186.2,184.56 186.01,184.75 PU1602.7
  BOTTOM w0.356: PC1629.2 186.21,183.96 PR1610.1
N23168727: length 2.6
  BOTTOM w0.305: PU1602.31 186.01,189.18 186.28,189.45 186.28,190.07 187.17,190.96 PR1628.2
N23168729: length 4.2
  BOTTOM w0.203: PU1602.2 187.02,187.76 187.29,188.04 187.29,188.67 187.52,188.9 187.52,190.61 PR1611.2
N23168733: length 3.1
  BOTTOM w0.254: PU1602.4 187.41,186.96 188.28,187.84 188.28,188.62 PR1629.1
N23169663: length 1.6
  BOTTOM w0.305: PR1633.1 209.65,188.04 208.97,187.36 PU1603.3
N23169685: length 2.7
  BOTTOM w0.305: PC1648.2 207.92,184.56 207.73,184.75 PU1603.7
  BOTTOM w0.356: PC1648.2 207.93,183.96 PR1617.1
N23170380: length 2.4
  BOTTOM w0.305: PU1603.31 207.73,189.18 207.9,189.35 208.25,189.35
  BOTTOM w0.356: PR1630.2 209.35,189.82 208.88,189.35 208.25,189.35
N23170382: length 1.4
  BOTTOM w0.305: PU1603.4 209.51,186.96 PR1632.1
N23170384: length 2
  BOTTOM w0.203: PR1620.2 209.52,188.93 209.01,188.42 209.01,188.04 208.73,187.76 PU1603.2
N24008107: length 1.1
  BOTTOM w0.097: PT1601.1 195.61,190.06 PU1601.28
N24010016: length 2.4
  BOTTOM w0.305: PU1601.6 198.24,186.16 198.34,186.26 PC1609.1
  BOTTOM w0.356: PC1609.1 198.77,185.83 198.98,185.63 PR1602.2
N24010249: length 2.6
  TOP w0.356: PR1609.2 187.43,185.5 v1(187.04,185.5) PC1628.1
  BOTTOM w0.254: v1(187.04,185.5) 187.04,185.88 186.76,186.16 PU1602.6
N24011067: length 2.4
  BOTTOM w0.305: PC1647.1 209.27,186.26 209.17,186.16 PU1603.6
  BOTTOM w0.356: PC1647.1 209.7,185.83 209.9,185.63 PR1616.2
N24022243: length 2.6
  BOTTOM w0.254: PC907.1 258.46,197.51 258.14,197.83 PU901.6
  BOTTOM w0.508: PC907.1 259.81,197.51 260.05,197.76 PR903.2
N24022700: length 2.8
  BOTTOM w0.254: PU902.6 270.34,197.83 270.66,197.51 PC1542.1
  BOTTOM w0.508: PC1542.1 271.93,197.51 272.45,196.99 PR911.2
N24023177: length 2.6
  BOTTOM w0.254: PC1072.1 221.89,197.51 221.57,197.83 PU1001.6
  BOTTOM w0.508: PR1002.2 223.32,197.51 PC1072.1
N24023662: length 2.5
  BOTTOM w0.254: PC1082.1 234.16,197.51 233.84,197.83 PU1002.6
  BOTTOM w0.508: PR1021.2 235.03,197.76 PC1082.1
N24034924: length 1.6
  TOP w0.203: PC1327.2 199.41,153.57 199.81,153.17 PU1308.5
N24579709: length 9
  BOTTOM w0.076: 33.03,56.21 33.03,55.31 33.18,55.16
  BOTTOM w0.089: U5.K5 34.27,54.42 33.92,54.77 33.92,54.99 33.75,55.16 33.18,55.16 ; 31.47,58.63 30.58,58.63
  BOTTOM w0.097: 30.58,58.63 v2(29.84,59.36) 29.69,59.52 C310.1 ; 33.03,56.21 33.03,57.19 32.86,57.36 32.74,57.36 31.47,58.63
N24733526: length 1.9
  BOTTOM w0.254: U50.2 62.19,11.45 R872.1
N25031555: length 4.5
  BOTTOM w0.097: U58.2 44.55,35.51 43.78,36.27 v2(43.78,36.4) 43.78,36.91 44.55,37.67 C699.1 R300.1
N25091766: length 1.1
  BOTTOM w0.097: U61.2 46.12,41.1 R521.2
N25091772: length 2
  BOTTOM w0.097: R61.1 C572.2 46.01,41.75 U61.1
N25389389: length 41.8
  TOP w0.203: v1(79.98,18.49) 80.11,18.37 80.11,18.05 PR233.2
  TOP w0.254: v1(48.1,29.67) 48.1,30.18 47.58,30.7 PR201.1
  IN03 w0.254: v1(79.98,18.49) 80.11,18.62 80.11,19.48 78.68,20.91 75.53,20.91 69.06,27.38 57.63,27.38 55.98,29.04 50.52,29.04 50.13,28.65 48.66,28.65 48.31,29.01 48.31,29.47 v1(48.1,29.67)
  vias: v2(44.17,34.37)
N25440711: length 3.7
  TOP w0.254: PR1177.1 PC1141.1 PC1143.1 121.91,183.39 PR1169.2 v2(120.95,183.34)
N25456253: length 7.9
  TOP w0.203: PU201.32 83.79,11.64 83.54,11.89 82.62,11.89 v2(82.06,12.45) 81.96,12.55 80.45,12.55 79.66,13.34 PC205.1 79.66,14.24 79.74,14.32 PC224.1 79.74,15.69 79.6,15.83 PR233.1
N25456262: length 7.8
  TOP w0.203: PU201.31 84.19,12 83.92,12.27 83.03,12.27 82.39,12.91 80.87,12.91 80.68,13.1 PC206.1 80.68,13.99 81.13,14.44 PC224.2 81.13,15.88 PR232.1
N25470408: length 6.1
  IN03 w0.508: v1(153.32,200.54) 152.37,199.59 152.37,197.67 152.88,197.17 v1(152.94,197.17)
  BOTTOM w0.305: PU1303.A1 152.3,197.55 152.69,197.17 v1(152.94,197.17)
  BOTTOM w0.33: 152.44,199.58 152.3,199.45 PU1303.A4
  BOTTOM w0.508: PC1307.1 152.44,199.58
N25470498: length 5.3
  BOTTOM w0.097: PU1303.B3 151.16,198.69 150.78,198.31 149.08,198.31 148.43,198.96 v2(148.18,198.96) 148.18,198.2 148.31,198.07 148.31,198.07 PR1305.1
N25470530: length 1.6
  BOTTOM w0.33: PU1303.B2 151.17,198.19 150.78,197.8 150.38,197.8 PC1317.2
N25541282: length 12
  TOP w0.097: R484.1 v1(259.18,66.12)
  BOTTOM w0.097: v1(259.18,66.12) 263.49,66.12 267.5,70.13 JWLAN1.54
N25541303: length 11.3
  TOP w0.097: R517.1 v1(259.18,67.39)
  BOTTOM w0.097: JWLAN1.56 267,70.01 264,67.01 259.56,67.01 v1(259.18,67.39)
N25547911: length 1.2
  TOP w0.381: R849.2 296.23,34.28 C510.2
N25547913: length 1.3
  TOP w0.381: C511.2 296.3,31.63 R850.2
N25547935: length 1.8
  BOTTOM w0.508: v2(295.65,31.55) 295.53,31.67 R847.1 295.52,32.48 D9.1
N25547941: length 1.8
  BOTTOM w0.508: D10.1 295.49,33.62 R848.1 295.53,34.42 v2(295.6,34.5)
N25681410: length 2.8
  BOTTOM w0.097: R873.2 58.74,9.68 ; 58.74,9.68 v2(58.74,9.67) ; 58.74,9.68 58.85,9.68 59.23,10.06 59.23,10.57 59,10.8 U50.4
N25683019: length 6.9
  TOP w0.076: 72.85,7.06 72.85,8.34 72.6,8.59 U19.J4
  TOP w0.089: 73.96,5.54 72.94,6.56 72.85,6.56 72.85,7.06
  TOP w0.097: 73.96,5.54 R930.2 73.81,5.36 73.63,5.19 73.63,3.66 v2(74.06,3.23)
N25683144: length 11.4
  TOP w0.097: C320.1 v3(77.69,6)
  TOP w0.102: U19.K5 v2(73.63,9.37)
  BOTTOM w0.097: v3(77.69,6) 77.11,5.41 72.49,5.41 v2(72.36,5.54) 72.36,5.92 73.88,7.45 73.88,9.11 v2(73.63,9.37)
N25685333: length 9.5
  TOP w0.076: 69.84,15.07 69.84,13.12 U19.D12
  TOP w0.097: TP143.1 69.06,21.29 68.93,21.16 v2(68.93,21.14) 68.75,20.96 68.75,16.39 69.84,15.3 69.84,15.07
N25685335: length 8.7
  TOP w0.097: U19.D13 70.1,15.42 68.98,16.54 68.98,18.7 v2(69.15,18.88) 69.15,20.24 69.44,20.53 69.95,20.53 TP155.1
N25685337: length 7.3
  TOP w0.076: U19.E12 70.34,13.12 70.34,13.47
  TOP w0.097: TP161.1 70.25,19.26 69.36,18.37 v2(69.36,17.35) 69.36,16.54 70.33,15.57 70.33,13.49 70.34,13.47
N25691111: length 1.3
  BOTTOM w0.097: v2(62.45,10.75) 62.4,10.8 U50.3
N25940457: length 1.3
  BOTTOM w0.097: U59.4 137.26,149.58 137,149.84 R537.1
N27165992: length 3.8
  BOTTOM w0.089: 36.05,57.09 36.05,58.31 R257.1 v2(37.21,58.55)
  BOTTOM w0.097: 36.05,57.09 35.78,56.82 U5.N8
N27176542: length 5.7
  BOTTOM w0.089: 40.86,51.01 40.61,51.26 40.1,51.26 39.97,51.13 39.47,51.13 38.69,51.91 ; v2(40.76,52.02) 41.5,52.02
  BOTTOM w0.097: U5.E13 38.69,51.91 ; 41.5,52.02 41.55,52.02 R777.2 R546.2 40.86,51.01
N27536412: length 1.8
  TOP w0.097: U21.5 22.56,41.99 22.83,42.26 22.83,43.06 R498.2
N27707657: length 2.1
  BOTTOM w0.097: U22.2 54.11,41.77 R832.1
N27707680: length 2.1
  BOTTOM w0.097: R833.1 54.07,41.35 53.71,41.72 U22.3
N27707693: length 1.9
  BOTTOM w0.097: R834.1 53.18,41.35 53.31,41.48 U22.4
N27707695: length 1.2
  BOTTOM w0.097: R834.2 53.18,38.94 TP138.1
N27707716: length 2.1
  BOTTOM w0.097: R835.1 52.91,41.54 U22.5
N27707880: length 2.2
  BOTTOM w0.097: U22.6 52.51,42.08 51.4,40.97 R836.1
N27707929: length 4.5
  BOTTOM w0.097: U22.7 52.11,42.06 51.91,41.86 51.45,41.86 R837.1 50.21,40.92 49.5,40.21 v2(49.5,39.7)
N27708322: length 2.1
  TOP w0.097: v2(109.06,98.5) 109.14,98.43 R57.2 108.86,97.21 U56.2
N27708482: length 2.9
  BOTTOM w0.097: U22.10 51.38,44.17 51.18,44.38 v2(51.18,44.83) 51.15,44.86 50.46,44.86 50.08,44.48 R838.1
N27708566: length 2.5
  BOTTOM w0.097: U22.8 51.33,43.37 51.02,43.06 v2(51.02,42.73) 50.29,41.99 R839.1
N27708610: length 2
  BOTTOM w0.097: U22.9 51.15,43.77 50.39,43.01 R840.1
N27708793: length 5.8
  BOTTOM w0.097: U22.12 52.51,45.84 51.73,46.61 R841.2 52.17,47.12 52.17,47.8 52.01,47.96 50.13,47.96 v2(50.01,47.83)
N27708827: length 1.9
  BOTTOM w0.097: U22.13 52.91,46.59 R842.2
N27708900: length 2.1
  BOTTOM w0.097: U22.14 53.31,45.98 R843.2
N27709001: length 2.1
  BOTTOM w0.097: TP132.1 56.72,43.37 v2(56,43.37) U22.20
N27709027: length 2.3
  BOTTOM w0.097: U22.19 56.23,43.77 v2(56.87,44.4)
N27709052: length 1.4
  BOTTOM w0.097: U22.18 55.87,44.17 TP144.1
N27709061: length 3.8
  BOTTOM w0.097: v2(56.87,46.82) 56.87,46.18 56.23,45.55 54.71,45.55 54.51,45.35 U22.17
N27709088: length 2.3
  BOTTOM w0.097: U22.16 54.11,45.33 54.71,45.93 TP182.1
N27794221: length 2.6
  BOTTOM w0.097: R844.2 54.4,46.05 53.94,46.05 53.71,45.82 U22.15
N28118695: length 1
  TOP w0.097: PR1415.2 53.26,9.48 PQ1402.5
N28118785: length 1.1
  TOP w0.254: PQ1402.6 53.95,8.98 53.69,8.72 PR1403.1
N28551818: length 76.5
  TOP w0.508: v1(83.28,19.13) 83.15,19.13 82.39,18.37 v2(82.39,16.34) 82.39,16.08 82.77,15.7 82.95,15.7 83.28,15.37 PR202.1 ; v1(39.67,25.78) PR236.1 40.53,26.5 PR235.1 ; v1(39.09,36.91) 38.96,37.04 PC202.2 38.4,37.56 PR237.1 38.13,39.07 35.35,39.07 PC201.1
  IN03 w0.508: v1(39.09,36.91) 37.69,35.51 37.69,27 38.91,25.78 v1(39.67,25.78) 42.31,25.78 46.96,30.43 56.23,30.43 58.14,28.53 69.82,28.53 72.49,25.86 75.66,25.86 82.39,19.13 v1(83.28,19.13)
N28552039: length 2.1
  TOP w0.097: PR213.2 82.06,8.72 82.35,9 PU201.6
N28552088: length 2.3
  TOP w0.097: PU201.7 82.69,8.6 v2(82.26,8.17) 81.91,7.83 PR215.2
N28552117: length 2.5
  TOP w0.097: PR216.2 81.58,6.81 82.97,8.2 PU201.8
N28552363: length 3.5
  TOP w0.254: PR219.2 81.33,5.92 v2(82.29,6.88) 82.38,6.97 82.38,6.98 82.6,7.19 83.61,7.19 83.79,7.37 PU201.9
N28552439: length 1
  TOP w0.254: PR221.1 81.07,4.91 81,4.98 PC222.2
N28552547: length 3.1
  TOP w0.254: PU201.11 84.59,6.98 84.42,6.82 84.42,6.81 83.87,6.25 PR224.2 PR222.1
N28554029: length 4.4
  TOP w0.254: PC216.1 88.15,5.23 PR211.1 88.05,5.22 87.35,5.92 87.35,6 PC213.1 86.19,7.16 PU201.15
N28554039: length 4
  TOP w0.254: PU201.14 85.79,6.64 PC213.2 86.25,6 86.87,5.38 PR212.1 85.87,5.22 PC217.1
N28554122: length 2.6
  TOP w0.254: 87.85,11.38 87.48,11 PU201.24
  TOP w0.356: 87.85,11.38 87.85,11.57 PR210.1
N28554284: length 1
  TOP w0.508: PR210.2 PC212.1
N28555638: length 2
  TOP w0.254: 84.93,12.53 84.99,12.47 PU201.29
  TOP w0.356: 84.93,12.53 84.55,12.91 PR204.2
N28555679: length 2.9
  TOP w0.254: PC207.2 85.29,13.59 85.29,12.83 85.39,12.73 PU201.28
N28555719: length 1.7
  TOP w0.254: PU201.27 85.79,12.65 85.82,12.69 PC207.1
N28555734: length 3.3
  TOP w0.254: PU201.26 86.19,11.9 86.46,12.17
  TOP w0.356: PC231.1 86.46,12.47 86.46,12.17
  TOP w0.508: PC231.1 86.76,14.55 PR205.2
N28559619: length 8.5
  TOP w0.508: PR218.2 94.04,6.04 v1(94.2,6.2) 95.5,6.2 PD201.1
  BOTTOM w0.508: v1(94.2,6.2) 94.2,7.41 93.34,8.27 93.34,8.99 93.7,9.35 PD202.1
N28559889: length 5.6
  TOP w0.254: PR217.2 91.16,5.67 91.03,5.79 90.73,5.79 89.43,7.09 88.28,7.09 v2(88.12,7.25) 87.17,8.2 PU201.17
N28559931: length 8.9
  TOP w0.254: PR217.1 v1(91.16,3.64)
  TOP w0.305: v1(97.33,5.54) 97.4,5.62 PH201.2
  IN08 w0.254: v1(97.33,5.54) 97.07,5.29 92.81,5.29 v1(91.16,3.64)
N28563405: length 4.9
  TOP w0.254: PR223.1 89.71,5.67 89.71,5.92 PR225.2 88.92,6.71 87.32,6.71 86.59,7.44 PU201.16
N28563583: length 2.2
  TOP w0.254: PU201.12 84.99,6.71 v2(84.88,6.6) 84.81,6.53 PR220.2
N28615744: length 1.3
  BOTTOM w0.508: PR919.1 PC23.2
N28664348: length 4.9
  TOP w0.097: PU201.13 85.39,6.25 85.31,6.18 85.31,3.64 84.93,3.25 PR208.2
N29688421: length 1.5
  TOP w0.097: PU605.3 73.51,51.76 PT602.1
N29688423: length 1.4
  TOP w0.097: PU605.4 73.38,51.26 PT603.1
N29688473: length 1.9
  TOP w0.254: PU605.15 79.58,47.8 PR624.2
N29688500: length 5.8
  TOP w0.203: PR647.1 78.4,47.65 77.95,47.2 PR648.1 v2(78.86,45.24)
  TOP w0.254: PR647.1 79.08,48.02 PU605.14
N29688522: length 2.2
  TOP w0.254: PU605.16 80.08,48.82 79.97,48.72 79.97,48.34 80.66,47.65 PR649.2
N29884571: length 6.6
  TOP w0.097: LD1.3 4.76,171.51 4.93,171.34 C168.1 v1(4.93,170.01) 4.93,169.84 R184.2
  BOTTOM w0.097: v1(4.93,170.01) 4.93,168.34 v2(6.32,166.96)
N29884573: length 13.1
  TOP w0.097: C169.1 5.67,174.44 6.07,174.83 10.64,174.83 v2(11.78,173.69) ; C169.1 5.33,174.35 5.29,174.31 LD1.1 ; C169.1 5.89,174.13 5.89,172.27 5.43,171.81 5.43,169.62 5.3,169.5 R191.2
N29961497: length 2.6
  TOP w0.097: R495.1 19.96,67.14 18.64,67.14 18.32,67.45 U18.2
N29961526: length 3.4
  TOP w0.097: U18.4 18.97,70.64 19.65,71.33 v2(19.78,71.33) 19.91,71.33 20.21,71.02 R496.2
N30237927: length 7
  TOP w0.097: R854.2 C509.2 106.46,3.01 D55.1 107.41,3.51 v1(107.79,3.89)
  BOTTOM w0.097: v1(107.79,3.89) 107.56,3.66 SWPWR2.1 SWPWR2.3
N30678816: length 0.8
  TOP w0.356: PC601.2 PR605.1
N31577862: length 3.2
  BOTTOM w0.097: R894.2 205.89,197.56 205.46,197.56 v2(205.2,197.82) 204.57,198.45 JEDP1.5
N31743879: length 1.5
  BOTTOM w0.097: U26.4 44.72,46.4 R580.2
N33040713: length 3.9
  TOP w0.097: C407.2 R791.2 ; C407.2 R152.2 v2(19.07,47.88) ; C407.2 19.15,45.98 Q52.2
N33040971: length 5.6
  TOP w0.097: v1(19.27,44.4) 19.65,44.03 Q52.6
  BOTTOM w0.097: C406.2 18.03,44.73 Q29.2 ; C406.2 18.89,44.78 v1(19.27,44.4) 19.32,44.35 R377.2 ; C406.2 18.08,45.6 v2(18.28,45.8)
N33486178: length 3.9
  TOP w0.089: v2(39.72,52.78) 39.9,52.61 R523.2
  IN03 w0.089: v2(39.72,52.78) 39.59,52.66 v2(37.43,52.66)
  BOTTOM w0.089: U5.G10 37.03,52.66 v2(37.43,52.66)
N33525072: length 3.3
  BOTTOM w0.254: PQ1409.5 PQ1409.6 v2(306.79,109.8) 307.24,109.8 PR712.2 PR3551.2
N33525121: length 4.9
  BOTTOM w0.097: PR414.2 304.06,106.71 v2(303.75,107.01) 303.75,107.27 304.06,107.57 PR416.1 304.82,107.57 305.53,108.28 306.04,108.28 306.29,108.03 PQ1409.2
N33525138: length 3
  BOTTOM w0.254: PU701.13 301.98,95.2 302.1,95.08 PR704.1 PR703.2
N33525142: length 1
  BOTTOM w0.254: PC721.1 219.17,166.02 PR717.2
N33525205:
  vias: v2(210.03,160.73)
N33525247: length 1
  TOP w0.508: PC712.1 PR714.2
N33525265: length 2.9
  TOP w0.097: v1(217.39,165.81) 217.65,166.07 PR720.2 PR722.2
  BOTTOM w0.097: PU702.2 216.96,166.24 v1(217.39,165.81)
N33525329: length 13.1
  BOTTOM w0.254: PR415.2 309.16,97.67 306.8,100.03 306.8,100.16 306.42,100.54 305.4,100.54 305.02,100.92 305.02,104.91 306.04,105.92 v2(306.04,106.51) 305.79,106.75 PQ1409.3
N33525740: length 1.3
  BOTTOM w0.508: PC3409.1 PR3404.2
N33525746: length 1.3
  BOTTOM w0.508: PC3425.1 PR3409.2
N33525779: length 5.8
  BOTTOM w0.254: PR3420.2 308.73,94.24 307.26,94.24 306.98,94.52 PR3421.1 306.06,94.82 PC3436.2 ; PR3420.2 310.15,93.68 PR3422.1 ; PR3420.2 PC3438.2
N33533058: length 0.9
  TOP w0.508: D39.2 80.46,19.76 R570.1
N33547696: length 4.3
  BOTTOM w0.097: PU1604.13 214.22,101.17 214.6,101.55 v2(215.23,101.55) 215.36,101.68 PR3449.2 PR3426.1
N33548040: length 1.3
  BOTTOM w0.508: PR3434.2 PC3515.1
N33548052: length 1.2
  BOTTOM w0.508: PC3519.1 PR3445.2
N33548085: length 3.8
  BOTTOM w0.254: PR3435.1 210.74,103.48 PC3514.2 ; PC3514.2 209.82,103.46 PR3437.1 ; PC3514.2 PR3438.2 210.71,102.44 210.66,102.39 PC3506.2
N33548178: length 11.8
  BOTTOM w0.254: PR3433.1 210.38,96.02 PR3540.1 PC3518.1 209.57,95.15 209.85,94.87 209.85,93.88 209.34,93.37 v2(209.34,92.99) 208.43,92.99 207.79,93.63 207.79,97.54 208.38,98.12 PR3431.2
N33575839: length 0.9
  BOTTOM w0.254: PC3528.1 126.18,133.25 PR3459.2
N33575872: length 1.4
  BOTTOM w0.508: PC3538.1 119.37,126.91 PR3460.2
N33575908: length 1.4
  TOP w0.356: PC3533.1 122.72,133.74 PR3462.2
N33575935: length 4.6
  BOTTOM w0.254: PR3464.2 125.16,129.72 124.63,130.25 124.63,131.49 124.35,131.77 124.35,132.69 123.9,133.13 PU1309.2
N33583518: length 30.3
  TOP w0.254: PR1449.1 PR1446.2 290.09,177.42 289.91,177.24 287.85,177.24 286.96,176.36 282.96,176.36 282.16,177.15 282.16,180.83 277.97,185.02 277.97,186.39 276.84,187.52 276.84,188.56 v1(276.96,188.67)
  BOTTOM w0.254: v1(276.96,188.67) 276.83,188.8 276.83,189.9 275.26,191.47 272.71,191.47 PH1108.1
N33583760: length 1.3
  TOP w0.254: PR1461.1 294.48,178.77 293.64,177.93 PC1429.2
N33583816: length 1.8
  TOP w0.254: PC1431.2 297.4,178.26 297.02,177.88 PR1463.1
N33583836: length 2.1
  TOP w0.097: PU1605.39 295.12,185.63 295.88,186.39 PR1467.2
N33589722: length 5.5
  TOP w0.254: 288.64,184.86 288.64,184.61 288.82,184.43 PU1605.15 ; 288.64,184.86 288.68,184.83 PU1605.14 ; 288.64,184.86 v1(288.64,185.45) 288.82,185.45 289.04,185.23 PU1605.13
  BOTTOM w0.254: PR3526.2 v1(288.64,185.45)
N33598415: length 0.8
  BOTTOM w0.356: PT1005.1 245.08,195.91 244.7,196.29
N33598431: length 1.3
  BOTTOM w0.508: PC3547.2 PR3538.1
N33598435: length 2.1
  BOTTOM w0.254: PU1606.30 244.72,201.4 245.21,201.88 PR3538.2
N33598437: length 4.1
  BOTTOM w0.254: PU1606.27 243.52,202.17 PC3547.1 244.35,202.17 244.35,201.53 244.32,201.5 PU1606.29
N33598858: length 1.7
  BOTTOM w0.254: PR3536.1 247.01,199.72 246.32,199.03 PU1606.3
N33598864: length 5.1
  BOTTOM w0.254: PU1606.7 245.12,196.63 245.89,195.86 PC3556.2
  BOTTOM w0.508: PR3539.1 247.56,194.9 246.1,194.9 245.89,195.1 PC3556.2
N33598872: length 2.6
  BOTTOM w0.254: PU1606.31 245.12,201.16 246.35,202.39 PR3534.2
N33598874: length 2
  BOTTOM w0.254: PR3533.2 246.4,200.08 246.4,199.67 246.16,199.43 PU1606.2
N33598878: length 1.5
  BOTTOM w0.254: PU1606.4 246.96,198.63 PR3535.1
N33599032: length 2.6
  BOTTOM w0.254: PC3558.1 246.27,197.51 245.95,197.83 PU1606.6
  BOTTOM w0.508: PC3558.1 247.38,197.91 PR3537.2
N33607325: length 0.9
  BOTTOM w0.254: PR3432.2 PR3541.1
N33610549: length 1
  TOP w0.254: PR3547.2 299.99,187.91 PR3468.1
N33610807: length 11.2
  TOP w0.254: PR3467.2 PC3542.1 297.23,190.66 297.53,190.96 v2(298.17,190.96) 298.8,190.96 299.13,190.63 PR3542.2 299.44,189.69 299.82,190.07 300.58,190.07 300.71,189.94 300.71,187.53 300.2,187.02 PR3466.1
N33675888: length 9.5
  TOP w0.457: PQ205.4 36.16,37.29 36.8,37.93 v1(36.8,38.18) PR237.2
  TOP w0.508: v1(35.28,32.59) 35.91,31.95 PQ201.4
  IN03 w0.508: v1(36.8,38.18) 36.8,34.12 v1(35.28,32.59)
N33675896: length 1.4
  TOP w0.508: PQ202.4 40.48,27.46 PR235.2
N33769583: length 2.3
  BOTTOM w0.254: R827.1 50.09,45.3 Q53.3 48.81,45.3 48.66,45.45 48.66,45.65 48.81,45.8 Q53.2
N33769629: length 4
  BOTTOM w0.097: Q53.5 48.08,45.8 48.48,46.21 v2(48.48,47.32) 48.2,47.32 47.49,46.61 R435.2
N34215558: length 1.6
  BOTTOM w0.097: U2015.20 67.92,84.61 R2314.2
N34263843: length 1.7
  BOTTOM w0.097: U2016.8 74.12,89.98 73.93,89.79 73.93,89.01 R2315.2
N34625001: length 5.1
  TOP w0.097: C2153.2 57.96,87.07 58.1,87.22 58.1,87.41 58,87.51 57.55,87.51 57.01,86.97 v1(56.74,86.97) 54.95,86.97 54.76,86.78 54.53,86.78 54.43,86.89 54.43,86.99 v3(54.47,87.03)
  BOTTOM w0.102: U2005.Y11 54.8,86.71 v3(54.47,87.03)
N34625004: length 5.1
  TOP w0.097: v3(53.82,87.03) 53.95,87.03 54.33,87.4 54.64,87.4 54.76,87.29 54.76,87.29 54.81,87.24 v1(55.09,87.24) 56.9,87.24 57.44,87.78 57.75,87.78 C2154.2
  BOTTOM w0.102: U2005.W11 v3(53.82,87.03)
N35183294: length 2.7
  BOTTOM w0.097: C1340.1 R1003.2 ; C1340.1 205.61,131.43 Q13.2 ; C1340.1 206.39,130.64 R1004.2
N35184706: length 2.5
  TOP w0.356: v3(243.24,133.72) 243.24,133.37 243.69,132.92 C685.1 R16.2
  BOTTOM w0.3: G2.BB30 243.14,133.72 v3(243.24,133.72)
N35211433: length 1.1
  TOP w0.097: v3(261.49,142.97) 261.66,142.79 R1022.2
  BOTTOM w0.097: v3(261.49,142.97) G2.R44
N35211439: length 2.2
  TOP w0.097: v3(262.79,142.97) 263.17,142.58 263.52,142.58 R1021.2
  BOTTOM w0.097: v3(262.79,142.97) G2.P44
N35211449: length 1.7
  TOP w0.097: R1023.1 262.17,144.35 v3(261.49,143.67)
  BOTTOM w0.11: G2.R45 v3(261.49,143.67)
N35211451: length 1
  TOP w0.097: TP118.1 262.71,143.59 v3(262.79,143.67)
  BOTTOM w0.097: v3(262.79,143.67) G2.P45
N35211455: length 12.6
  TOP w0.254: R1024.2 R1025.1 274.54,150.27 274.54,151.08 274.04,151.59 269.97,151.59 268.89,152.67 v3(268.89,152.74)
  BOTTOM w0.097: G2.E52 268.84,148.92 268.84,149.95 269.34,150.45 269.34,152.23 268.89,152.67 v3(268.89,152.74)
N35236381: length 3.3
  TOP w0.097: v2(202.84,127.89) R998.2 R996.2 202.41,129.87 202.15,129.62 Q75.5
N35237831: length 3
  TOP w0.097: R988.2 243.91,102.62 244.44,103.15 244.91,103.15 245.08,103.32 Q76.2 245.08,104.27 R989.2
N35237855: length 1.8
  TOP w0.097: Q76.5 R991.2 R992.2
N35239365: length 9.1
  TOP w0.097: R963.1 219.12,113.06 v2(219.04,112.98)
  TOP w0.356: R2158.1 220.03,115.19 R962.2 219.17,114.51 219.12,114.46 R963.1 R2157.1 ; R2158.1 R2157.1 ; R2158.1 R2159.1 R2160.1 R2161.1 ; R2157.1 R2156.1
N35242647: length 4
  TOP w0.097: U63.4 301.96,70.3 301.72,70.06 300.96,70.06 v2(300.83,70.18) 300.83,70.56 301.09,70.82 R2172.1 R2171.2
N35243502: length 1.7
  BOTTOM w0.097: TP113.1 235.17,128.98 235.38,129.19 235.81,129.19 G2.BM24
N35243504: length 5.9
  BOTTOM w0.097: G2.BM23 234.78,127.46 232.76,127.46 232.51,127.71 TP116.1 231.74,127.71 231.24,127.21 R2255.2
N35243522: length 6.2
  BOTTOM w0.097: G2.BL23 236.41,128.57 234.94,127.11 TP117.1 v2(234.03,126.6) 233.78,126.6 233.57,126.8 233.57,127.05 233.42,127.21 232.56,127.21 R2254.2
N35243524: length 11.5
  BOTTOM w0.097: G2.BK24 237.05,129.27 236.71,129.61 235.54,129.61 235.4,129.47 234.34,129.47 233.9,129.03 233.9,128.1 233.66,127.86 233.14,127.86 232.65,128.35 230.09,128.35 TP114.1 R2257.1 R2256.2
N35243532: length 7.8
  BOTTOM w0.097: G2.BL24 236.28,128.96 235.78,128.96 234.92,128.1 234.49,128.1 234.05,127.66 232.89,127.66 232.45,128.1 231.39,128.1 v2(230.98,127.69) 230.35,127.05 R1019.1
N35243651: length 5.5
  BOTTOM w0.097: G2.BK23 237.13,128.57 236.79,128.22 236.35,128.22 234.27,126.14 233.65,126.14 R1020.1
N35248107: length 2.8
  TOP w0.381: R774.1 R2219.1 247.97,169.64 248.33,170.01 C887.1
N35248159: length 1.9
  BOTTOM w0.381: R2213.2 247.12,173.14 v2(247.12,174.04) 247.12,174.32 246.99,174.45 Q81.6
N35249592: length 3.5
  TOP w0.097: v3(262.31,171.15) v2(262.99,171.15) 263.58,171.15 264.13,171.7 R874.2
  BOTTOM w0.097: U48.J1 v3(262.31,171.15)
N35249617: length 2
  TOP w0.381: C907.1 R2215.1 R2218.1
N35249695: length 1.7
  TOP w0.097: R2216.2 232.55,171.2 v3(232.63,171.12)
  BOTTOM w0.097: v3(232.63,171.12) 232.65,171.15 U2022.J1
N35260582: length 2
  TOP w0.381: R2223.1 R2221.1 C908.1
N35260616: length 1.1
  BOTTOM w0.356: R866.2 282.33,172.55 282.3,172.57 Q82.6
N35261197: length 3.1
  TOP w0.097: C1326.1 283.43,170.38 v2(283.43,170.39)
  TOP w0.381: C1326.1 R871.1 R2220.1
N35261623: length 1.7
  TOP w0.097: v3(294.1,145.56) 294.05,145.51 R859.2
  BOTTOM w0.097: U2023.J1 v3(294.1,145.56)
N35261629: length 1.6
  TOP w0.097: R2222.2 266.8,171.33 267.5,171.33 v3(267.7,171.12)
  BOTTOM w0.097: v3(267.7,171.12) 267.73,171.15 U55.J1
N35266531: length 5.8
  BOTTOM w0.381: Q83.6 301.6,124.92 v2(298.8,124.92) 298.17,124.92 297.53,125.56 R2224.2
N35267092: length 1.7
  TOP w0.097: R900.2 294.18,110.46 v3(294.23,110.51)
  BOTTOM w0.097: U2025.J1 v3(294.23,110.51)
N35267128: length 2
  TOP w0.381: R903.1 R901.1 C2425.1
N35267218: length 1.8
  TOP w0.097: v3(294.23,140.17) 294.66,140.6 R904.2
  BOTTOM w0.097: U2024.J1 v3(294.23,140.17)
N35268749: length 2
  TOP w0.381: C1353.1 R2227.1 R2226.1
N35274430: length 2
  TOP w0.381: C1373.1 R906.1 R785.1
N35274464: length 4.1
  BOTTOM w0.381: Q84.6 258.92,85.93 R909.2
N35275015: length 1.6
  TOP w0.097: R913.2 243.24,91.57 v3(243.29,91.52)
  BOTTOM w0.097: U2026.J1 v3(243.29,91.52)
N35275051: length 2
  TOP w0.381: R916.1 R914.1 C2439.1
N35275141: length 1.9
  TOP w0.097: R2228.2 273.79,92.08 v3(273.28,91.57)
  BOTTOM w0.097: U60.J1 273.23,91.52 v3(273.28,91.57)
N35284510: length 3.3
  TOP w0.097: Q85.5 289.45,173.94 R2184.2 289.71,175.16 v2(289.66,175.21) 289.53,175.21 288.89,174.58 288.89,174.58 Q85.6
N35284626:
  vias: v2(276.58,77.04)
N35284705: length 1.9
  TOP w0.097: Q85.2 286.81,173.94 C2221.1 R2186.2
N35285830: length 4.4
  BOTTOM w0.254: PU5.12 299.94,199.91 299.58,200.26 PC10.1 298.73,200.26 298.41,200.58 PR3553.2 PR29.2
N35285832: length 4.8
  BOTTOM w0.254: PU5.14 v2(302.79,202.44) 302.79,203.06 302.56,203.28 301.82,203.28 PC11.2 300.62,202.96 PR36.2
N35285834: length 6.6
  BOTTOM w0.254: PR24.2 PR3554.2 300.8,204.54 300.99,204.35 PC11.1 301.94,203.91 302.61,203.91 v2(302.74,203.79) 303.44,203.09 PU5.15
N35285836: length 3.4
  BOTTOM w0.254: PR26.2 297.92,198.87 PC10.2 299.62,198.87 300.01,199.26 PU5.11
N35285838: length 4.8
  BOTTOM w0.254: PR34.1 PR28.1 ; PR34.1 304.51,195.88 304.09,196.3 PU5.5 ; PR34.1 303.95,195.2 303.75,194.99 303.75,194.49 303.54,194.28 PR23.1
N35285847: length 2.6
  BOTTOM w0.356: PR22.2 PC9.2 306.25,197.86 306.16,197.95 PU5.4
N35285970: length 3.2
  TOP w0.097: 303.92,78.18 R2188.2 v2(303.93,79.28) ; 303.92,78.18 Q86.6 ; 303.92,78.18 303.42,77.68 Q86.5
N35286052: length 3.1
  TOP w0.097: Q86.2 C2222.1 R2189.2 v2(300.78,79.78)
N35290550: length 7.9
  BOTTOM w0.104: R2229.2 279.19,65.87 280.53,65.87 280.91,66.25 v1(282.23,66.25) 283.54,66.25 284.24,65.55 285.71,65.55 R2232.1
N35290561: length 8
  BOTTOM w0.104: R2107.1 285.71,65.29 284.13,65.29 283.43,65.99 281.02,65.99 280.64,65.61 v1(280.26,65.61) 279.19,65.61 R2106.2
N35290569: length 7.9
  BOTTOM w0.104: R2233.2 279.19,63.84 v1(280.1,63.84) 280.51,63.84 281.02,63.33 283.32,63.33 283.77,63.77 285.71,63.77 R2230.1
N35290577: length 7.9
  BOTTOM w0.104: R2110.2 279.19,63.58 280.4,63.58 280.91,63.07 v1(282.17,63.07) 283.43,63.07 283.88,63.51 285.71,63.51 R2231.1
N35291020: length 3.7
  TOP w0.097: U14.16 284.04,66.65 284.31,66.92 v1(284.31,67.63)
  BOTTOM w0.097: R464.1 284.96,68.33 v2(284.96,67.64) 284.94,67.63 v1(284.31,67.63)
N35291238: length 2.3
  TOP w0.097: U14.7 281.79,62.27 R462.2
N36026252: length 4.4
  TOP w0.203: 45.35,12.23 PU301.5
  TOP w0.254: PR306.1 48.1,10.11 47.87,10.34 46.83,10.34 46.49,10.68 v2(46.49,10.85) 46.49,11.09 45.35,12.23
N36026261: length 1.2
  TOP w0.203: PU301.3 44.55,11.59
  TOP w0.381: 44.55,11.26 v2(44.55,11.38) 44.55,11.59
N36026271:
  vias: v2(45.59,19.28)
N36026291: length 3.8
  TOP w0.203: PU301.13 44.55,16.28 44.29,16.54 v2(44.29,16.74)
  TOP w0.508: v2(44.29,16.74) 44.29,17.8 PC316.1 PR312.2
N36026325: length 1.3
  TOP w0.762: PR308.2 PC309.1
N36026360: length 5.4
  TOP w0.203: PU301.1 43.75,12.23 43.53,12.02
  TOP w0.254: PR307.1 40.99,10.54 v2(41.07,10.62) 41.42,10.62 41.7,10.34 42.21,10.34 42.59,10.72 42.59,11.66 42.82,11.89 43.4,11.89 43.53,12.02
N36026424: length 1.3
  TOP w0.762: PR309.1 PC310.2
N36217862:
  vias: v2(216.25,122.76)
N36341567: length 15
  BOTTOM w0.097: G2.BK6 236.94,117.02 234.76,117.02 234.05,116.31 232.89,116.31 232.69,116.11 228.87,116.11 v2(227.68,117.3) R2252.1 226.61,117.73 226.41,117.94 224.58,117.94 R2251.2
N36341862: length 1.2
  TOP w0.097: v3(237.69,116.97) 237.66,117 R2253.1
  BOTTOM w0.097: v3(237.69,116.97) G2.BJ6
N36344834: length 3.9
  BOTTOM w0.254: PR3568.2 PR3555.2 307.62,198.8 307.56,198.87 PC3580.1 306.73,198.87 306.34,199.26 PU5.2
N36344836: length 3.1
  BOTTOM w0.254: PR3569.2 307.24,200.58 PC3580.2 306.73,200.26 306.37,199.91 PU5.1
N36354771: length 3.6
  BOTTOM w0.097: PU1607.2 208.24,122.51 208.5,122.25 208.5,120.65 PC13.1 PR38.2
N36355836: length 2.3
  BOTTOM w0.254: PU1607.5 210.1,122.51 PC3577.2 PC3578.2
N36384934: length 1.8
  BOTTOM w0.254: PR3556.2 PR3558.2 277.01,192.36 PR2261.1
N36385245: length 1.9
  BOTTOM w0.097: Q95.3 280.89,192.79 PR3561.2 PR3560.2
N36390914: length 1.8
  TOP w0.097: R808.1 C1332.1 Q88.2
N36390918: length 7.3
  TOP w0.097: C1330.1 303.67,58.25 Q87.4 302.47,58.25 302.23,58.5 302.23,59.39 302.99,60.15 302.99,60.4 303.5,60.91 303.88,60.91 304.26,61.29 v2(304.26,61.55) 304.01,61.79 Q88.6
N36391449: length 3.8
  TOP w0.097: v2(294.48,78.18) 294.28,77.98 R2262.1 C2682.1 292.45,76.91 292.83,76.53 Q97.5
N36493829: length 2
  TOP w0.097: R813.2 C1338.1 295.45,72.6 296.02,72.6
N36493854: length 1.9
  TOP w0.097: C1341.1 R1009.2 209.52,154.33 Q92.2
N36493878: length 3.8
  TOP w0.356: R1008.1 209.01,156.99 209.01,154.71 209.02,154.71 Q92.3
N36493887: length 3.2
  TOP w0.097: Q90.2 C1342.1 R1013.2 293.54,174.83 v2(293.97,174.83)
N36493900: length 1.9
  TOP w0.356: Q90.3 293.47,172.81 292.89,172.23 R1012.1
N36494579: length 3.4
  TOP w0.097: Q94.2 300.88,82.76 C2680.1 R2259.2 299.38,82.81 v2(298.67,83.52)
N36494588: length 2.5
  TOP w0.254: Q94.3 302.48,81.5 v2(302.48,81.11) R2270.1
N36494795: length 1.2
  TOP w0.356: R2264.1 206.47,126.44 205.95,125.93 Q100.3
N36494804: length 1.9
  TOP w0.097: R2266.2 C2685.1 206.65,125.43 Q100.2
N36495019: length 2.2
  TOP w0.097: v2(287.5,168.86) 287.67,169.04 R2267.1
  TOP w0.356: Q101.3 287.51,170.05 R2267.1
N36495028: length 3.2
  TOP w0.097: v2(284.58,172.04) 284.75,171.86 R2269.2 C2686.1 287.07,171.4 Q101.2
N36495768: length 1.9
  TOP w0.097: D2015.1 17.32,139.1 17.32,138.28 R565.2
N36495771: length 1.9
  TOP w0.097: D2014.1 17.6,139.15 17.6,138.36 R862.2
N36715737: length 5.5
  BOTTOM w0.097: R781.2 211.3,197.18 211.68,197.56 211.68,198.45 211.42,198.71 210.74,198.71 C888.1 210.08,198.63 209.65,198.2 v2(209.65,197.95) 209.65,197.56 209.77,197.44 Q49.2
N36820462: length 182.3
  IN05 w0.081: v1(86.93,87.09) 86.93,87.28 87.16,87.5 88.38,87.5 88.86,87.99 88.86,97.61 98.39,107.14 111.75,107.14 117.61,113.01 183.02,113.01 196.79,126.77 199.94,126.77 202.89,129.72 204.16,129.72 205.4,130.97 221.41,130.97 222.88,129.5 229.61,129.5 232.16,126.95 235.43,126.95 235.83,126.55 240.59,126.55 240.7,126.43 240.7,126.25 240.62,126.17 v3(240.39,126.17)
  BOTTOM w0.081: G2.BF20 v3(240.39,126.17) ; v1(86.93,87.09) 86.66,87.36 85.51,87.36 C2411.2
N36820464: length 182.3
  IN05 w0.081: v3(241.09,126.17) 241.09,126.39 240.69,126.79 235.94,126.79 235.53,127.2 232.26,127.2 229.71,129.75 222.98,129.75 221.52,131.21 205.3,131.21 204.06,129.97 202.79,129.97 199.84,127.02 196.68,127.02 182.92,113.25 117.51,113.25 111.64,107.39 98.29,107.39 88.62,97.71 88.62,88.09 88.27,87.75 87.14,87.75 v1(86.93,87.95)
  BOTTOM w0.081: C2165.2 85.51,87.67 86.66,87.67 v1(86.93,87.95) ; G2.BE20 v3(241.09,126.17)
