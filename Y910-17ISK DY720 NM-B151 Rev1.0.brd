# Allegro board Y910-17ISK DY720 NM-B151 Rev1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MY0: length 32.8
  IN10 w0.091: v1(60.29,51.51) 60.04,51.77 56.74,51.77 54.96,53.55 54.96,56.01 v1(55.34,56.39)
  BOTTOM w0.076: U5.M8 35.78,55.42 36.03,55.67 36.03,56.21
  BOTTOM w0.097: 36.03,56.21 36.03,56.62 36.29,56.88 36.29,57.61 36.8,58.12 47.98,58.12 49.37,56.72 52.17,56.72 52.42,56.98 54.76,56.98 v1(55.34,56.39) ; v1(60.29,51.51) 60.47,51.69 JEC1.20
MY1: length 34.8
  IN03 w0.089: 41.5,55.58 40.1,55.58 39.59,56.09 34.51,56.09 33.62,55.2 33.62,54.56 34.39,53.8 34.89,53.8 v2(35.28,53.42)
  IN03 w0.091: 41.5,55.58 52.29,55.58 52.67,55.96 55.98,55.96 56.23,56.21 57.37,56.21 v1(57.88,55.71)
  BOTTOM w0.089: U5.J7 v2(35.28,53.42)
  BOTTOM w0.097: JEC1.16 62.47,53.02 61.69,53.8 60.93,53.8 59.91,54.82 59.02,54.82 v2(58.64,55.2) 58.14,55.71 v1(57.88,55.71)
MY2: length 34.3
  IN10 w0.091: v1(63.09,51.26) 63.09,51.64 62.58,52.15 61.82,52.15 60.68,51.01 57.12,51.01 54.58,53.55 54.58,55.71 v1(53.82,56.47)
  BOTTOM w0.097: JEC1.14 63.47,51.65 v1(63.09,51.26) ; v1(53.82,56.47) 49.12,56.47 47.71,57.87 38.05,57.87 36.28,56.1 U5.N9
MY3: length 35.3
  IN10 w0.091: v1(66.26,51.3) 64.78,52.78 57.25,52.78 56.23,53.8 56.23,54.18 v1(55.47,54.94)
  BOTTOM w0.076: U5.M9 36.28,55.42 36.53,55.67 36.53,56.09
  BOTTOM w0.097: 36.53,56.09 38.06,57.62 47.33,57.62 48.74,56.21 53.31,56.21 53.56,55.96 54.45,55.96 v1(55.47,54.94) ; v1(66.26,51.3) 65.97,51.59 JEC1.9
MY4: length 31.4
  IN03 w0.089: 41.5,54.94 41.37,55.07 38.88,55.07 38.38,55.58 36.16,55.58 35.78,55.19 v2(35.78,54.94)
  IN03 w0.091: 41.5,54.94 41.63,54.82 54.33,54.82 54.96,55.45 56.1,55.45 56.36,55.2 59.28,55.2 v1(59.41,55.32)
  BOTTOM w0.089: U5.K8 v2(35.78,54.94)
  BOTTOM w0.097: JEC1.13 63.97,53.04 63.72,53.29 62.96,53.29 v2(62.33,53.93) 62.2,54.05 61.06,54.05 59.79,55.32 v1(59.41,55.32)
MY5: length 33.8
  IN03 w0.089: 41.5,55.32 39.97,55.32 39.47,55.83 34.51,55.83 33.88,55.2 33.88,54.69 34.51,54.05 35.15,54.05 v2(35.78,53.43)
  IN03 w0.091: v1(56.99,55.71) 54.83,55.71 54.81,55.73 53.08,55.73 52.67,55.32 41.5,55.32
  BOTTOM w0.089: U5.J8 v2(35.78,53.43)
  BOTTOM w0.097: v1(56.99,55.71) 57.22,55.71 57.85,55.07 57.98,55.07 58.62,54.44 59.79,54.44 60.68,53.55 61.44,53.55 61.97,53.01 JEC1.17
MY6: length 36.8
  IN10 w0.091: v1(54.07,55.3) 54.07,53.67 56.99,50.75 60.8,50.75 61.95,51.9 62.33,51.9 62.58,51.64 62.58,50.88 62.83,50.63 63.98,50.63 64.28,50.93 64.28,51.51 64.54,51.77 64.99,51.77 65.47,51.29 v1(65.47,51.26)
  BOTTOM w0.097: U5.N10 36.78,56.07 38.08,57.37 47.2,57.37 48.61,55.96 52.93,55.96 53.59,55.3 v1(54.07,55.3) ; JEC1.10 v1(65.47,51.26)
MY7: length 32.1
  IN10 w0.091: v1(63.85,51.26) 63.85,51.51 62.83,52.53 56.99,52.53 55.67,53.85 v1(55.54,53.85)
  BOTTOM w0.076: 37.03,56.06 37.03,55.67 36.78,55.42 U5.M10
  BOTTOM w0.097: 37.03,56.06 38.08,57.12 43.78,57.12 44.05,56.85 v2(45.69,56.85) 47.09,56.85 48.23,55.71 52.8,55.71 53.82,54.69 54.71,54.69 v1(55.54,53.85) ; JEC1.12 64.47,51.88 v1(63.85,51.26)
MY8: length 35.6
  IN10 w0.091: v1(54.58,51.64) 55.09,51.13 55.09,49.74 55.72,49.1 63.09,49.1 64.74,50.75 v1(64.74,51.26)
  BOTTOM w0.097: v1(54.58,51.64) 53.94,52.28 53.94,54.18 52.67,55.45 48.1,55.45 47.15,56.4 43.62,56.4 43.15,56.87 38.12,56.87 37.28,56.03 U5.N11 ; v1(64.74,51.26) 64.97,51.49 JEC1.11
MY9: length 26.4
  IN03 w0.091: v1(57.09,54.75) 56.91,54.56 56.18,54.56 56.13,54.51 55.01,54.51 54.96,54.56 40.61,54.56 40.36,54.31 38.96,54.31 37.94,55.32 36.67,55.32 v2(36.28,54.93)
  BOTTOM w0.089: U5.K9 v2(36.28,54.93)
  BOTTOM w0.097: JEC1.23 58.97,52.96 58.77,53.17 57.12,53.17 56.74,53.55 56.74,54.39 v1(57.09,54.75)
MY10: length 41.9
  BOTTOM w0.076: U5.N12 37.78,55.91 38.04,55.66 38.43,55.66
  BOTTOM w0.089: v2(41.12,56.09) 41.5,56.09
  BOTTOM w0.097: v2(41.12,56.09) 40.76,55.73 40.08,55.73 39.59,56.21 38.98,56.21 38.43,55.66 ; 41.5,56.09 41.85,55.73 46.81,55.73 47.72,54.82 51.91,54.82 52.8,53.93 52.8,51.23 52.85,51.18 55.01,51.18 55.98,52.15 55.98,56.34 56.48,56.85 59.53,56.85 61.44,54.94 62.71,54.94 63.6,54.05 67.15,54.05 67.79,53.42 68.17,53.42 68.47,53.11 JEC1.4
MY11: length 40.2
  IN10 w0.091: v1(68.04,51.26) 68.04,51.01 66.64,49.61 66.39,49.61 63.98,47.2 63.98,46.82 63.6,46.43 57.25,46.43 53.31,50.37 v1(53.31,51.64)
  BOTTOM w0.097: JEC1.5 67.97,51.33 v1(68.04,51.26) ; U5.N13 38.32,55.91 39,56.59 42.9,56.59 43.4,56.09 46.96,56.09 47.98,55.07 52.55,55.07 53.31,54.31 v1(53.31,51.64)
MY12: length 37
  IN10 w0.091: v1(67.03,51.26) 64.49,48.72 55.6,48.72 54.58,49.74 v1(54.58,50.75)
  BOTTOM w0.097: JEC1.8 66.47,51.81 v1(67.03,51.26) ; v1(54.58,50.75) 53.97,50.75 53.72,50.5 52.87,50.5 52.42,50.94 52.42,53.8 51.66,54.56 46.96,54.56 46.02,55.5 39.92,55.5 39.46,55.97 39.08,55.97 38.53,55.41 U5.M13
MY13: length 40
  BOTTOM w0.076: 38.58,54.66 38.04,54.66 37.78,54.91 U5.L12
  BOTTOM w0.097: JEC1.7 66.97,53.22 66.64,53.55 63.34,53.55 62.45,54.44 61.06,54.44 59.28,56.21 56.74,56.21 56.48,55.96 56.48,51.72 54.63,49.86 52.04,49.86 51.15,50.75 51.15,53.04 50.77,53.42 v2(48.36,53.42) 47.34,53.42 45.73,55.03 39.92,55.03 39.54,54.66 38.58,54.66
MY14: length 40.5
  BOTTOM w0.097: U5.L13 39.42,54.91 39.78,55.27 45.87,55.27 47.09,54.05 v2(50.39,54.05) 51.66,54.05 52.17,53.55 52.17,50.75 52.8,50.12 54.55,50.12 56.23,51.79 56.23,56.21 56.48,56.47 59.53,56.47 61.31,54.69 62.58,54.69 63.47,53.8 67.03,53.8 67.41,53.42 67.41,52.58 JEC1.6
MY15: length 39.4
  IN10 w0.091: v1(50.64,51.9) 50.64,51.01 55.72,45.93 63.6,45.93 64.23,46.56 64.23,47.07 66.14,48.97 66.69,48.97 v1(68.97,51.26)
  BOTTOM w0.076: 38.58,54.16 38.04,54.16 37.78,54.41 U5.K12
  BOTTOM w0.097: 38.58,54.16 40.05,54.16 40.6,54.7 45.67,54.7 47.98,52.4 50.13,52.4 v1(50.64,51.9) ; JEC1.3 v1(68.97,51.26)
NBSWON_N: length 384.9
  TOP w0.097: v1(32.48,46.18) 32.23,45.93 R250.2 ; R854.1 104.62,2.04 104.41,2.24 v1(103.22,2.24)
  IN03 w0.091: v1(32.48,46.18) 31.97,45.67 29.56,45.67 28.16,44.28 28.16,25.86 27.4,25.1 27.4,19 28.16,18.24 28.16,5.89 28.89,5.16 28.93,5.16 31.08,3 52.55,3 54.96,5.41 59.28,5.41 61.06,3.64 67.28,3.64 67.66,4.02 69.57,4.02 70.71,2.87 79.58,2.87 80.39,3.68 80.82,3.68 81.25,3.25 85.44,3.25 85.69,3.51 88.11,3.51 88.87,2.75 97.12,2.75 97.63,2.24 v1(103.22,2.24)
  IN05 w0.091: v1(103.22,2.24) 108.05,2.24 113.25,7.45 113.25,26.59 114.35,27.69 114.98,28.32 120.77,28.32 120.77,42.27 122.02,43.51 193.39,43.51 195.04,45.16 195.04,45.67 195.3,45.93 212.53,45.93 212.78,45.67 214.43,45.67 215.26,44.84 224.44,44.84 225.16,44.12 228.81,44.12 229.36,43.57 233.68,43.57 235.96,41.29 250.22,41.29 254.68,45.74 266.36,45.74 266.92,46.31 268.45,46.31 269.08,45.67 269.08,44.24 270.53,42.79 273.22,42.79 275,44.57 277.27,44.57 279.04,42.79 287.38,42.79 288.2,41.96 293.6,41.96 295.98,39.58 297.53,39.58 301.07,36.04 301.07,35.78 302.86,33.99 v1(302.86,32.97)
  BOTTOM w0.076: 33.52,49.23 33.52,50.15 33.77,50.4 U5.B4
  BOTTOM w0.097: 33.52,49.23 33.37,49.08 33.37,48.18 32.86,47.67 32.86,46.56 v1(32.48,46.18) ; JIO1.50 301.56,33.32 301.72,33.48 302.36,33.48 v1(302.86,32.97)
NOVO_BTN_N: length 312.5
  IN05 w0.091: v1(255.22,43.13) 255.88,43.79 257.83,43.79 258.52,44.48 263.42,44.48 264.01,45.07 267.53,45.07 270.32,42.28 273.43,42.28 275.21,44.06 277.05,44.06 278.83,42.28 287.21,42.28 287.99,41.51 293.44,41.51 295.87,39.07 297.28,39.07 300.58,35.77 300.58,33.73 301.34,32.97 v1(302.1,32.97) ; v1(33.62,42.88) 33.71,42.96 44.59,42.96 45.05,42.5 49.05,42.5 51.64,39.9 51.64,35.47 56.88,30.23 57.32,30.23 58.28,29.27 63.49,29.27 64.99,27.77 71.23,27.77 74.05,30.58 83.54,30.58 83.77,30.81 93.09,30.81 93.73,31.45 98.01,31.45 99.72,33.16 111.21,33.16 111.55,33.49 114.67,33.49 v1(115.06,33.1)
  IN08 w0.091: v1(115.06,33.1) 114.65,33.51 114.65,36.66 113.89,37.42 113.89,42.21 119.28,47.6 168.98,47.6 170.78,45.8 190.6,45.8 193.46,42.93 199.67,42.93 202.66,45.93 213.2,45.93 216.41,42.72 222.69,42.72 223.74,43.77 235.43,43.77 235.94,43.26 252.57,43.26 252.83,43.51 254.84,43.51 v1(255.22,43.13)
  BOTTOM w0.097: JIO1.51 302.05,32.92 v1(302.1,32.97) ; v1(33.62,42.88) 33.62,43.16 34.08,43.61 34.08,45.17 R249.2 R265.2
NOVO_BTN_N_R: length 2.8
  BOTTOM w0.089: v2(34.13,48.59) 34.09,48.56 34.09,48.25 33.62,47.78 R265.1
  BOTTOM w0.097: U5.A5 34.27,48.74 v2(34.13,48.59)
NVVDD_PSI: length 268.9
  TOP w0.097: PR3528.1 PR820.2 298.98,185.25 299.52,184.71 v1(299.56,184.71)
  IN05 w0.091: v1(242.89,111.33) 242.27,111.33 241.43,110.5 241.43,109.07 241.27,108.9 241.27,106.12 239.79,104.65 239.79,90.3 239.49,90 224.25,90 222.6,88.34 216.12,88.34 215.11,89.36 v1(214.6,89.36) ; v1(299.56,184.71) 299.69,184.59 299.69,183.09 299.31,182.71 299.31,181.31 300.71,179.91 300.71,176.61 306.42,170.89 306.42,122.51 305.53,121.62 305.53,110.44 304.86,109.77 304.86,108.74 302.79,106.67 302.79,104.27 303.98,103.08 306.04,103.08 307.34,101.77 307.34,94.12 306.65,93.42 306.17,93.42 304.79,92.05 304.79,91.5 304.26,90.97 304.26,82.63 304.39,82.5 304.39,81.87 v1(304.9,81.36)
  IN10 w0.091: v1(242.89,111.33) 242.89,110.99 242.92,110.95 242.92,101.81 239.87,98.76 239.87,90.38 239.24,89.74 239.24,84.41 242.29,81.36 249.91,81.36 250.26,81 266.95,81 267.18,81.23 277.09,81.23 277.46,80.86 296.5,80.86 297.91,79.45 301.09,79.45 302.23,80.6 304.13,80.6 v1(304.9,81.36)
  BOTTOM w0.097: v1(214.6,89.36) 214.47,89.49 v2(214.47,90.25) 214.8,90.58 PR3570.2 ; v1(242.89,111.33) 243.3,111.33 244.19,110.44 R977.2 ; G2.BD2 241.49,113.66 241.65,113.49
  BOTTOM w0.1: v1(242.89,111.33) 242.29,111.33 241.81,111.81 241.81,113.33 241.65,113.49
NVVDD_PWM_VID: length 215.4
  TOP w0.097: PR1467.1 297.91,186.39 v1(298.04,186.26)
  IN05 w0.091: v1(303.88,81.99) 303.88,82.35 304.01,82.47 304.01,91.03 304.51,91.53 304.51,92.15 306.04,93.68 306.59,93.68 307.13,94.21 307.13,99.83 306.29,100.66 305.28,100.66 305.02,100.92 305.02,101.68 302.57,104.13 302.57,106.78 304.55,108.76 304.55,109.97 305.28,110.7 305.28,121.75 306.04,122.51 306.04,162.11 303.88,164.27 303.88,172.93 297.28,179.53 297.28,185.5 v1(298.04,186.26)
  IN10 w0.091: v1(303.88,81.99) 303.25,81.36 297.91,81.36 297.82,81.45 277.72,81.45 277.43,81.74 266.8,81.74 266.51,81.45 250.92,81.45 250.29,82.08 242.65,82.08 240.63,84.1 240.63,98.52 243.67,101.56 243.67,110.31 243.94,110.57 243.94,115.52 242.49,116.97 v3(241.79,116.97)
  BOTTOM w0.097: v3(241.79,116.97) G2.BD6
NVVDDS_B+:
  vias: v1(225.01,89.11) v1(225.65,89.11) v1(228.57,89.11) v1(229.2,89.11) v1(229.84,89.11) v1(234.28,88.98) v1(235.05,88.98) v1(235.81,88.98) v1(236.57,88.98) v2(222.6,88.34)
NVVDDS_BS1: length 2.2
  BOTTOM w0.254: 215.49,96.47 215.23,96.47 215.02,96.69 PU1604.1
  BOTTOM w0.508: PR3434.1 216.25,96.09 215.87,96.47 215.49,96.47
NVVDDS_BS2: length 3.3
  BOTTOM w0.254: 215.54,100.71 215.02,100.19 PU1604.15
  BOTTOM w0.508: 215.54,100.71 215.67,100.71 216.96,102.01 PR3445.1
NVVDDS_COMP: length 3.6
  BOTTOM w0.254: PR3446.1 PR3444.1 213.53,102.57 213.53,102.31 213.79,102.06 PC3516.1 213.82,101.65 PU1604.12
NVVDDS_EN_R: length 2.7
  BOTTOM w0.097: PR3550.1 PC3505.1 PU1604.3
NVVDDS_FB: length 8.3
  BOTTOM w0.254: 212.16,102.62 PC3571.2 212.69,101.86 PC3516.2 212.87,101.37 213.42,100.83 PU1604.11 ; 212.16,102.62 212.11,102.57 PR3438.1 ; 212.16,102.62 212.16,103.94 212.52,104.3 PR3441.1 213.05,104.4 PR3573.2 213.48,104.85 213.05,105.29 PR3579.2
NVVDDS_FBRTN: length 3.8
  BOTTOM w0.254: PU1604.10 212.53,99.3 212.31,99.52 212.31,99.88 211.55,100.64 PR3448.1 PC3506.1 PR3436.1
NVVDDS_FS: length 1.3
  BOTTOM w0.254: PR3440.2 211.64,99.52 212.26,98.9 PU1604.9
NVVDDS_HG1: length 28.2
  TOP w0.508: PR3591.1 232.06,89.42 v1(232.38,89.11)
  IN08 w0.508: v1(214.73,96.09) 216.63,94.19 216.63,88.73 218.28,87.07 230.86,87.07 232.38,88.6 v1(232.38,89.11)
  BOTTOM w0.254: PU1604.2 214.62,96.2 v1(214.73,96.09)
NVVDDS_HG1_R: length 2.2
  TOP w0.635: v1(233.4,89.18) 233.46,89.25 PR3591.2
  BOTTOM w0.635: PQ1411.3 v1(233.4,89.18)
NVVDDS_HG2: length 18
  IN08 w0.508: v1(220.7,89.11) 220.7,89.46 219.3,90.86 219.3,96.73 218.16,97.87 218.16,100.16 217.27,101.04 215.03,101.04 v1(214.9,100.92)
  BOTTOM w0.254: v1(214.9,100.92) 214.62,100.63 PU1604.14
  BOTTOM w0.635: PR3592.1 220.7,88.64 v1(220.7,89.11)
NVVDDS_HG2_R: length 2.1
  BOTTOM w0.635: PR3592.2 221.55,89.4 221.23,89.72 PQ1412.3
NVVDDS_LG1: length 16.5
  TOP w0.508: PR3593.1 v1(229.65,95.2)
  IN05 w0.508: v1(216.63,98) 218.03,96.6 229.08,96.6 229.65,96.03 v1(229.65,95.2)
  BOTTOM w0.254: PU1604.19 216.52,98.1 v1(216.63,98)
NVVDDS_LG1_R: length 2
  TOP w0.508: PR3593.2 231.05,95.14 v1(231.11,95.2)
  BOTTOM w0.508: PQ1411.5 231.39,95.48 v1(231.11,95.2)
NVVDDS_LG2: length 1.9
  BOTTOM w0.254: PU1604.17 216.27,98.9 216.63,99.27 216.76,99.27
  BOTTOM w0.635: 216.76,99.27 217.05,99.27 PR3594.1
NVVDDS_LG2_R: length 5
  BOTTOM w0.635: PR3594.2 219.32,99.55 219.96,98.91 PQ1412.5
NVVDDS_PEX_EN: length 218.8
  TOP w0.097: D2020.2 298.52,65.48 298.36,65.64 298.36,66.09 298.52,66.25 D2010.2 D2009.2 299.05,67.77 299.18,67.9 R2244.2 ; v1(212.54,153.11) 212.19,153.11 211.32,153.98 211.32,156.39 210.92,156.8 210.28,156.8 209.9,156.42 R1009.1 ; R2334.2 299.56,67.43 299.61,67.48 R2244.2 ; v1(299.56,68.66) 299.61,68.61 R2244.2 ; PR715.2 v1(219.93,162.51)
  IN08 w0.091: v1(218.79,78.95) 213.96,83.77 v1(213.96,85.42) 212.88,86.51 212.88,93.93 211.77,95.03 211.77,101.86 213.28,103.37 216.74,103.37 218.14,104.77 218.14,107.3 217.92,107.52 217.92,111.24 216.34,112.82 216.34,115.49 216.63,115.78 216.63,117.55 217.75,118.67 220.56,118.67 220.82,118.93 220.82,120.73 220.95,120.86 221.33,120.86 222.44,121.96 222.44,122.73 222.08,123.08 217,123.08 212.24,127.85 212.24,146.03 212.82,146.61 212.82,151.34 212.54,151.62 v1(212.54,153.11) 212.54,154.87 213.71,156.04 218.03,156.04 219.3,157.31 219.3,161.88 v1(219.93,162.51)
  IN10 w0.091: v1(218.79,78.95) 219.17,79.33 229.59,79.33 230.09,79.84 236.57,79.84 238.09,78.31 245.41,78.31 245.8,77.93 248.76,77.93 249.06,77.63 262.3,77.63 262.61,77.93 285.47,77.93 286.23,77.17 290.42,77.17 296.77,70.82 296.77,70.44 298.55,68.66 v1(299.56,68.66)
  BOTTOM w0.097: PR3550.2 215.25,94.24 216,93.49 v2(216,87.46) v1(213.96,85.42)
NVVDDS_PEX_EN_N: length 22.8
  TOP w0.097: Q92.5 209.52,152.99 209.39,153.11 208.88,153.11 208.5,153.5 208.5,158.07 212.06,161.62 218.19,161.62 218.41,161.4 Q104.4 ; Q92.5 Q92.6 ; Q92.5 209.52,151.64 R1010.2 209.57,151.16 209.77,150.96 211.17,150.96 v2(211.81,151.59)
NVVDDS_PSI: length 56
  TOP w0.097: v3(240.39,115.65) 241.14,114.89 243.81,114.89 244.75,115.83 R1002.2
  IN05 w0.091: v3(240.39,115.65) 240.63,115.4 240.63,114.25 240.25,113.87 239.49,113.87 239.36,113.74 239.36,111.33 238.94,110.91 238.61,110.91 235.28,107.57 235.28,104.71 234.56,103.99 220.07,103.99 217.63,101.55 211.81,101.55 211.55,101.3 211.55,97.49 215.57,93.47 v1(215.57,93.3)
  BOTTOM w0.097: G2.BE5 240.79,115.94 240.49,115.65 v3(240.39,115.65) ; v1(215.57,93.3) 215.57,92.92 PR3456.2
NVVDDS_PSI_R: length 9.1
  BOTTOM w0.097: PR3570.1 PR3456.1 213.25,92.79 v2(211.75,92.79) 211.75,94.77 212.14,95.15 PR3428.2 PR3454.2 213.33,95.46 213.82,95.95 PU1604.4
NVVDDS_PVCC: length 2.8
  BOTTOM w0.254: PU1604.18 216.5,98.5 216.55,98.56 216.76,98.56
  BOTTOM w0.356: 216.76,98.56 217.27,98.56 PC3509.1 217.32,97.37 PR3442.2
NVVDDS_PWM_VID: length 56.3
  IN05 w0.091: v1(210.41,93.55) 210.41,93.81 210.66,94.06 211.14,94.06 211.55,93.65 211.55,93.42 212.69,92.28 216.25,92.28 217.88,90.66 237.94,90.66 238.6,91.31 238.6,104.31 240.76,106.47 v1(240.76,110.57)
  BOTTOM w0.097: PR3439.1 v1(210.41,93.55)
  BOTTOM w0.1: G2.BE4 241.14,114.92 241.14,112.99 241.27,112.86 241.27,111.97 240.76,111.46 v2(240.76,111.2) v1(240.76,110.57)
NVVDDS_PWROK: length 139.5
  TOP w0.097: Q97.2 291.61,76.53 290.93,75.85 R2263.2 288.97,75.85 v1(288.89,75.77) ; D2017.2 D71.1 288.48,71.58 287.97,71.58 v1(287.62,71.23) 287.34,71.23 286.86,71.71 v2(286.86,72.22) 286.86,72.98 287.02,73.14 D2013.2
  IN03 w0.091: v1(288.89,75.77) 289.53,75.14 289.53,73.14 v1(287.62,71.23)
  IN08 w0.091: v1(287.62,71.23) 286.89,71.96 284.45,71.96 283.69,71.2 280.39,71.2 279.75,70.56 279.75,68.41 279.37,68.02 276.85,68.02 275.73,69.14 275.73,69.85 274.2,71.38 259.12,71.38 258.56,71.95 258.56,74.23 258.14,74.64 253.73,74.64 252.19,73.1 252.19,72.6 251.68,72.09 250.54,72.09 246.86,68.41 243.81,68.41 243.68,68.28 242.67,68.28 242.03,68.91 240.63,68.91 239.75,69.8 235.55,69.8 235.3,69.55 233.27,69.55 233.14,69.68 233.14,71.84 232.76,72.22 229.9,72.22 225.07,77.04 214.22,77.04 211.55,79.71 211.55,89.74 209.77,91.52 209.77,94.19 210.86,95.27 210.86,102.45 213.61,105.21 215.33,105.21 215.91,104.63 v1(216.12,104.63)
  BOTTOM w0.097: PR3426.2 216.25,103.97 216.12,104.09 v1(216.12,104.63)
NVVDDS_PWROK_N: length 37
  TOP w0.097: v1(298.55,59.39) 298.42,59.52 298.42,61.8 302.23,65.61 v2(302.23,66.5) 301.91,66.82 301.91,68.47 299.56,70.82 299.56,73.74 299.05,74.25 299.05,75.01 298.75,75.31 297.86,75.31 297.66,75.52 297.66,76.28 296.39,77.55 294.41,77.55 R2261.2 ; Q97.6 292.96,77.04 R2261.2 ; Q98.2 v1(303.37,56.47) ; Q97.3 291.7,75.76 292.2,75.26 293.09,75.26 293.85,76.03 293.85,76.99 R2261.2
  IN10 w0.091: v1(298.55,59.39) 299.82,58.12 301.72,58.12 v1(303.37,56.47)
NVVDDS_REFIN: length 5.1
  BOTTOM w0.254: PU1604.7 212.14,98.1 211.63,97.59 PC3570.1 211.63,97.16 211.4,96.93 PR3540.2 PR3432.1
NVVDDS_TGR1: length 26.4
  IN08 w0.508: v1(216.95,96.41) 217.39,95.96 217.39,89.61 218.79,88.22 230.86,88.22 231.36,88.73 v1(231.36,89.11)
  BOTTOM w0.254: PU1604.20 216.03,97.7 216.25,97.49
  BOTTOM w0.508: PC3515.2 217.52,95.84 v1(216.95,96.41) 216.5,96.85 216.5,97.23 216.25,97.49
  BOTTOM w0.635: v1(231.36,89.11) 232.13,89.87 PQ1411.4
NVVDDS_TGR2: length 15.8
  IN08 w0.508: v1(216.63,100.28) 217.27,99.65 217.27,97.49 218.54,96.22 218.54,90.53 219.68,89.39 v1(219.68,89.11)
  BOTTOM w0.254: 216.12,99.77 216.12,99.52 215.91,99.3 PU1604.16
  BOTTOM w0.508: 216.12,99.77 v1(216.63,100.28) 217.11,100.77 PC3519.2
  BOTTOM w0.635: v1(219.68,89.11) 219.96,89.39 PQ1412.4
NVVDDS_VID_R: length 4.3
  BOTTOM w0.097: PR3439.2 PC3510.1 211.86,95.71 212.95,95.71 213.42,96.18 PU1604.5
NVVDDS_VIDBUF: length 2
  BOTTOM w0.254: PU1604.6 212.53,97.7 212.44,97.62 212.44,96.98 211.81,96.35 PR3433.2
NVVDDS_VREF: length 3.9
  BOTTOM w0.254: PR3431.1 209.7,98.12 209.77,98.05 211.35,98.05 211.63,98.33 PC3507.1 211.75,98.5 PU1604.8
OC_WARN: length 247.8
  TOP w0.097: R986.2 250.92,107.52 251.71,108.31 251.71,112.73 251.43,113.01 251.07,113.01 250.92,112.86 248.65,112.86 248.39,113.11 244.83,113.11 v3(244.57,112.86)
  IN05 w0.091: v1(296.9,196.29) 297.15,196.29 297.4,196.55 297.91,196.55 301.47,192.99 301.47,183.47 301.09,183.09 301.09,181.69 302.04,180.74 302.04,176.42 307.18,171.28 307.18,122.13 306.29,121.24 306.29,112.09 307.06,111.33 307.06,108.66 305.4,107.01 304.21,107.01 303.45,106.26 303.45,104.65 304.18,103.92 306.78,103.92 308.03,102.67 308.03,93.15 306.29,91.42 306.29,84.28 v1(305.79,83.77)
  IN10 w0.091: v1(305.79,83.77) 305.15,83.14 298.17,83.14 296.92,81.89 278.08,81.89 277.72,82.25 266.67,82.25 266.31,81.89 251.23,81.89 250.6,82.52 242.96,82.52 241.14,84.33 241.14,98.14 244.19,101.19 244.19,105.49 244.74,106.04 244.74,109.85 246.48,111.59 246.48,111.97 245.59,112.86 v3(244.57,112.86)
  BOTTOM w0.097: PR31.2 298.63,194.14 298.21,194.56 PR35.2 297.43,194.87 296.9,195.41 v1(296.9,196.29)
  BOTTOM w0.1: v3(244.57,112.86) 244.44,112.73 243.56,112.73 243.24,113.05 243.24,114.92 G2.BB4
PA_USB2_RBIAS: length 2.2
  TOP w0.076: v2(49.27,82.48) 48.94,82.15 48.94,81.64 48.81,81.51
  TOP w0.178: R2046.1 48.81,81.25 48.81,81.51
  BOTTOM w0.178: v2(49.27,82.48) 48.95,82.81 U2005.H19
PB_USB2_RBIAS: length 2.3
  TOP w0.178: v2(48.62,82.48) 48.61,82.48 47.72,81.59 R2047.2
  BOTTOM w0.178: U2005.F19 48.3,82.81 v2(48.62,82.48)
PC_BEEP: length 3.7
  TOP w0.097: U7.23 288.73,29.25 288.89,29.09 288.89,28.58 287.7,27.38 C330.1
PCH_2_CPU_TRIGGER: length 226.8
  TOP w0.097: v1(173.45,53.42) 173.45,41.26 v1(173.99,40.72)
  IN08 w0.091: v1(173.45,53.42) 172.56,52.53 170.78,52.53 169.9,53.42 169.9,72.85 169.13,73.61 169.13,102.95 194.91,128.73 194.91,131.52 195.42,132.03 195.42,141.18 191.36,145.24 189.96,145.24 189.05,146.16 186.13,146.16 185.73,146.55 v1(185.72,146.55)
  IN10 w0.091: v1(173.99,40.72) 174.64,40.07 184.72,40.07 186,41.35 203.93,41.35 207.04,44.47 211.99,44.47 215.46,40.99 246.81,40.99 250.29,44.47 250.29,46.19 251.05,46.95 251.05,49.87 251.75,50.57 251.75,56.53 252.03,56.81 253,56.81 253.43,56.39 v1(253.72,56.39)
  BOTTOM w0.097: R203.1 252.83,57.23 253.67,56.39 v1(253.72,56.39)
  BOTTOM w0.102: v1(185.72,146.55) 185.34,146.93 U1.H23
PCH_2_CPU_TRIGGER_R: length 4.5
  BOTTOM w0.097: R203.2 250.72,56.72 250.41,56.72 249.83,57.3 248.72,57.3 247.77,58.25 U2.AL2
PCH_CLKRUN_N: length 8.6
  TOP w0.097: v3(238.17,49.74) 238.17,50.47 238.98,51.29 238.98,52.53 238.86,52.66 238.86,54.31 v3(238.48,54.69)
  BOTTOM w0.097: v3(238.17,49.74) 238.09,49.74 236.65,48.29 R136.2 ; U2.AW22 237.87,54.09 v3(238.48,54.69)
PCH_CS0_N: length 222.2
  TOP w0.097: R937.2 217.29,49.38 v1(217.29,48.47)
  IN03 w0.091: v1(31.59,40.34) 32.35,41.1 32.35,43.51 33.5,44.66 45.94,44.66 47.09,45.8 48.61,45.8 49.37,45.04 52.33,45.04 53.57,46.28 61.03,46.28 63.83,49.08 71.45,49.08 75.28,52.91 87.22,52.91 88.87,54.56 95.6,54.56 95.98,54.18 97,54.18 98.39,55.58 104.77,55.58 106.17,56.98 125.68,56.98 127.2,55.45 155.04,55.45 160.62,49.86 175.1,49.86 175.86,49.1 201.52,49.1 202.47,48.15 212.89,48.15 213.33,47.7 216,47.7 216.76,48.47 v1(217.29,48.47)
  IN10 w0.091: v1(217.29,48.47) 217.39,48.57 221.1,48.57 221.84,47.83 224.02,47.83 224.52,47.32 229.76,47.32 231.41,48.97 v3(231.87,48.97)
  BOTTOM w0.097: v1(31.59,40.34) 31.73,40.48 RP4.1 ; v3(231.87,48.97) 232.25,49.36 232.25,49.89 232.53,50.17 232.94,50.17 233.27,50.5 U2.BD31 ; U3.1 217.65,48.82 v1(217.29,48.47)
PCH_GPP_B23: length 1.8
  TOP w0.097: v3(234.92,55.25) 235.3,55.63 R547.2
  BOTTOM w0.097: U2.AT27 235.43,55.53 235.2,55.53 v3(234.92,55.25)
PCH_GPP_E8: length 3.9
  BOTTOM w0.097: U2.AD44 226.16,61.57 226.03,61.45 v2(223.57,61.45) 223.39,61.45 TP160.1
PCH_GPP_F6: length 4.2
  BOTTOM w0.076: 226.21,63 227.48,63 U2.AB42
  BOTTOM w0.097: 226.21,63 226.13,63.07 225.52,63.07 225.27,63.33 TP170.1
PCH_GPP_F7: length 4.1
  BOTTOM w0.076: U2.AB43 227.13,62.82 226.54,62.82 226.41,62.69
  BOTTOM w0.097: TP171.1 224.12,62.31 v2(224.38,62.56) 224.51,62.69 226.41,62.69
PCH_GPP_F8: length 1.4
  TOP w0.097: v2(231.11,61.67) v3(230.7,62.08)
  BOTTOM w0.097: v3(230.7,62.08) 230.55,62.23 U2.AB36
PCH_GPP_F9: length 1.7
  TOP w0.097: TP169.1 229.33,61.67 v3(229.71,62.06)
  BOTTOM w0.097: U2.AB39 229.03,62.74 v3(229.71,62.06)
PCH_GPP_G18: length 6.1
  BOTTOM w0.076: U2.N43 227.1,67.39 226.66,67.39 225.8,66.53
  BOTTOM w0.097: v2(223.24,67.14) 223.24,66.75 223.06,66.58 R303.1 223.31,65.87 224.28,65.87 224.94,66.53 225.8,66.53
PCH_HOLD_N: length 34.1
  TOP w0.097: R126.1 233.19,51.34 v3(233.65,50.88)
  IN10 w0.091: v3(233.65,50.88) 233.27,51.26 232.38,51.26 232,50.88 231.11,50.88 230.47,50.24 226.16,50.24 225.96,50.44 224.51,50.44 223.94,51.01 222.23,51.01 219.81,53.42 217.82,53.42 217.39,53.85 213.12,53.85 v1(212.69,53.42)
  BOTTOM w0.097: v3(233.65,50.88) 233.65,51.64 U2.BD30 ; R120.1 213.76,59.85 v2(212.67,58.75) 212.44,58.53 212.44,53.67 v1(212.69,53.42)
PCH_HOLD_N_R: length 3.7
  BOTTOM w0.097: U3.7 R118.1 R120.2 v2(214.57,58.93)
PCH_I2C_CLK0: length 80.2
  TOP w0.097: v1(264.51,25.35) 264.51,25.81 R321.1 ; v3(229.84,55.58) 229.46,55.2 228.7,55.2 227.93,54.44 223.82,54.44 R109.1
  IN08 w0.091: v1(256.64,53.55) 256.13,53.55 254.73,54.94 253.46,54.94 252.89,54.37 248.19,54.37 247.75,53.93 247.75,53.04 246.86,52.15 243.81,52.15 243.17,52.78 242.41,52.78 242.03,52.4 241.52,52.4 241.14,52.78 240.38,52.78 239.87,52.28 239.24,52.28 238.73,52.78 237.97,52.78 237.71,53.04 237.71,54.56 236.44,55.83 236.44,56.85 236.25,57.04 235.74,57.04 234.92,56.21 230.6,56.21 229.97,55.58 v3(229.84,55.58)
  IN10 w0.091: v1(256.64,53.55) 256.64,52.53 257.78,51.39 264.51,51.39 265.91,49.99 265.91,33.25 265.65,32.99 265.65,26.5 v1(264.51,25.35)
  BOTTOM w0.097: U2.AR38 229.81,55.61 v3(229.84,55.58)
PCH_I2C_CLK1: length 222.7
  TOP w0.089: v2(76.04,11.51) 76.22,11.69 76.55,11.69
  TOP w0.097: v3(228.19,55.58) 227.68,55.07 226.92,55.07 226.41,55.58 v2(226,55.58) 223.57,55.58 R106.1 ; 76.55,11.69 R879.2
  IN03 w0.091: v1(70.06,31.7) 70.96,31.7 73.38,29.29 77.44,29.29 78.46,28.27 81.25,28.27 82.16,29.18 96.76,29.18 99.2,31.62 108.71,31.62 114.79,37.7 117.54,37.7 120.14,40.3 120.14,42.51 122.11,44.48 132.86,44.48 137.89,39.45 v1(137.89,38.81)
  IN08 w0.089: 69.54,15.07 70.48,14.12 70.48,10.47 70.71,10.24 72.36,10.24 72.74,10.62 72.74,14.18 73.38,14.81 75.66,14.81 76.04,14.43 v2(76.04,11.51)
  IN08 w0.091: 69.54,15.07 69.01,15.6 69.01,24.04 70.06,25.1 v1(70.06,31.7)
  IN10 w0.091: v3(228.19,55.58) 223.85,55.58 220.89,58.54 218.19,58.54 217.27,57.61 204.32,57.61 203.68,56.98 195.57,56.98 194.84,56.24 187.45,56.24 186.02,54.82 175.53,54.82 174.64,53.93 169.92,53.93 167.63,51.64 148.36,51.64 138.53,41.81 138.53,39.45 v1(137.89,38.81)
  BOTTOM w0.097: v3(228.19,55.58) 228.29,55.68 U2.AR41
PCH_I2C_CLK2: length 248.6
  IN03 w0.091: v1(136.62,40.08) 132.47,44.24 122.21,44.24 120.36,42.39 120.36,40.21 117.63,37.48 114.88,37.48 108.77,31.37 99.35,31.37 96.94,28.96 82.32,28.96 81.38,28.02 78.2,28.02 77.19,29.04 73.23,29.04 71.05,31.22 68.4,31.22 67.03,32.59 58.39,32.59 57.75,33.23 47.47,33.23 44.8,35.89 42.77,35.89 41.93,36.73 41.93,39.02 40.48,40.47 39.34,40.47 v1(39.21,40.59)
  IN05 w0.089: 31.72,46.69 30.83,47.58 30.83,53.42 30.04,54.21 30.04,58.14 29.81,58.37
  IN05 w0.091: v3(29.56,58.63) 29.81,58.37 ; 31.72,46.69 31.72,42.88 34.9,39.69 38.31,39.69 v1(39.21,40.59)
  IN10 w0.091: v1(136.62,40.08) 136.62,41.48 147.67,52.53 167.12,52.53 169.28,54.69 174.09,54.69 174.98,55.58 185.01,55.58 186.02,56.59 186.02,57.86 186.53,58.37 216.5,58.37 218.28,60.15 219.93,60.15 220.19,59.9 223.24,59.9 224.89,58.25 v3(224.89,57.48)
  BOTTOM w0.089: 32.77,56.43 32.77,56.94 31.34,58.37
  BOTTOM w0.097: v3(29.56,58.63) 29.81,58.37 31.34,58.37 ; U2.AK44 226.9,58.61 226.16,57.86 225.27,57.86 v3(224.89,57.48) 224.51,57.1 223.82,57.1 R548.2 ; 32.77,56.43 U5.N2
PCH_I2C_DATA0: length 77.6
  TOP w0.097: v1(264.89,29.29) 265.15,29.04 265.2,29.04 R320.1
  IN08 w0.091: v1(256.64,54.31) 257.14,54.82 257.14,55.96 255.24,57.86 254.6,57.86 254.22,58.25 248.76,58.25 247.36,56.84 242.32,56.84 241.81,57.36 237.62,57.36 237.11,57.86 229.08,57.86 227.3,56.09 226.54,56.09 225.27,54.82 v3(224,54.82)
  IN10 w0.091: v1(256.64,54.31) 256.13,53.8 256.13,52.44 257.43,51.13 264.21,51.13 265.53,49.81 265.53,33.23 265.4,33.1 265.4,29.8 v1(264.89,29.29)
  BOTTOM w0.076: 226.27,55.6 226.51,55.6 226.59,55.53 227.05,55.53 227.1,55.58 227.49,55.58 U2.AT42
  BOTTOM w0.097: R111.1 223.87,54.94 v3(224,54.82) 224.12,54.94 225.61,54.94 226.27,55.6
PCH_I2C_DATA1: length 220.3
  TOP w0.097: R880.2 77.64,10.67 v3(77.44,10.87)
  IN03 w0.091: v1(137.89,40.08) 133.27,44.71 122.01,44.71 119.92,42.62 119.92,40.4 117.44,37.92 114.61,37.92 108.53,31.84 99.04,31.84 96.6,29.4 83.55,29.4 83.41,29.54 73.81,29.54 71.14,32.21 69.23,32.21 v1(68.72,31.7)
  IN08 w0.089: 76.55,10.47 76.06,10.47 75.79,10.75 75.79,11 75.66,11.13 75.66,11.64 75.79,11.76 75.79,14.33 75.56,14.56 73.88,14.56
  IN08 w0.091: 73.88,14.56 73.48,14.56 72.99,14.07 72.99,10.24 72.23,9.48 70.71,9.48 70.28,9.91 70.28,13.97 68.75,15.5 68.75,29.85 68.72,29.88 v1(68.72,31.7) ; v3(77.44,10.87) 77.04,10.47 76.97,10.47 76.55,10.47
  IN10 w0.091: v3(224,55.96) 224,56.04 223.03,57.01 223.03,58.09 221.86,59.26 220.48,59.26 220.08,58.86 218.01,58.86 217.01,57.86 204.26,57.86 203.63,57.23 195.45,57.23 194.69,56.47 186.94,56.47 185.54,55.07 175.36,55.07 174.45,54.16 169.79,54.16 167.53,51.9 148.11,51.9 138.26,42.05 137.89,41.68 v1(137.89,40.08)
  BOTTOM w0.097: R107.1 223.44,55.96 v3(224,55.96) 224.12,55.96 224.63,55.45 225.78,55.45 226.16,55.83 226.32,55.83 U2.AR44
PCH_I2C_DATA2: length 248.3
  IN03 w0.091: v1(38.32,40.59) 38.83,40.08 40.48,40.08 41.71,38.86 41.71,36.57 42.77,35.51 42.77,34.24 44.04,32.97 57.5,32.97 58.14,32.34 66.95,32.34 68.29,31 70.96,31 73.21,28.75 77.06,28.75 78.04,27.77 81.5,27.77 82.48,28.75 97.03,28.75 99.44,31.15 108.86,31.15 113.87,36.16 116.64,36.16 120.58,40.1 120.58,42.3 122.3,44.02 132.05,44.02 136.62,39.45 v1(136.62,38.81)
  IN05 w0.089: 31.97,46.69 31.97,58.63
  IN05 w0.091: v1(38.32,40.59) 37.64,39.91 35.07,39.91 31.97,43.01 31.97,46.69 ; 31.97,58.63 v1(31.97,59.13)
  IN10 w0.091: v3(224.12,57.48) 224.12,58.02 222.63,59.52 220.31,59.52 219.93,59.13 217.9,59.13 216.89,58.12 186.91,58.12 186.28,57.48 186.28,56.34 185.26,55.32 175.1,55.32 174.21,54.44 169.39,54.44 167.23,52.28 147.85,52.28 137.94,42.37 137.26,41.68 137.26,39.45 v1(136.62,38.81)
  BOTTOM w0.076: U5.M3 33.27,55.42 33.53,55.67 33.53,56.21
  BOTTOM w0.097: 33.53,56.21 33.53,57.45 33.04,57.94 32.74,57.94 32.23,58.45 32.23,58.88 v1(31.97,59.13) ; R549.2 223.87,57.94 223.87,57.74 v3(224.12,57.48) 224.25,57.48 225.14,58.37 226.08,58.37 U2.AK45
PCH_INTRUDER_N: length 3.5
  TOP w0.097: R114.2 242.29,49.1 242.79,49.61 v3(242.79,49.86)
  BOTTOM w0.097: v3(242.79,49.86) 242.62,50.03 242.62,51.01 242.95,51.34 U2.BE11
PCH_ITP_PMODE: length 24.3
  TOP w0.097: v2(255.75,60.91) 256.51,60.91 v1(256.64,61.04) 256.94,61.34 R596.2 ; v3(249.91,53.42) 249.91,53.67 TP61.1
  IN08 w0.091: v3(249.91,53.42) 250.34,52.99 254.53,52.99 255.11,52.4 257.02,52.4 258.41,53.8 258.41,59.01 258.03,59.39 256.89,59.39 256.64,59.64 v1(256.64,61.04)
  BOTTOM w0.097: U2.AT2 247.49,55.46 248,54.94 248.76,54.94 249.91,53.8 v3(249.91,53.42)
PCH_JTAG_TCK: length 3.3
  TOP w0.097: v1(249.52,56.47) 249.91,56.09 v2(250.03,56.09)
  BOTTOM w0.097: v1(249.52,56.47) 249.32,56.47 248.95,56.84 247.63,56.84 247.32,57.15 U2.AN3
PCH_JTAG_TDI: length 4.8
  TOP w0.097: R306.1 250.79,54.31 250.54,54.56 v2(250.16,54.56) 249.78,54.94 v1(249.78,55.2)
  BOTTOM w0.097: v1(249.78,55.2) 249.78,55.22 248.76,56.24 247.86,56.24 U2.AP2
PCH_JTAG_TDO: length 3.9
  TOP w0.097: R507.1 v1(250.54,55.2)
  BOTTOM w0.097: U2.AP1 248.82,56.59 249.45,55.96 250.03,55.96 250.54,55.45 v1(250.54,55.2)
PCH_JTAG_TMS: length 5.8
  BOTTOM w0.076: U2.AR2 248.67,55.97 249.37,55.27
  BOTTOM w0.097: 249.37,55.27 249.37,54.97 250.03,54.31 250.36,54.31 v2(251.23,53.45) R216.1
PCH_JTAGX: length 2.7
  TOP w0.097: R220.1 248.18,56.19 v2(248.13,56.14) 247.82,56.44 v3(247.07,56.44)
  BOTTOM w0.097: v3(247.07,56.44) 247.07,56 U2.AR3
PCH_LAN_WAKE_N: length 4
  BOTTOM w0.097: U2.BD11 242.98,51.77 242.42,51.22 242.42,50.23 242.29,50.09 242.29,49.36 241.9,48.97 R288.1
PCH_PECI: length 5.2
  BOTTOM w0.097: U2.AL3 247.11,58.25 247.37,57.99 247.59,57.99 247.74,57.84 247.74,57.51 248.15,57.1 249.65,57.1 250.54,56.21 R174.1
PCH_PLTRST_N: length 244.8
  TOP w0.097: R117.1 248.51,46.56 248.76,46.82 v1(248.76,47.45)
  IN03 w0.091: v1(46.45,37.04) 46.45,36.02 47.85,34.62 58.39,34.62 59.15,33.86 71.29,33.86 73.92,31.23 86.18,31.23 88.05,33.1 95.71,33.1 96.4,33.79 107.43,33.79 119.64,45.99 137.95,45.99 145.26,38.69 v1(149.58,38.69)
  IN05 w0.091: v1(248.76,47.45) 247.87,48.34 243.43,48.34 242.03,46.94 242.03,45.67 241.27,44.91 238.65,44.91 238.02,45.55 238.02,45.88 237.21,46.69 v1(237.21,46.74) 237.21,46.82 235.43,48.59 235.43,52.53 v3(234.92,53.04)
  IN10 w0.091: v1(149.58,38.69) 150.34,39.45 150.34,40.52 153.84,44.02 202.41,44.02 205.9,47.51 214.15,47.51 216.63,45.04 225.01,45.04 225.56,44.49 234.96,44.49 v1(237.21,46.74)
  BOTTOM w0.097: R835.2 v2(50.98,38.7) 50.59,38.31 47.59,38.31 46.45,37.16 v1(46.45,37.04) ; U2.BB27 235.15,53.04 v3(234.92,53.04) ; v1(248.76,47.45) 249.27,46.94 C180.1 248.92,46.64 248.76,46.8 U4.1 247.73,46.8 247.62,46.69 247.62,46.31 247.75,46.18 248.2,46.18 U4.2
PCH_PWRBTN_N: length 268.9
  TOP w0.097: R381.2 220.19,51.39 v1(219.93,51.64) ; v1(27.02,57.48) 26.89,57.36 TP58.1
  IN05 w0.089: 30.2,46.69 30.2,52.4 29.81,52.78
  IN05 w0.091: v1(27.02,57.48) 27.02,57.23 28.54,55.71 28.54,54.05 29.81,52.78 ; 30.2,46.69 30.2,46.43 29.69,45.93 29.43,45.93 28.93,45.42 28.93,42.36 29.55,41.74 30.07,41.74 30.32,41.99 31.85,41.99 34.64,39.2 38.58,39.2 39.2,39.82 39.46,39.82 40.36,40.72 46.58,40.72 48.86,38.43 49.12,38.43 49.75,37.8 49.75,33.99 55.23,28.51 56.34,28.51 57.25,27.6 62.54,27.6 64.16,25.99 71.9,25.99 74.31,28.4 82.14,28.4 82.64,28.9 93.76,28.9 94.75,29.89 97.72,29.89 99.62,31.78 110.77,31.78 111.38,32.39 118.28,32.39 v1(118.71,31.96)
  IN08 w0.091: v1(118.71,31.96) 121.13,34.37 121.13,41.23 122.93,43.03 140.03,43.03 v1(142.97,40.08)
  IN10 w0.091: v1(142.97,40.08) 142.97,42.55 149.91,49.48 170.4,49.48 171.29,50.37 175.23,50.37 176.25,51.39 178.15,51.39 178.66,50.88 178.66,50.63 178.91,50.37 196.18,50.37 198.6,52.78 217.27,52.78 217.33,52.85 219.11,52.85 219.93,52.02 v1(219.93,51.64) 220.95,50.63 223.87,50.63 224.25,50.24 225.65,50.24 225.9,49.99 230.6,49.99 231.11,50.5 235.3,50.5 236.44,51.64 238.86,51.64 239.29,52.08 239.67,52.08 240.51,52.91 241.02,52.91 241.4,53.29 241.4,55.58 v3(241.78,55.96)
  BOTTOM w0.097: v3(241.78,55.96) 242.04,55.96 U2.AT13 ; D3.2 v1(27.02,57.48)
PCH_PWRBTN_N_R: length 6
  BOTTOM w0.076: 32.16,55.67 32.52,55.67 U5.M2
  BOTTOM w0.089: 29.81,57.74 29.94,57.86 30.96,57.86 31.85,56.98 31.85,55.98 32.16,55.67
  BOTTOM w0.097: D3.1 29.56,57.48 v2(29.69,57.61) 29.81,57.74
PCH_RTC_X1: length 8.7
  BOTTOM w0.076: 243.56,50.93 243.78,51.16 243.78,51.54 243.89,51.64 243.89,52.1 244.12,52.33 U2.BC9
  BOTTOM w0.097: Y1.1 244.49,44.98 C205.2 244.52,45.95 R192.2 244.19,47.15 244.19,47.96 243.73,48.42 243.73,49.18 243.89,49.34 243.89,50.26 243.56,50.59 243.56,50.93
PCH_RTC_X2: length 7.8
  BOTTOM w0.076: U2.BD10 243.59,51.7 243.59,51.24 243.35,51.01
  BOTTOM w0.097: 243.35,51.01 243.35,50.51 243.68,50.18 243.68,49.42 243.53,49.27 243.53,48.29 243.91,47.9 243.91,47.12 R192.1 243.61,45.95 C208.2 243.63,44.98 Y1.2
PCH_SCK: length 24
  TOP w0.097: R122.1 v1(214.73,51.13) R938.2
  IN10 w0.091: v3(231.87,49.74) 231.24,49.74 230.86,49.36 229.59,49.36 229.33,49.1 221.71,49.1 221.33,49.48 220.19,49.48 217.52,52.15 215.74,52.15 v1(214.73,51.13)
  BOTTOM w0.076: U2.BC31 233.01,52.04 233.01,51.51
  BOTTOM w0.097: 233.01,51.51 233.06,51.46 233.06,50.68 232.76,50.37 232.36,50.37 231.87,49.88 v3(231.87,49.74)
PCH_SCK_R: length 205.1
  TOP w0.097: v1(214.47,53.42) 214.73,53.17 R122.2
  IN03 w0.089: 34.39,46.69 35.4,46.69 38.03,49.31
  IN03 w0.091: v1(30.7,41.23) 31.13,41.66 31.13,43.44 34.39,46.69 ; 38.03,49.31 38.47,49.31 39.98,47.8 39.98,47.8 40.32,47.46 43.67,47.46 43.92,47.21 46.33,47.21 46.82,47.7 60.81,47.7 63.06,49.95 70.8,49.95 74.9,54.05 86.73,54.05 89.5,56.82 104.41,56.82 105.58,57.99 126.21,57.99 127.73,56.47 155.65,56.47 161.24,50.88 175.59,50.88 176.35,50.12 182.01,50.12 182.69,50.8 199.52,50.8 201.37,52.66 213.71,52.66 v1(214.47,53.42)
  BOTTOM w0.097: v1(214.47,53.42) 215.11,54.05 U3.6 ; RP4.4 32.09,41.98 31.97,41.86 31.34,41.86 v1(30.7,41.23)
PCH_SI: length 30.9
  TOP w0.097: R593.2 R124.1 v1(213.58,51.13) R931.2 ; R125.1 233.32,49.66 v3(232.63,48.97)
  IN10 w0.091: v3(232.63,48.97) 232.25,49.36 231.36,49.36 229.71,47.7 224.63,47.7 224.25,48.09 221.97,48.09 221.2,48.85 219.3,48.85 216.59,51.56 215.91,51.56 214.98,50.63 214.09,50.63 v1(213.58,51.13)
  BOTTOM w0.076: 234.13,50.42 234.26,50.55 234.26,51.41 234.13,51.54 234.13,52.33 234.42,52.62 U2.BB29
  BOTTOM w0.097: 234.13,50.42 233.8,50.09 233.57,50.09 232.63,49.15 v3(232.63,48.97)
PCH_SI_R: length 206.8
  TOP w0.097: v1(213.58,53.42) R124.2
  IN03 w0.091: v1(30.7,40.34) 30.2,40.85 30.2,41.48 30.7,41.99 30.7,43.51 34.26,47.07 35.4,47.07 37.94,49.61 38.7,49.61 39.85,48.47 40.48,48.47 41.27,47.68 43.76,47.68 43.99,47.45 46.2,47.45 46.71,47.96 59.66,47.96 62.58,50.88 62.58,52.15 63.72,53.29 70.96,53.29 72.74,55.07 76.17,55.07 76.68,54.56 86.77,54.56 89.25,57.04 104.32,57.04 105.65,58.37 126.25,58.37 127.9,56.72 155.75,56.72 161.34,51.13 175.69,51.13 176.46,50.37 181.9,50.37 182.59,51.06 199.41,51.06 201.26,52.91 213.08,52.91 v1(213.58,53.42)
  BOTTOM w0.097: v1(213.58,53.42) 213.84,53.67 U3.5 ; v1(30.7,40.34) 31.13,40.77 32.02,40.77 32.23,40.98 RP4.2
PCH_SMB_CLK: length 120.9
  TOP w0.097: v1(272.51,19.76) 272.38,19.89 R573.1
  IN05 w0.091: v1(272.51,19.76) 272.08,19.34 270.65,19.34 269.03,20.96 269.03,23.19 268.64,23.57 268.45,23.57 265.4,26.62 265.4,33.99 263.75,35.64 263.75,40.18 262.5,41.43 259.63,41.43 257.91,39.71 257.84,39.71 257.74,39.61 254.26,39.61 253.02,40.85 235.78,40.85 233.5,43.14 229.18,43.14 228.81,43.5 228.63,43.69 224.98,43.69 224.26,44.41 215.08,44.41 214.29,45.2 197.2,45.2 197,44.99 196.64,44.99 196.43,45.2 196.02,45.2 v1(195.8,45.42)
  IN08 w0.091: v1(195.8,45.42) 196.57,46.18 196.57,48.79 193.64,51.71 193.64,56.72 v1(193.14,57.23)
  BOTTOM w0.097: Q1.1 193.32,54.11 R162.2 191.13,54.11 190.93,54.31 190.93,57.43 191.49,57.99 TP64.1 193.06,57.99 R81.1 v1(193.14,57.23)
PCH_SMB_DAT: length 113.6
  TOP w0.097: v1(271.24,19.76) 271.5,20.02 R572.1
  IN05 w0.091: v1(196.82,45.42) 214.38,45.42 215.17,44.63 224.35,44.63 225.07,43.9 228.72,43.9 228.85,43.78 229.27,43.36 233.59,43.36 235.87,41.07 253.11,41.07 254.35,39.83 257.65,39.83 259.63,41.81 262.5,41.81 264.13,40.18 264.13,35.77 265.65,34.24 265.65,27.13 269.44,23.35 269.44,21.19 270.86,19.76 v1(271.24,19.76)
  IN08 w0.091: v1(196.82,45.42) 196.82,48.85 193.9,51.77 193.9,56.72 v1(194.41,57.23)
  BOTTOM w0.097: Q1.4 195.18,55.19 195.22,55.15 R161.2 195.68,55.96 195.3,56.34 194.66,56.34 TP63.1 v1(194.41,57.23) R82.1
PCH_SO: length 26
  TOP w0.097: R119.2 v1(216.38,51.13) R936.2
  IN10 w0.091: v3(232.63,49.74) 233.01,49.36 233.01,48.59 232.89,48.47 232.25,48.47 232.13,48.34 232.13,48.09 231.11,47.07 224.51,47.07 224,47.58 221.58,47.58 220.82,48.34 218.79,48.34 218.41,47.96 217.14,47.96 216.76,48.34 216.76,50.75 v1(216.38,51.13)
  BOTTOM w0.097: v3(232.63,49.74) 232.86,49.74 233.5,50.37 233.7,50.37 234.03,50.7 234.03,51.22 U2.BE30
PCH_SO_R: length 201.8
  TOP w0.097: R119.1 216.38,48.72 v1(216.12,48.47)
  IN03 w0.091: v1(216.12,48.47) 215.62,47.96 213.46,47.96 212.95,48.47 202.53,48.47 201.64,49.36 176.03,49.36 175.28,50.12 160.88,50.12 155.29,55.71 127.31,55.71 125.79,57.23 105.98,57.23 104.71,55.96 98.14,55.96 96.74,54.56 96.11,54.56 95.14,55.53 89.47,55.53 87.11,53.17 75.15,53.17 71.29,49.3 63.67,49.3 60.87,46.5 53.48,46.5 52.27,45.29 49.88,45.29 49.15,46.02 46.99,46.02 46.58,46.43 46.07,46.43 45.01,45.37 33.58,45.37 31.59,43.39 v1(31.59,41.35)
  BOTTOM w0.097: RP4.3 31.71,41.48 v1(31.59,41.35) ; U3.2 216.38,48.72 v1(216.12,48.47)
PCH_THERMTRIP_N: length 4.7
  TOP w0.097: R287.1 v1(250.54,59.26)
  BOTTOM w0.076: 248.92,58.63 248.26,59.29 247.47,59.29 247.33,59.43 U2.AJ3
  BOTTOM w0.097: 248.92,58.63 249.91,58.63 v1(250.54,59.26)
PCH_TRST_N: length 7.6
  TOP w0.097: v3(245.87,54.11) 246.42,54.11 247.75,52.78 249.27,52.78 v2(249.4,52.66) 249.91,52.15 v3(249.91,51.64)
  BOTTOM w0.097: v3(245.87,54.11) 245.87,53.69 U2.AY5 ; v3(249.91,51.64) 250.79,50.75 R202.1
PCH_UART2_CTS_N: length 4.5
  BOTTOM w0.097: R535.2 223.69,56.34 v2(224.53,56.34) 225.9,56.34 226.28,56.72 227.05,56.72 227.32,56.99 U2.AN43
PCH_UART2_RTS_N: length 2
  TOP w0.097: R536.2 225.83,56.9 v3(225.65,56.72)
  BOTTOM w0.097: U2.AN44 226.08,57.03 225.78,56.72 v3(225.65,56.72)
PCH_UART2_RXD: length 12.4
  TOP w0.097: R266.2 223.69,56.34 224.25,56.34 224.63,55.96 v3(224.89,55.96)
  IN08 w0.091: v3(224.89,55.96) 224.51,56.34 222.35,56.34 221.97,56.72 220.82,56.72 v1(218.54,54.44)
  BOTTOM w0.097: v3(224.89,55.96) 225.9,55.96 226.03,56.09 226.07,56.09 U2.AR45 ; TP17.1 218.92,54.82 v1(218.54,54.44)
PCH_UART2_TXD: length 13.8
  TOP w0.097: v3(228.95,55.58) 228.49,56.04 227.88,56.04 227.73,55.88 R534.2 226.74,55.88 226.28,56.34 224.63,56.34 224.25,56.72 v3(224.12,56.72)
  IN08 w0.091: v1(218.54,57.48) 219.3,56.72 220.19,56.72 220.57,57.1 222.22,57.1 222.6,56.72 v3(224.12,56.72)
  BOTTOM w0.097: TP16.1 219.55,56.47 v1(218.54,57.48) ; U2.AR39 229.05,55.68 v3(228.95,55.58)
PCH_VRALERT_N: length 4.6
  BOTTOM w0.076: U2.BD23 237.3,51.93 237.79,51.44
  BOTTOM w0.097: 237.79,51.44 237.79,50.19 237.87,50.12 238.35,50.12 238.55,49.91 238.55,49.46 v2(238.59,49.42) 238.59,48.53 R137.1
PCH_WP_N: length 24.7
  TOP w0.097: v3(232.63,48.09) 232.76,47.96 R594.2
  IN10 w0.091: v1(216.71,47.58) 216.94,47.35 223.72,47.35 224.25,46.82 231.36,46.82 v3(232.63,48.09)
  BOTTOM w0.076: U2.BC29 234.31,52.12 234.31,51.62 234.44,51.49 234.44,50.4
  BOTTOM w0.097: v1(216.71,47.58) 216,46.87 R116.1 R121.2 ; v3(232.63,48.09) 233.04,48.49 233.04,49.2 233.57,49.74 233.78,49.74 234.44,50.4
PCH_WP_N_R: length 3
  BOTTOM w0.097: v2(214.07,47.78) R121.1 214.98,48.09 215.11,48.21 U3.3
PCH_XDP_PRDY_N: length 5.9
  TOP w0.097: R201.1 v3(250.54,53.42)
  BOTTOM w0.076: U2.AT4 246.72,55.73 248.64,55.73 249.14,55.22
  BOTTOM w0.097: v3(250.54,53.42) 250.54,53.5 249.14,54.89 249.14,55.22
PCH_XDP_PREQ_N: length 6.5
  TOP w0.097: R200.1 v3(250.54,52.53)
  BOTTOM w0.097: U2.AT3 246.86,55.38 246.86,54.69 247.01,54.54 247.72,54.54 247.75,54.56 248.76,54.56 249.52,53.8 249.52,53.17 v2(249.96,52.73) 250.16,52.53 v3(250.54,52.53)
PCH_XTAL24_IN: length 7.6
  BOTTOM w0.097: Y2.1 246.36,78.83 245.89,78.36 245.89,77.76 246.81,76.85 C206.1 246.78,76.64 R190.2 247.06,75.49 247.06,75.26 246.74,74.93 246.74,74.53 245.99,73.79 245.99,73.33 U2.A6
PCH_XTAL24_OUT: length 5.8
  BOTTOM w0.097: U2.A5 246.2,73.03 246.2,73.66 247.09,74.55 v2(247.09,74.78) 247.31,75.01 247.31,75.39 R190.1 247.7,76.64 C207.1 247.67,77.3 247.89,77.52 Y2.3
PCIE1_TBT_RX_DN0: length 237.3
  IN05 w0.114: v3(240.76,69.42) 240.89,69.55 241.4,69.55 242.55,70.7 242.55,78.38 241.98,78.95 241.98,80.52 237.08,85.42 221.99,85.42 220.28,83.72 213.66,83.72 211.43,85.94 206.71,85.94 203.41,89.25 200.39,89.25 199.12,87.98 195.82,87.98 195.31,87.47 147.13,87.47 145.24,85.58 145.24,82.23 143.04,80.03 136.06,80.03 134.35,78.32 131.89,78.32 128.94,75.38 128,75.38 124.97,72.36 119.97,72.36 119.21,73.12 114.9,73.12 114.14,72.36 110.48,72.36 109.92,71.8 106.64,71.8 104.65,69.82 103.87,69.82 101.68,67.63 101.68,63.94 101.08,63.34 99.93,63.34 98,61.4 98,59.63 97.27,58.89 95.49,58.89 93.33,56.73 90.54,56.73 89.01,55.21 81.39,55.21 80.37,56.23 73.74,56.23 73.25,56.72 73.25,57.74 72.93,58.05 71.91,58.05 68.55,61.42 66.77,61.42 66.4,61.79 66.4,63.69 64.85,65.24 64.37,65.24 60.31,69.31 60.31,74.1 58.39,76.03 57.63,76.03 57.37,76.28 57.37,76.86 v1(57.58,77.07)
  BOTTOM w0.097: v3(240.76,69.42) 240.83,69.49 U2.H15
  BOTTOM w0.104: v1(57.58,77.07) 57.38,77.26 57.38,77.45 C2030.1
PCIE1_TBT_RX_DP0: length 237.3
  IN05 w0.114: v1(56.94,77.07) 57.11,76.9 57.11,76.17 57.52,75.76 58.27,75.76 60.04,73.99 60.04,69.2 64.26,64.98 64.74,64.98 66.14,63.58 66.14,61.68 66.66,61.15 68.43,61.15 71.8,57.79 72.82,57.79 72.98,57.63 72.98,56.61 73.63,55.96 80.26,55.96 81.28,54.94 89.12,54.94 90.65,56.47 93.44,56.47 95.6,58.63 97.38,58.63 98.27,59.52 98.27,61.29 100.05,63.07 101.19,63.07 101.95,63.83 101.95,67.52 103.98,69.55 104.77,69.55 106.75,71.53 110.03,71.53 110.59,72.09 114.25,72.09 115.01,72.85 119.1,72.85 119.86,72.09 125.08,72.09 128.11,75.11 129.05,75.11 132,78.06 134.46,78.06 136.17,79.77 143.16,79.77 145.51,82.12 145.51,85.47 147.24,87.2 195.42,87.2 195.93,87.71 199.23,87.71 200.5,88.98 203.3,88.98 206.6,85.68 211.32,85.68 213.55,83.45 220.39,83.45 222.1,85.16 236.97,85.16 241.71,80.41 241.71,78.84 242.29,78.26 242.29,70.81 241.29,69.82 240.77,69.82 240.63,69.96 240.63,70.13 240.69,70.18 v3(240.76,70.18)
  BOTTOM w0.097: v3(240.76,70.18) 240.83,70.26 U2.G15
  BOTTOM w0.104: C2028.1 57.13,77.45 57.13,77.25 v1(56.94,77.07)
PCIE1_TBT_TX_DN0: length 231.1
  IN05 w0.114: v1(59.2,73.94) 59.04,73.78 59.04,72.75 59.15,72.63 59.15,72.18 59.04,72.06 59.04,71.82 59.15,71.71 59.15,71.25 59.04,71.13 59.04,70.83 59.15,70.72 59.15,70.26 59.04,70.15 59.04,69.32 62.72,65.64 62.72,64.06 64.03,62.75 64.55,62.75 64.99,62.32 64.99,59.52 65.88,58.63 68.55,58.63 70.45,56.72 71.72,56.72 73.1,55.34 79.99,55.34 81,54.32 89.39,54.32 90.92,55.85 93.71,55.85 95.74,57.88 98.28,57.88 99.14,58.74 99.14,61.28 100.32,62.45 101.71,62.45 102.59,63.32 102.59,67.13 104.13,68.67 104.77,68.67 106.93,70.83 110.22,70.83 110.86,71.47 114.66,71.47 115.42,72.23 118.82,72.23 119.59,71.47 125.34,71.47 128.26,74.38 132.02,74.38 133.48,75.84 134.53,75.84 135.21,76.52 135.21,77.79 136.57,79.14 143.55,79.14 145.26,80.85 146.53,80.85 147.53,81.85 147.53,85.92 148.07,86.45 195.82,86.45 196.2,86.83 200.74,86.83 203.03,84.55 211.29,84.55 213.01,82.83 220.72,82.83 221.99,84.1 228.76,84.1 229.18,84.52 235.05,84.52 235.47,84.1 236.34,84.1 237.14,83.3 237.93,83.3 241.07,80.17 241.07,78.61 241.36,78.32 241.36,75.99 240.95,75.59 240.95,74.51 240.41,73.97 240.41,73.64 240.56,73.49 240.84,73.49 240.99,73.64 v3(240.99,73.74)
  BOTTOM w0.104: v1(59.2,73.94) 59.01,74.13 59.01,74.99 C2029.2 ; U2.A16 240.53,73.28 v3(240.99,73.74)
PCIE1_TBT_TX_DP0: length 231.1
  IN05 w0.114: v1(58.57,73.94) 58.77,73.74 58.77,69.21 62.45,65.53 62.45,63.95 63.92,62.48 64.44,62.48 64.72,62.21 64.72,59.41 65.77,58.36 68.44,58.36 70.34,56.46 71.61,56.46 72.99,55.07 79.88,55.07 80.89,54.05 89.5,54.05 91.03,55.58 93.82,55.58 95.85,57.61 98.39,57.61 99.41,58.63 99.41,61.17 100.43,62.18 101.82,62.18 102.85,63.21 102.85,67.02 104.24,68.41 104.88,68.41 107.04,70.56 110.33,70.56 110.97,71.2 114.77,71.2 115.54,71.96 118.71,71.96 119.48,71.2 125.45,71.2 128.37,74.12 132.14,74.12 133.59,75.57 134.64,75.57 135.48,76.41 135.48,77.68 136.68,78.88 143.66,78.88 145.37,80.59 146.64,80.59 147.8,81.74 147.8,85.8 148.18,86.19 195.93,86.19 196.31,86.57 200.63,86.57 202.92,84.28 211.18,84.28 212.9,82.56 220.83,82.56 222.1,83.84 228.87,83.84 229.29,84.26 234.94,84.26 235.35,83.84 236.23,83.84 237.03,83.04 237.82,83.04 240.8,80.06 240.8,78.5 241.09,78.2 241.09,76.1 240.68,75.7 240.68,74.62 240.14,74.08 240.14,73.53 240.45,73.22 240.88,73.22 v3(240.99,73.1)
  BOTTOM w0.104: v3(240.99,73.1) 240.99,72.83 240.65,72.49 U2.B16 ; v1(58.57,73.94) 58.76,74.13 58.76,74.99 C2027.2
PCIE2_TBT_RX_DN1: length 236.4
  IN05 w0.114: v3(239.62,70.95) 239.88,70.95 240.01,71.07 240.01,71.25 239.88,71.37 239.49,71.37 239.36,71.5 239.36,72.09 237.97,73.49 237.71,73.49 236.57,74.63 236.57,75.45 237.09,75.97 237.09,77.49 237.38,77.78 237.38,78.78 236.46,79.7 228.36,79.7 227.99,79.34 222.49,79.34 221.78,78.64 221.15,78.64 220.83,78.32 166.48,78.32 165.82,77.66 165.82,76.39 165.21,75.78 147.81,75.78 145.9,73.87 145.52,73.87 145.28,73.63 139.51,73.63 138.98,73.09 138.98,68.61 136.99,66.62 119.73,66.62 119.42,66.93 116.5,66.93 116.42,67.02 108.57,67.02 106.26,64.71 106.26,60.9 105.87,60.52 105.87,57.59 102.22,53.94 100.18,53.94 95.74,49.5 91.52,49.5 90.38,50.64 81.39,50.64 80.88,50.13 74.5,50.13 73.61,51.02 71.45,51.02 70.2,52.28 65.37,52.28 63.47,54.18 62.83,54.18 62.21,54.8 62.21,55.93 60.04,58.1 60.04,61.04 51.91,69.16 51.91,71.47 v1(52.2,71.75)
  BOTTOM w0.097: v3(239.62,70.95) 239.69,71.02 U2.E17
  BOTTOM w0.104: C2034.1 56.17,73.39 56.17,72.86 55.9,72.6 v1(53.56,72.6) 52.29,72.6 51.91,72.22 51.91,72.03 v1(52.2,71.75)
PCIE2_TBT_RX_DP1: length 236.5
  IN05 w0.114: v1(51.38,71.75) 51.65,71.48 51.65,69.05 59.77,60.93 59.77,57.99 61.95,55.82 61.95,54.69 62.72,53.92 63.35,53.92 65.26,52.01 70.09,52.01 71.34,50.75 73.5,50.75 74.39,49.86 81,49.86 81.5,50.37 90.27,50.37 91.41,49.23 95.85,49.23 100.29,53.67 102.33,53.67 106.14,57.48 106.14,60.4 106.52,60.79 106.52,64.6 108.68,66.75 116.3,66.75 116.39,66.67 119.31,66.67 119.62,66.36 137.1,66.36 139.24,68.49 139.24,72.98 139.62,73.36 145.39,73.36 145.63,73.6 146.01,73.6 147.92,75.52 165.32,75.52 166.09,76.28 166.09,77.55 166.59,78.06 220.95,78.06 221.26,78.37 221.9,78.37 222.6,79.07 228.11,79.07 228.47,79.44 236.35,79.44 237.12,78.67 237.12,77.89 236.82,77.6 236.82,76.08 236.3,75.56 236.3,74.52 237.6,73.22 237.86,73.22 239.09,71.98 239.09,70.78 v3(239.62,70.26)
  BOTTOM w0.097: U2.G17 v3(239.62,70.26)
  BOTTOM w0.104: v1(51.38,71.75) 51.66,72.03 51.66,72.32 52.19,72.85 55.8,72.85 55.91,72.97 55.91,73.39 C2032.1
PCIE2_TBT_TX_DN1: length 237.1
  IN05 w0.114: v1(239.48,74.25) 239.65,74.41 239.67,74.41 239.69,74.44 239.88,74.44 240.18,74.73 240.18,79.76 237.55,82.39 236.65,82.39 235.82,83.21 234.97,83.21 234.56,83.62 229.53,83.62 229.13,83.21 222.36,83.21 221.09,81.94 211.48,81.94 210.26,83.15 203.03,83.15 201.37,84.8 198.33,84.8 197.44,85.69 196.45,85.69 196.04,85.28 196.04,81.6 195.69,81.25 148.45,81.25 147.04,79.84 145.5,79.84 143.92,78.25 137.96,78.25 137.38,77.68 137.38,76.66 135.48,74.76 133.96,74.76 132.7,73.49 128.63,73.49 127.46,72.33 127.46,71.56 127.11,71.21 126.48,71.21 125.33,70.07 119.46,70.07 118.19,71.34 116.83,71.34 116.06,70.58 111.24,70.58 110.6,69.94 107.3,69.94 104.88,67.53 104.25,67.53 103.59,66.86 103.59,62.3 102.08,60.79 102.08,58.37 100.57,56.86 96,56.86 95.46,56.32 95.46,55.56 94.47,54.58 91.03,54.58 89.89,53.43 80.63,53.43 79.99,54.07 73.1,54.07 71.91,55.26 70.39,55.26 67.91,57.74 64.23,57.74 62.71,59.26 62.71,62.44 61.63,63.51 61.63,65.46 57.32,69.78 57.32,74.02 55.23,76.11 55.23,76.9 v1(55.19,76.94)
  BOTTOM w0.076: U2.B19 239.38,72.24 239.46,72.16 239.57,72.16 239.64,72.24 239.64,72.67 239.59,72.72 239.39,72.72 239.03,73.08 239.03,73.21 239.11,73.28 239.11,73.43 239.03,73.51 239.03,73.69 239.16,73.82 239.16,73.99 239.03,74.12 239.03,74.25 239.14,74.35 239.38,74.35 v1(239.48,74.25)
  BOTTOM w0.104: C2033.2 55,77.47 55,77.13 v1(55.19,76.94)
PCIE2_TBT_TX_DP1: length 237
  IN05 w0.114: v1(239.49,75.01) 239.47,74.99 239.47,74.82 239.58,74.7 239.77,74.7 239.91,74.84 239.91,79.65 237.44,82.12 236.54,82.12 235.71,82.95 234.86,82.95 234.45,83.35 229.64,83.35 229.24,82.95 222.47,82.95 221.2,81.67 211.37,81.67 210.15,82.88 202.92,82.88 201.26,84.53 198.22,84.53 197.33,85.42 196.57,85.42 196.31,85.17 196.31,81.49 195.8,80.98 148.56,80.98 147.15,79.57 145.61,79.57 144.03,77.99 138.07,77.99 137.65,77.57 137.65,76.55 135.59,74.49 134.07,74.49 132.81,73.23 128.74,73.23 127.73,72.22 127.73,71.45 127.22,70.95 126.59,70.95 125.45,69.8 119.35,69.8 118.08,71.07 116.94,71.07 116.17,70.31 111.35,70.31 110.71,69.68 107.41,69.68 104.99,67.26 104.36,67.26 103.86,66.75 103.86,62.19 102.34,60.68 102.34,58.26 100.68,56.59 96.11,56.59 95.73,56.21 95.73,55.45 94.58,54.31 91.15,54.31 90,53.17 80.52,53.17 79.88,53.8 72.99,53.8 71.8,54.99 70.28,54.99 67.8,57.47 64.12,57.47 62.44,59.15 62.44,62.33 61.37,63.4 61.37,65.35 57.06,69.67 57.06,73.91 54.96,76 54.96,76.28 54.83,76.41 54.65,76.41 54.55,76.5 v1(54.55,76.94)
  BOTTOM w0.076: U2.C19 239.13,72.16 239.13,72.77 238.88,73.02 238.88,74.39 239.17,74.67 239.17,74.69
  BOTTOM w0.104: C2031.2 54.74,77.48 54.74,77.13 v1(54.55,76.94) ; v1(239.49,75.01) 239.17,74.69
